.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_128ck40 FIND v(dout0_128) AT=25.025n

.meas tran vdout0_129ck40 FIND v(dout0_129) AT=25.025n

.meas tran vdout0_130ck40 FIND v(dout0_130) AT=25.025n

.meas tran vdout0_131ck40 FIND v(dout0_131) AT=25.025n

.meas tran vdout0_132ck40 FIND v(dout0_132) AT=25.025n

.meas tran vdout0_133ck40 FIND v(dout0_133) AT=25.025n

.meas tran vdout0_134ck40 FIND v(dout0_134) AT=25.025n

.meas tran vdout0_135ck40 FIND v(dout0_135) AT=25.025n

.meas tran vdout0_136ck40 FIND v(dout0_136) AT=25.025n

.meas tran vdout0_137ck40 FIND v(dout0_137) AT=25.025n

.meas tran vdout0_138ck40 FIND v(dout0_138) AT=25.025n

.meas tran vdout0_139ck40 FIND v(dout0_139) AT=25.025n

.meas tran vdout0_140ck40 FIND v(dout0_140) AT=25.025n

.meas tran vdout0_141ck40 FIND v(dout0_141) AT=25.025n

.meas tran vdout0_142ck40 FIND v(dout0_142) AT=25.025n

.meas tran vdout0_143ck40 FIND v(dout0_143) AT=25.025n

.meas tran vdout0_144ck40 FIND v(dout0_144) AT=25.025n

.meas tran vdout0_145ck40 FIND v(dout0_145) AT=25.025n

.meas tran vdout0_146ck40 FIND v(dout0_146) AT=25.025n

.meas tran vdout0_147ck40 FIND v(dout0_147) AT=25.025n

.meas tran vdout0_148ck40 FIND v(dout0_148) AT=25.025n

.meas tran vdout0_149ck40 FIND v(dout0_149) AT=25.025n

.meas tran vdout0_150ck40 FIND v(dout0_150) AT=25.025n

.meas tran vdout0_151ck40 FIND v(dout0_151) AT=25.025n

.meas tran vdout0_152ck40 FIND v(dout0_152) AT=25.025n

.meas tran vdout0_153ck40 FIND v(dout0_153) AT=25.025n

.meas tran vdout0_154ck40 FIND v(dout0_154) AT=25.025n

.meas tran vdout0_155ck40 FIND v(dout0_155) AT=25.025n

.meas tran vdout0_156ck40 FIND v(dout0_156) AT=25.025n

.meas tran vdout0_157ck40 FIND v(dout0_157) AT=25.025n

.meas tran vdout0_158ck40 FIND v(dout0_158) AT=25.025n

.meas tran vdout0_159ck40 FIND v(dout0_159) AT=25.025n

.meas tran vdout0_160ck40 FIND v(dout0_160) AT=25.025n

.meas tran vdout0_161ck40 FIND v(dout0_161) AT=25.025n

.meas tran vdout0_162ck40 FIND v(dout0_162) AT=25.025n

.meas tran vdout0_163ck40 FIND v(dout0_163) AT=25.025n

.meas tran vdout0_164ck40 FIND v(dout0_164) AT=25.025n

.meas tran vdout0_165ck40 FIND v(dout0_165) AT=25.025n

.meas tran vdout0_166ck40 FIND v(dout0_166) AT=25.025n

.meas tran vdout0_167ck40 FIND v(dout0_167) AT=25.025n

.meas tran vdout0_168ck40 FIND v(dout0_168) AT=25.025n

.meas tran vdout0_169ck40 FIND v(dout0_169) AT=25.025n

.meas tran vdout0_170ck40 FIND v(dout0_170) AT=25.025n

.meas tran vdout0_171ck40 FIND v(dout0_171) AT=25.025n

.meas tran vdout0_172ck40 FIND v(dout0_172) AT=25.025n

.meas tran vdout0_173ck40 FIND v(dout0_173) AT=25.025n

.meas tran vdout0_174ck40 FIND v(dout0_174) AT=25.025n

.meas tran vdout0_175ck40 FIND v(dout0_175) AT=25.025n

.meas tran vdout0_176ck40 FIND v(dout0_176) AT=25.025n

.meas tran vdout0_177ck40 FIND v(dout0_177) AT=25.025n

.meas tran vdout0_178ck40 FIND v(dout0_178) AT=25.025n

.meas tran vdout0_179ck40 FIND v(dout0_179) AT=25.025n

.meas tran vdout0_180ck40 FIND v(dout0_180) AT=25.025n

.meas tran vdout0_181ck40 FIND v(dout0_181) AT=25.025n

.meas tran vdout0_182ck40 FIND v(dout0_182) AT=25.025n

.meas tran vdout0_183ck40 FIND v(dout0_183) AT=25.025n

.meas tran vdout0_184ck40 FIND v(dout0_184) AT=25.025n

.meas tran vdout0_185ck40 FIND v(dout0_185) AT=25.025n

.meas tran vdout0_186ck40 FIND v(dout0_186) AT=25.025n

.meas tran vdout0_187ck40 FIND v(dout0_187) AT=25.025n

.meas tran vdout0_188ck40 FIND v(dout0_188) AT=25.025n

.meas tran vdout0_189ck40 FIND v(dout0_189) AT=25.025n

.meas tran vdout0_190ck40 FIND v(dout0_190) AT=25.025n

.meas tran vdout0_191ck40 FIND v(dout0_191) AT=25.025n

.meas tran vdout0_192ck40 FIND v(dout0_192) AT=25.025n

.meas tran vdout0_193ck40 FIND v(dout0_193) AT=25.025n

.meas tran vdout0_194ck40 FIND v(dout0_194) AT=25.025n

.meas tran vdout0_195ck40 FIND v(dout0_195) AT=25.025n

.meas tran vdout0_196ck40 FIND v(dout0_196) AT=25.025n

.meas tran vdout0_197ck40 FIND v(dout0_197) AT=25.025n

.meas tran vdout0_198ck40 FIND v(dout0_198) AT=25.025n

.meas tran vdout0_199ck40 FIND v(dout0_199) AT=25.025n

.meas tran vdout0_200ck40 FIND v(dout0_200) AT=25.025n

.meas tran vdout0_201ck40 FIND v(dout0_201) AT=25.025n

.meas tran vdout0_202ck40 FIND v(dout0_202) AT=25.025n

.meas tran vdout0_203ck40 FIND v(dout0_203) AT=25.025n

.meas tran vdout0_204ck40 FIND v(dout0_204) AT=25.025n

.meas tran vdout0_205ck40 FIND v(dout0_205) AT=25.025n

.meas tran vdout0_206ck40 FIND v(dout0_206) AT=25.025n

.meas tran vdout0_207ck40 FIND v(dout0_207) AT=25.025n

.meas tran vdout0_208ck40 FIND v(dout0_208) AT=25.025n

.meas tran vdout0_209ck40 FIND v(dout0_209) AT=25.025n

.meas tran vdout0_210ck40 FIND v(dout0_210) AT=25.025n

.meas tran vdout0_211ck40 FIND v(dout0_211) AT=25.025n

.meas tran vdout0_212ck40 FIND v(dout0_212) AT=25.025n

.meas tran vdout0_213ck40 FIND v(dout0_213) AT=25.025n

.meas tran vdout0_214ck40 FIND v(dout0_214) AT=25.025n

.meas tran vdout0_215ck40 FIND v(dout0_215) AT=25.025n

.meas tran vdout0_216ck40 FIND v(dout0_216) AT=25.025n

.meas tran vdout0_217ck40 FIND v(dout0_217) AT=25.025n

.meas tran vdout0_218ck40 FIND v(dout0_218) AT=25.025n

.meas tran vdout0_219ck40 FIND v(dout0_219) AT=25.025n

.meas tran vdout0_220ck40 FIND v(dout0_220) AT=25.025n

.meas tran vdout0_221ck40 FIND v(dout0_221) AT=25.025n

.meas tran vdout0_222ck40 FIND v(dout0_222) AT=25.025n

.meas tran vdout0_223ck40 FIND v(dout0_223) AT=25.025n

.meas tran vdout0_224ck40 FIND v(dout0_224) AT=25.025n

.meas tran vdout0_225ck40 FIND v(dout0_225) AT=25.025n

.meas tran vdout0_226ck40 FIND v(dout0_226) AT=25.025n

.meas tran vdout0_227ck40 FIND v(dout0_227) AT=25.025n

.meas tran vdout0_228ck40 FIND v(dout0_228) AT=25.025n

.meas tran vdout0_229ck40 FIND v(dout0_229) AT=25.025n

.meas tran vdout0_230ck40 FIND v(dout0_230) AT=25.025n

.meas tran vdout0_231ck40 FIND v(dout0_231) AT=25.025n

.meas tran vdout0_232ck40 FIND v(dout0_232) AT=25.025n

.meas tran vdout0_233ck40 FIND v(dout0_233) AT=25.025n

.meas tran vdout0_234ck40 FIND v(dout0_234) AT=25.025n

.meas tran vdout0_235ck40 FIND v(dout0_235) AT=25.025n

.meas tran vdout0_236ck40 FIND v(dout0_236) AT=25.025n

.meas tran vdout0_237ck40 FIND v(dout0_237) AT=25.025n

.meas tran vdout0_238ck40 FIND v(dout0_238) AT=25.025n

.meas tran vdout0_239ck40 FIND v(dout0_239) AT=25.025n

.meas tran vdout0_240ck40 FIND v(dout0_240) AT=25.025n

.meas tran vdout0_241ck40 FIND v(dout0_241) AT=25.025n

.meas tran vdout0_242ck40 FIND v(dout0_242) AT=25.025n

.meas tran vdout0_243ck40 FIND v(dout0_243) AT=25.025n

.meas tran vdout0_244ck40 FIND v(dout0_244) AT=25.025n

.meas tran vdout0_245ck40 FIND v(dout0_245) AT=25.025n

.meas tran vdout0_246ck40 FIND v(dout0_246) AT=25.025n

.meas tran vdout0_247ck40 FIND v(dout0_247) AT=25.025n

.meas tran vdout0_248ck40 FIND v(dout0_248) AT=25.025n

.meas tran vdout0_249ck40 FIND v(dout0_249) AT=25.025n

.meas tran vdout0_250ck40 FIND v(dout0_250) AT=25.025n

.meas tran vdout0_251ck40 FIND v(dout0_251) AT=25.025n

.meas tran vdout0_252ck40 FIND v(dout0_252) AT=25.025n

.meas tran vdout0_253ck40 FIND v(dout0_253) AT=25.025n

.meas tran vdout0_254ck40 FIND v(dout0_254) AT=25.025n

.meas tran vdout0_255ck40 FIND v(dout0_255) AT=25.025n

.meas tran vdout0_0ck60 FIND v(dout0_0) AT=35.025n

.meas tran vdout0_1ck60 FIND v(dout0_1) AT=35.025n

.meas tran vdout0_2ck60 FIND v(dout0_2) AT=35.025n

.meas tran vdout0_3ck60 FIND v(dout0_3) AT=35.025n

.meas tran vdout0_4ck60 FIND v(dout0_4) AT=35.025n

.meas tran vdout0_5ck60 FIND v(dout0_5) AT=35.025n

.meas tran vdout0_6ck60 FIND v(dout0_6) AT=35.025n

.meas tran vdout0_7ck60 FIND v(dout0_7) AT=35.025n

.meas tran vdout0_8ck60 FIND v(dout0_8) AT=35.025n

.meas tran vdout0_9ck60 FIND v(dout0_9) AT=35.025n

.meas tran vdout0_10ck60 FIND v(dout0_10) AT=35.025n

.meas tran vdout0_11ck60 FIND v(dout0_11) AT=35.025n

.meas tran vdout0_12ck60 FIND v(dout0_12) AT=35.025n

.meas tran vdout0_13ck60 FIND v(dout0_13) AT=35.025n

.meas tran vdout0_14ck60 FIND v(dout0_14) AT=35.025n

.meas tran vdout0_15ck60 FIND v(dout0_15) AT=35.025n

.meas tran vdout0_16ck60 FIND v(dout0_16) AT=35.025n

.meas tran vdout0_17ck60 FIND v(dout0_17) AT=35.025n

.meas tran vdout0_18ck60 FIND v(dout0_18) AT=35.025n

.meas tran vdout0_19ck60 FIND v(dout0_19) AT=35.025n

.meas tran vdout0_20ck60 FIND v(dout0_20) AT=35.025n

.meas tran vdout0_21ck60 FIND v(dout0_21) AT=35.025n

.meas tran vdout0_22ck60 FIND v(dout0_22) AT=35.025n

.meas tran vdout0_23ck60 FIND v(dout0_23) AT=35.025n

.meas tran vdout0_24ck60 FIND v(dout0_24) AT=35.025n

.meas tran vdout0_25ck60 FIND v(dout0_25) AT=35.025n

.meas tran vdout0_26ck60 FIND v(dout0_26) AT=35.025n

.meas tran vdout0_27ck60 FIND v(dout0_27) AT=35.025n

.meas tran vdout0_28ck60 FIND v(dout0_28) AT=35.025n

.meas tran vdout0_29ck60 FIND v(dout0_29) AT=35.025n

.meas tran vdout0_30ck60 FIND v(dout0_30) AT=35.025n

.meas tran vdout0_31ck60 FIND v(dout0_31) AT=35.025n

.meas tran vdout0_32ck60 FIND v(dout0_32) AT=35.025n

.meas tran vdout0_33ck60 FIND v(dout0_33) AT=35.025n

.meas tran vdout0_34ck60 FIND v(dout0_34) AT=35.025n

.meas tran vdout0_35ck60 FIND v(dout0_35) AT=35.025n

.meas tran vdout0_36ck60 FIND v(dout0_36) AT=35.025n

.meas tran vdout0_37ck60 FIND v(dout0_37) AT=35.025n

.meas tran vdout0_38ck60 FIND v(dout0_38) AT=35.025n

.meas tran vdout0_39ck60 FIND v(dout0_39) AT=35.025n

.meas tran vdout0_40ck60 FIND v(dout0_40) AT=35.025n

.meas tran vdout0_41ck60 FIND v(dout0_41) AT=35.025n

.meas tran vdout0_42ck60 FIND v(dout0_42) AT=35.025n

.meas tran vdout0_43ck60 FIND v(dout0_43) AT=35.025n

.meas tran vdout0_44ck60 FIND v(dout0_44) AT=35.025n

.meas tran vdout0_45ck60 FIND v(dout0_45) AT=35.025n

.meas tran vdout0_46ck60 FIND v(dout0_46) AT=35.025n

.meas tran vdout0_47ck60 FIND v(dout0_47) AT=35.025n

.meas tran vdout0_48ck60 FIND v(dout0_48) AT=35.025n

.meas tran vdout0_49ck60 FIND v(dout0_49) AT=35.025n

.meas tran vdout0_50ck60 FIND v(dout0_50) AT=35.025n

.meas tran vdout0_51ck60 FIND v(dout0_51) AT=35.025n

.meas tran vdout0_52ck60 FIND v(dout0_52) AT=35.025n

.meas tran vdout0_53ck60 FIND v(dout0_53) AT=35.025n

.meas tran vdout0_54ck60 FIND v(dout0_54) AT=35.025n

.meas tran vdout0_55ck60 FIND v(dout0_55) AT=35.025n

.meas tran vdout0_56ck60 FIND v(dout0_56) AT=35.025n

.meas tran vdout0_57ck60 FIND v(dout0_57) AT=35.025n

.meas tran vdout0_58ck60 FIND v(dout0_58) AT=35.025n

.meas tran vdout0_59ck60 FIND v(dout0_59) AT=35.025n

.meas tran vdout0_60ck60 FIND v(dout0_60) AT=35.025n

.meas tran vdout0_61ck60 FIND v(dout0_61) AT=35.025n

.meas tran vdout0_62ck60 FIND v(dout0_62) AT=35.025n

.meas tran vdout0_63ck60 FIND v(dout0_63) AT=35.025n

.meas tran vdout0_64ck60 FIND v(dout0_64) AT=35.025n

.meas tran vdout0_65ck60 FIND v(dout0_65) AT=35.025n

.meas tran vdout0_66ck60 FIND v(dout0_66) AT=35.025n

.meas tran vdout0_67ck60 FIND v(dout0_67) AT=35.025n

.meas tran vdout0_68ck60 FIND v(dout0_68) AT=35.025n

.meas tran vdout0_69ck60 FIND v(dout0_69) AT=35.025n

.meas tran vdout0_70ck60 FIND v(dout0_70) AT=35.025n

.meas tran vdout0_71ck60 FIND v(dout0_71) AT=35.025n

.meas tran vdout0_72ck60 FIND v(dout0_72) AT=35.025n

.meas tran vdout0_73ck60 FIND v(dout0_73) AT=35.025n

.meas tran vdout0_74ck60 FIND v(dout0_74) AT=35.025n

.meas tran vdout0_75ck60 FIND v(dout0_75) AT=35.025n

.meas tran vdout0_76ck60 FIND v(dout0_76) AT=35.025n

.meas tran vdout0_77ck60 FIND v(dout0_77) AT=35.025n

.meas tran vdout0_78ck60 FIND v(dout0_78) AT=35.025n

.meas tran vdout0_79ck60 FIND v(dout0_79) AT=35.025n

.meas tran vdout0_80ck60 FIND v(dout0_80) AT=35.025n

.meas tran vdout0_81ck60 FIND v(dout0_81) AT=35.025n

.meas tran vdout0_82ck60 FIND v(dout0_82) AT=35.025n

.meas tran vdout0_83ck60 FIND v(dout0_83) AT=35.025n

.meas tran vdout0_84ck60 FIND v(dout0_84) AT=35.025n

.meas tran vdout0_85ck60 FIND v(dout0_85) AT=35.025n

.meas tran vdout0_86ck60 FIND v(dout0_86) AT=35.025n

.meas tran vdout0_87ck60 FIND v(dout0_87) AT=35.025n

.meas tran vdout0_88ck60 FIND v(dout0_88) AT=35.025n

.meas tran vdout0_89ck60 FIND v(dout0_89) AT=35.025n

.meas tran vdout0_90ck60 FIND v(dout0_90) AT=35.025n

.meas tran vdout0_91ck60 FIND v(dout0_91) AT=35.025n

.meas tran vdout0_92ck60 FIND v(dout0_92) AT=35.025n

.meas tran vdout0_93ck60 FIND v(dout0_93) AT=35.025n

.meas tran vdout0_94ck60 FIND v(dout0_94) AT=35.025n

.meas tran vdout0_95ck60 FIND v(dout0_95) AT=35.025n

.meas tran vdout0_96ck60 FIND v(dout0_96) AT=35.025n

.meas tran vdout0_97ck60 FIND v(dout0_97) AT=35.025n

.meas tran vdout0_98ck60 FIND v(dout0_98) AT=35.025n

.meas tran vdout0_99ck60 FIND v(dout0_99) AT=35.025n

.meas tran vdout0_100ck60 FIND v(dout0_100) AT=35.025n

.meas tran vdout0_101ck60 FIND v(dout0_101) AT=35.025n

.meas tran vdout0_102ck60 FIND v(dout0_102) AT=35.025n

.meas tran vdout0_103ck60 FIND v(dout0_103) AT=35.025n

.meas tran vdout0_104ck60 FIND v(dout0_104) AT=35.025n

.meas tran vdout0_105ck60 FIND v(dout0_105) AT=35.025n

.meas tran vdout0_106ck60 FIND v(dout0_106) AT=35.025n

.meas tran vdout0_107ck60 FIND v(dout0_107) AT=35.025n

.meas tran vdout0_108ck60 FIND v(dout0_108) AT=35.025n

.meas tran vdout0_109ck60 FIND v(dout0_109) AT=35.025n

.meas tran vdout0_110ck60 FIND v(dout0_110) AT=35.025n

.meas tran vdout0_111ck60 FIND v(dout0_111) AT=35.025n

.meas tran vdout0_112ck60 FIND v(dout0_112) AT=35.025n

.meas tran vdout0_113ck60 FIND v(dout0_113) AT=35.025n

.meas tran vdout0_114ck60 FIND v(dout0_114) AT=35.025n

.meas tran vdout0_115ck60 FIND v(dout0_115) AT=35.025n

.meas tran vdout0_116ck60 FIND v(dout0_116) AT=35.025n

.meas tran vdout0_117ck60 FIND v(dout0_117) AT=35.025n

.meas tran vdout0_118ck60 FIND v(dout0_118) AT=35.025n

.meas tran vdout0_119ck60 FIND v(dout0_119) AT=35.025n

.meas tran vdout0_120ck60 FIND v(dout0_120) AT=35.025n

.meas tran vdout0_121ck60 FIND v(dout0_121) AT=35.025n

.meas tran vdout0_122ck60 FIND v(dout0_122) AT=35.025n

.meas tran vdout0_123ck60 FIND v(dout0_123) AT=35.025n

.meas tran vdout0_124ck60 FIND v(dout0_124) AT=35.025n

.meas tran vdout0_125ck60 FIND v(dout0_125) AT=35.025n

.meas tran vdout0_126ck60 FIND v(dout0_126) AT=35.025n

.meas tran vdout0_127ck60 FIND v(dout0_127) AT=35.025n

.meas tran vdout0_128ck60 FIND v(dout0_128) AT=35.025n

.meas tran vdout0_129ck60 FIND v(dout0_129) AT=35.025n

.meas tran vdout0_130ck60 FIND v(dout0_130) AT=35.025n

.meas tran vdout0_131ck60 FIND v(dout0_131) AT=35.025n

.meas tran vdout0_132ck60 FIND v(dout0_132) AT=35.025n

.meas tran vdout0_133ck60 FIND v(dout0_133) AT=35.025n

.meas tran vdout0_134ck60 FIND v(dout0_134) AT=35.025n

.meas tran vdout0_135ck60 FIND v(dout0_135) AT=35.025n

.meas tran vdout0_136ck60 FIND v(dout0_136) AT=35.025n

.meas tran vdout0_137ck60 FIND v(dout0_137) AT=35.025n

.meas tran vdout0_138ck60 FIND v(dout0_138) AT=35.025n

.meas tran vdout0_139ck60 FIND v(dout0_139) AT=35.025n

.meas tran vdout0_140ck60 FIND v(dout0_140) AT=35.025n

.meas tran vdout0_141ck60 FIND v(dout0_141) AT=35.025n

.meas tran vdout0_142ck60 FIND v(dout0_142) AT=35.025n

.meas tran vdout0_143ck60 FIND v(dout0_143) AT=35.025n

.meas tran vdout0_144ck60 FIND v(dout0_144) AT=35.025n

.meas tran vdout0_145ck60 FIND v(dout0_145) AT=35.025n

.meas tran vdout0_146ck60 FIND v(dout0_146) AT=35.025n

.meas tran vdout0_147ck60 FIND v(dout0_147) AT=35.025n

.meas tran vdout0_148ck60 FIND v(dout0_148) AT=35.025n

.meas tran vdout0_149ck60 FIND v(dout0_149) AT=35.025n

.meas tran vdout0_150ck60 FIND v(dout0_150) AT=35.025n

.meas tran vdout0_151ck60 FIND v(dout0_151) AT=35.025n

.meas tran vdout0_152ck60 FIND v(dout0_152) AT=35.025n

.meas tran vdout0_153ck60 FIND v(dout0_153) AT=35.025n

.meas tran vdout0_154ck60 FIND v(dout0_154) AT=35.025n

.meas tran vdout0_155ck60 FIND v(dout0_155) AT=35.025n

.meas tran vdout0_156ck60 FIND v(dout0_156) AT=35.025n

.meas tran vdout0_157ck60 FIND v(dout0_157) AT=35.025n

.meas tran vdout0_158ck60 FIND v(dout0_158) AT=35.025n

.meas tran vdout0_159ck60 FIND v(dout0_159) AT=35.025n

.meas tran vdout0_160ck60 FIND v(dout0_160) AT=35.025n

.meas tran vdout0_161ck60 FIND v(dout0_161) AT=35.025n

.meas tran vdout0_162ck60 FIND v(dout0_162) AT=35.025n

.meas tran vdout0_163ck60 FIND v(dout0_163) AT=35.025n

.meas tran vdout0_164ck60 FIND v(dout0_164) AT=35.025n

.meas tran vdout0_165ck60 FIND v(dout0_165) AT=35.025n

.meas tran vdout0_166ck60 FIND v(dout0_166) AT=35.025n

.meas tran vdout0_167ck60 FIND v(dout0_167) AT=35.025n

.meas tran vdout0_168ck60 FIND v(dout0_168) AT=35.025n

.meas tran vdout0_169ck60 FIND v(dout0_169) AT=35.025n

.meas tran vdout0_170ck60 FIND v(dout0_170) AT=35.025n

.meas tran vdout0_171ck60 FIND v(dout0_171) AT=35.025n

.meas tran vdout0_172ck60 FIND v(dout0_172) AT=35.025n

.meas tran vdout0_173ck60 FIND v(dout0_173) AT=35.025n

.meas tran vdout0_174ck60 FIND v(dout0_174) AT=35.025n

.meas tran vdout0_175ck60 FIND v(dout0_175) AT=35.025n

.meas tran vdout0_176ck60 FIND v(dout0_176) AT=35.025n

.meas tran vdout0_177ck60 FIND v(dout0_177) AT=35.025n

.meas tran vdout0_178ck60 FIND v(dout0_178) AT=35.025n

.meas tran vdout0_179ck60 FIND v(dout0_179) AT=35.025n

.meas tran vdout0_180ck60 FIND v(dout0_180) AT=35.025n

.meas tran vdout0_181ck60 FIND v(dout0_181) AT=35.025n

.meas tran vdout0_182ck60 FIND v(dout0_182) AT=35.025n

.meas tran vdout0_183ck60 FIND v(dout0_183) AT=35.025n

.meas tran vdout0_184ck60 FIND v(dout0_184) AT=35.025n

.meas tran vdout0_185ck60 FIND v(dout0_185) AT=35.025n

.meas tran vdout0_186ck60 FIND v(dout0_186) AT=35.025n

.meas tran vdout0_187ck60 FIND v(dout0_187) AT=35.025n

.meas tran vdout0_188ck60 FIND v(dout0_188) AT=35.025n

.meas tran vdout0_189ck60 FIND v(dout0_189) AT=35.025n

.meas tran vdout0_190ck60 FIND v(dout0_190) AT=35.025n

.meas tran vdout0_191ck60 FIND v(dout0_191) AT=35.025n

.meas tran vdout0_192ck60 FIND v(dout0_192) AT=35.025n

.meas tran vdout0_193ck60 FIND v(dout0_193) AT=35.025n

.meas tran vdout0_194ck60 FIND v(dout0_194) AT=35.025n

.meas tran vdout0_195ck60 FIND v(dout0_195) AT=35.025n

.meas tran vdout0_196ck60 FIND v(dout0_196) AT=35.025n

.meas tran vdout0_197ck60 FIND v(dout0_197) AT=35.025n

.meas tran vdout0_198ck60 FIND v(dout0_198) AT=35.025n

.meas tran vdout0_199ck60 FIND v(dout0_199) AT=35.025n

.meas tran vdout0_200ck60 FIND v(dout0_200) AT=35.025n

.meas tran vdout0_201ck60 FIND v(dout0_201) AT=35.025n

.meas tran vdout0_202ck60 FIND v(dout0_202) AT=35.025n

.meas tran vdout0_203ck60 FIND v(dout0_203) AT=35.025n

.meas tran vdout0_204ck60 FIND v(dout0_204) AT=35.025n

.meas tran vdout0_205ck60 FIND v(dout0_205) AT=35.025n

.meas tran vdout0_206ck60 FIND v(dout0_206) AT=35.025n

.meas tran vdout0_207ck60 FIND v(dout0_207) AT=35.025n

.meas tran vdout0_208ck60 FIND v(dout0_208) AT=35.025n

.meas tran vdout0_209ck60 FIND v(dout0_209) AT=35.025n

.meas tran vdout0_210ck60 FIND v(dout0_210) AT=35.025n

.meas tran vdout0_211ck60 FIND v(dout0_211) AT=35.025n

.meas tran vdout0_212ck60 FIND v(dout0_212) AT=35.025n

.meas tran vdout0_213ck60 FIND v(dout0_213) AT=35.025n

.meas tran vdout0_214ck60 FIND v(dout0_214) AT=35.025n

.meas tran vdout0_215ck60 FIND v(dout0_215) AT=35.025n

.meas tran vdout0_216ck60 FIND v(dout0_216) AT=35.025n

.meas tran vdout0_217ck60 FIND v(dout0_217) AT=35.025n

.meas tran vdout0_218ck60 FIND v(dout0_218) AT=35.025n

.meas tran vdout0_219ck60 FIND v(dout0_219) AT=35.025n

.meas tran vdout0_220ck60 FIND v(dout0_220) AT=35.025n

.meas tran vdout0_221ck60 FIND v(dout0_221) AT=35.025n

.meas tran vdout0_222ck60 FIND v(dout0_222) AT=35.025n

.meas tran vdout0_223ck60 FIND v(dout0_223) AT=35.025n

.meas tran vdout0_224ck60 FIND v(dout0_224) AT=35.025n

.meas tran vdout0_225ck60 FIND v(dout0_225) AT=35.025n

.meas tran vdout0_226ck60 FIND v(dout0_226) AT=35.025n

.meas tran vdout0_227ck60 FIND v(dout0_227) AT=35.025n

.meas tran vdout0_228ck60 FIND v(dout0_228) AT=35.025n

.meas tran vdout0_229ck60 FIND v(dout0_229) AT=35.025n

.meas tran vdout0_230ck60 FIND v(dout0_230) AT=35.025n

.meas tran vdout0_231ck60 FIND v(dout0_231) AT=35.025n

.meas tran vdout0_232ck60 FIND v(dout0_232) AT=35.025n

.meas tran vdout0_233ck60 FIND v(dout0_233) AT=35.025n

.meas tran vdout0_234ck60 FIND v(dout0_234) AT=35.025n

.meas tran vdout0_235ck60 FIND v(dout0_235) AT=35.025n

.meas tran vdout0_236ck60 FIND v(dout0_236) AT=35.025n

.meas tran vdout0_237ck60 FIND v(dout0_237) AT=35.025n

.meas tran vdout0_238ck60 FIND v(dout0_238) AT=35.025n

.meas tran vdout0_239ck60 FIND v(dout0_239) AT=35.025n

.meas tran vdout0_240ck60 FIND v(dout0_240) AT=35.025n

.meas tran vdout0_241ck60 FIND v(dout0_241) AT=35.025n

.meas tran vdout0_242ck60 FIND v(dout0_242) AT=35.025n

.meas tran vdout0_243ck60 FIND v(dout0_243) AT=35.025n

.meas tran vdout0_244ck60 FIND v(dout0_244) AT=35.025n

.meas tran vdout0_245ck60 FIND v(dout0_245) AT=35.025n

.meas tran vdout0_246ck60 FIND v(dout0_246) AT=35.025n

.meas tran vdout0_247ck60 FIND v(dout0_247) AT=35.025n

.meas tran vdout0_248ck60 FIND v(dout0_248) AT=35.025n

.meas tran vdout0_249ck60 FIND v(dout0_249) AT=35.025n

.meas tran vdout0_250ck60 FIND v(dout0_250) AT=35.025n

.meas tran vdout0_251ck60 FIND v(dout0_251) AT=35.025n

.meas tran vdout0_252ck60 FIND v(dout0_252) AT=35.025n

.meas tran vdout0_253ck60 FIND v(dout0_253) AT=35.025n

.meas tran vdout0_254ck60 FIND v(dout0_254) AT=35.025n

.meas tran vdout0_255ck60 FIND v(dout0_255) AT=35.025n

.meas tran vdout0_0ck80 FIND v(dout0_0) AT=45.025n

.meas tran vdout0_1ck80 FIND v(dout0_1) AT=45.025n

.meas tran vdout0_2ck80 FIND v(dout0_2) AT=45.025n

.meas tran vdout0_3ck80 FIND v(dout0_3) AT=45.025n

.meas tran vdout0_4ck80 FIND v(dout0_4) AT=45.025n

.meas tran vdout0_5ck80 FIND v(dout0_5) AT=45.025n

.meas tran vdout0_6ck80 FIND v(dout0_6) AT=45.025n

.meas tran vdout0_7ck80 FIND v(dout0_7) AT=45.025n

.meas tran vdout0_8ck80 FIND v(dout0_8) AT=45.025n

.meas tran vdout0_9ck80 FIND v(dout0_9) AT=45.025n

.meas tran vdout0_10ck80 FIND v(dout0_10) AT=45.025n

.meas tran vdout0_11ck80 FIND v(dout0_11) AT=45.025n

.meas tran vdout0_12ck80 FIND v(dout0_12) AT=45.025n

.meas tran vdout0_13ck80 FIND v(dout0_13) AT=45.025n

.meas tran vdout0_14ck80 FIND v(dout0_14) AT=45.025n

.meas tran vdout0_15ck80 FIND v(dout0_15) AT=45.025n

.meas tran vdout0_16ck80 FIND v(dout0_16) AT=45.025n

.meas tran vdout0_17ck80 FIND v(dout0_17) AT=45.025n

.meas tran vdout0_18ck80 FIND v(dout0_18) AT=45.025n

.meas tran vdout0_19ck80 FIND v(dout0_19) AT=45.025n

.meas tran vdout0_20ck80 FIND v(dout0_20) AT=45.025n

.meas tran vdout0_21ck80 FIND v(dout0_21) AT=45.025n

.meas tran vdout0_22ck80 FIND v(dout0_22) AT=45.025n

.meas tran vdout0_23ck80 FIND v(dout0_23) AT=45.025n

.meas tran vdout0_24ck80 FIND v(dout0_24) AT=45.025n

.meas tran vdout0_25ck80 FIND v(dout0_25) AT=45.025n

.meas tran vdout0_26ck80 FIND v(dout0_26) AT=45.025n

.meas tran vdout0_27ck80 FIND v(dout0_27) AT=45.025n

.meas tran vdout0_28ck80 FIND v(dout0_28) AT=45.025n

.meas tran vdout0_29ck80 FIND v(dout0_29) AT=45.025n

.meas tran vdout0_30ck80 FIND v(dout0_30) AT=45.025n

.meas tran vdout0_31ck80 FIND v(dout0_31) AT=45.025n

.meas tran vdout0_32ck80 FIND v(dout0_32) AT=45.025n

.meas tran vdout0_33ck80 FIND v(dout0_33) AT=45.025n

.meas tran vdout0_34ck80 FIND v(dout0_34) AT=45.025n

.meas tran vdout0_35ck80 FIND v(dout0_35) AT=45.025n

.meas tran vdout0_36ck80 FIND v(dout0_36) AT=45.025n

.meas tran vdout0_37ck80 FIND v(dout0_37) AT=45.025n

.meas tran vdout0_38ck80 FIND v(dout0_38) AT=45.025n

.meas tran vdout0_39ck80 FIND v(dout0_39) AT=45.025n

.meas tran vdout0_40ck80 FIND v(dout0_40) AT=45.025n

.meas tran vdout0_41ck80 FIND v(dout0_41) AT=45.025n

.meas tran vdout0_42ck80 FIND v(dout0_42) AT=45.025n

.meas tran vdout0_43ck80 FIND v(dout0_43) AT=45.025n

.meas tran vdout0_44ck80 FIND v(dout0_44) AT=45.025n

.meas tran vdout0_45ck80 FIND v(dout0_45) AT=45.025n

.meas tran vdout0_46ck80 FIND v(dout0_46) AT=45.025n

.meas tran vdout0_47ck80 FIND v(dout0_47) AT=45.025n

.meas tran vdout0_48ck80 FIND v(dout0_48) AT=45.025n

.meas tran vdout0_49ck80 FIND v(dout0_49) AT=45.025n

.meas tran vdout0_50ck80 FIND v(dout0_50) AT=45.025n

.meas tran vdout0_51ck80 FIND v(dout0_51) AT=45.025n

.meas tran vdout0_52ck80 FIND v(dout0_52) AT=45.025n

.meas tran vdout0_53ck80 FIND v(dout0_53) AT=45.025n

.meas tran vdout0_54ck80 FIND v(dout0_54) AT=45.025n

.meas tran vdout0_55ck80 FIND v(dout0_55) AT=45.025n

.meas tran vdout0_56ck80 FIND v(dout0_56) AT=45.025n

.meas tran vdout0_57ck80 FIND v(dout0_57) AT=45.025n

.meas tran vdout0_58ck80 FIND v(dout0_58) AT=45.025n

.meas tran vdout0_59ck80 FIND v(dout0_59) AT=45.025n

.meas tran vdout0_60ck80 FIND v(dout0_60) AT=45.025n

.meas tran vdout0_61ck80 FIND v(dout0_61) AT=45.025n

.meas tran vdout0_62ck80 FIND v(dout0_62) AT=45.025n

.meas tran vdout0_63ck80 FIND v(dout0_63) AT=45.025n

.meas tran vdout0_64ck80 FIND v(dout0_64) AT=45.025n

.meas tran vdout0_65ck80 FIND v(dout0_65) AT=45.025n

.meas tran vdout0_66ck80 FIND v(dout0_66) AT=45.025n

.meas tran vdout0_67ck80 FIND v(dout0_67) AT=45.025n

.meas tran vdout0_68ck80 FIND v(dout0_68) AT=45.025n

.meas tran vdout0_69ck80 FIND v(dout0_69) AT=45.025n

.meas tran vdout0_70ck80 FIND v(dout0_70) AT=45.025n

.meas tran vdout0_71ck80 FIND v(dout0_71) AT=45.025n

.meas tran vdout0_72ck80 FIND v(dout0_72) AT=45.025n

.meas tran vdout0_73ck80 FIND v(dout0_73) AT=45.025n

.meas tran vdout0_74ck80 FIND v(dout0_74) AT=45.025n

.meas tran vdout0_75ck80 FIND v(dout0_75) AT=45.025n

.meas tran vdout0_76ck80 FIND v(dout0_76) AT=45.025n

.meas tran vdout0_77ck80 FIND v(dout0_77) AT=45.025n

.meas tran vdout0_78ck80 FIND v(dout0_78) AT=45.025n

.meas tran vdout0_79ck80 FIND v(dout0_79) AT=45.025n

.meas tran vdout0_80ck80 FIND v(dout0_80) AT=45.025n

.meas tran vdout0_81ck80 FIND v(dout0_81) AT=45.025n

.meas tran vdout0_82ck80 FIND v(dout0_82) AT=45.025n

.meas tran vdout0_83ck80 FIND v(dout0_83) AT=45.025n

.meas tran vdout0_84ck80 FIND v(dout0_84) AT=45.025n

.meas tran vdout0_85ck80 FIND v(dout0_85) AT=45.025n

.meas tran vdout0_86ck80 FIND v(dout0_86) AT=45.025n

.meas tran vdout0_87ck80 FIND v(dout0_87) AT=45.025n

.meas tran vdout0_88ck80 FIND v(dout0_88) AT=45.025n

.meas tran vdout0_89ck80 FIND v(dout0_89) AT=45.025n

.meas tran vdout0_90ck80 FIND v(dout0_90) AT=45.025n

.meas tran vdout0_91ck80 FIND v(dout0_91) AT=45.025n

.meas tran vdout0_92ck80 FIND v(dout0_92) AT=45.025n

.meas tran vdout0_93ck80 FIND v(dout0_93) AT=45.025n

.meas tran vdout0_94ck80 FIND v(dout0_94) AT=45.025n

.meas tran vdout0_95ck80 FIND v(dout0_95) AT=45.025n

.meas tran vdout0_96ck80 FIND v(dout0_96) AT=45.025n

.meas tran vdout0_97ck80 FIND v(dout0_97) AT=45.025n

.meas tran vdout0_98ck80 FIND v(dout0_98) AT=45.025n

.meas tran vdout0_99ck80 FIND v(dout0_99) AT=45.025n

.meas tran vdout0_100ck80 FIND v(dout0_100) AT=45.025n

.meas tran vdout0_101ck80 FIND v(dout0_101) AT=45.025n

.meas tran vdout0_102ck80 FIND v(dout0_102) AT=45.025n

.meas tran vdout0_103ck80 FIND v(dout0_103) AT=45.025n

.meas tran vdout0_104ck80 FIND v(dout0_104) AT=45.025n

.meas tran vdout0_105ck80 FIND v(dout0_105) AT=45.025n

.meas tran vdout0_106ck80 FIND v(dout0_106) AT=45.025n

.meas tran vdout0_107ck80 FIND v(dout0_107) AT=45.025n

.meas tran vdout0_108ck80 FIND v(dout0_108) AT=45.025n

.meas tran vdout0_109ck80 FIND v(dout0_109) AT=45.025n

.meas tran vdout0_110ck80 FIND v(dout0_110) AT=45.025n

.meas tran vdout0_111ck80 FIND v(dout0_111) AT=45.025n

.meas tran vdout0_112ck80 FIND v(dout0_112) AT=45.025n

.meas tran vdout0_113ck80 FIND v(dout0_113) AT=45.025n

.meas tran vdout0_114ck80 FIND v(dout0_114) AT=45.025n

.meas tran vdout0_115ck80 FIND v(dout0_115) AT=45.025n

.meas tran vdout0_116ck80 FIND v(dout0_116) AT=45.025n

.meas tran vdout0_117ck80 FIND v(dout0_117) AT=45.025n

.meas tran vdout0_118ck80 FIND v(dout0_118) AT=45.025n

.meas tran vdout0_119ck80 FIND v(dout0_119) AT=45.025n

.meas tran vdout0_120ck80 FIND v(dout0_120) AT=45.025n

.meas tran vdout0_121ck80 FIND v(dout0_121) AT=45.025n

.meas tran vdout0_122ck80 FIND v(dout0_122) AT=45.025n

.meas tran vdout0_123ck80 FIND v(dout0_123) AT=45.025n

.meas tran vdout0_124ck80 FIND v(dout0_124) AT=45.025n

.meas tran vdout0_125ck80 FIND v(dout0_125) AT=45.025n

.meas tran vdout0_126ck80 FIND v(dout0_126) AT=45.025n

.meas tran vdout0_127ck80 FIND v(dout0_127) AT=45.025n

.meas tran vdout0_128ck80 FIND v(dout0_128) AT=45.025n

.meas tran vdout0_129ck80 FIND v(dout0_129) AT=45.025n

.meas tran vdout0_130ck80 FIND v(dout0_130) AT=45.025n

.meas tran vdout0_131ck80 FIND v(dout0_131) AT=45.025n

.meas tran vdout0_132ck80 FIND v(dout0_132) AT=45.025n

.meas tran vdout0_133ck80 FIND v(dout0_133) AT=45.025n

.meas tran vdout0_134ck80 FIND v(dout0_134) AT=45.025n

.meas tran vdout0_135ck80 FIND v(dout0_135) AT=45.025n

.meas tran vdout0_136ck80 FIND v(dout0_136) AT=45.025n

.meas tran vdout0_137ck80 FIND v(dout0_137) AT=45.025n

.meas tran vdout0_138ck80 FIND v(dout0_138) AT=45.025n

.meas tran vdout0_139ck80 FIND v(dout0_139) AT=45.025n

.meas tran vdout0_140ck80 FIND v(dout0_140) AT=45.025n

.meas tran vdout0_141ck80 FIND v(dout0_141) AT=45.025n

.meas tran vdout0_142ck80 FIND v(dout0_142) AT=45.025n

.meas tran vdout0_143ck80 FIND v(dout0_143) AT=45.025n

.meas tran vdout0_144ck80 FIND v(dout0_144) AT=45.025n

.meas tran vdout0_145ck80 FIND v(dout0_145) AT=45.025n

.meas tran vdout0_146ck80 FIND v(dout0_146) AT=45.025n

.meas tran vdout0_147ck80 FIND v(dout0_147) AT=45.025n

.meas tran vdout0_148ck80 FIND v(dout0_148) AT=45.025n

.meas tran vdout0_149ck80 FIND v(dout0_149) AT=45.025n

.meas tran vdout0_150ck80 FIND v(dout0_150) AT=45.025n

.meas tran vdout0_151ck80 FIND v(dout0_151) AT=45.025n

.meas tran vdout0_152ck80 FIND v(dout0_152) AT=45.025n

.meas tran vdout0_153ck80 FIND v(dout0_153) AT=45.025n

.meas tran vdout0_154ck80 FIND v(dout0_154) AT=45.025n

.meas tran vdout0_155ck80 FIND v(dout0_155) AT=45.025n

.meas tran vdout0_156ck80 FIND v(dout0_156) AT=45.025n

.meas tran vdout0_157ck80 FIND v(dout0_157) AT=45.025n

.meas tran vdout0_158ck80 FIND v(dout0_158) AT=45.025n

.meas tran vdout0_159ck80 FIND v(dout0_159) AT=45.025n

.meas tran vdout0_160ck80 FIND v(dout0_160) AT=45.025n

.meas tran vdout0_161ck80 FIND v(dout0_161) AT=45.025n

.meas tran vdout0_162ck80 FIND v(dout0_162) AT=45.025n

.meas tran vdout0_163ck80 FIND v(dout0_163) AT=45.025n

.meas tran vdout0_164ck80 FIND v(dout0_164) AT=45.025n

.meas tran vdout0_165ck80 FIND v(dout0_165) AT=45.025n

.meas tran vdout0_166ck80 FIND v(dout0_166) AT=45.025n

.meas tran vdout0_167ck80 FIND v(dout0_167) AT=45.025n

.meas tran vdout0_168ck80 FIND v(dout0_168) AT=45.025n

.meas tran vdout0_169ck80 FIND v(dout0_169) AT=45.025n

.meas tran vdout0_170ck80 FIND v(dout0_170) AT=45.025n

.meas tran vdout0_171ck80 FIND v(dout0_171) AT=45.025n

.meas tran vdout0_172ck80 FIND v(dout0_172) AT=45.025n

.meas tran vdout0_173ck80 FIND v(dout0_173) AT=45.025n

.meas tran vdout0_174ck80 FIND v(dout0_174) AT=45.025n

.meas tran vdout0_175ck80 FIND v(dout0_175) AT=45.025n

.meas tran vdout0_176ck80 FIND v(dout0_176) AT=45.025n

.meas tran vdout0_177ck80 FIND v(dout0_177) AT=45.025n

.meas tran vdout0_178ck80 FIND v(dout0_178) AT=45.025n

.meas tran vdout0_179ck80 FIND v(dout0_179) AT=45.025n

.meas tran vdout0_180ck80 FIND v(dout0_180) AT=45.025n

.meas tran vdout0_181ck80 FIND v(dout0_181) AT=45.025n

.meas tran vdout0_182ck80 FIND v(dout0_182) AT=45.025n

.meas tran vdout0_183ck80 FIND v(dout0_183) AT=45.025n

.meas tran vdout0_184ck80 FIND v(dout0_184) AT=45.025n

.meas tran vdout0_185ck80 FIND v(dout0_185) AT=45.025n

.meas tran vdout0_186ck80 FIND v(dout0_186) AT=45.025n

.meas tran vdout0_187ck80 FIND v(dout0_187) AT=45.025n

.meas tran vdout0_188ck80 FIND v(dout0_188) AT=45.025n

.meas tran vdout0_189ck80 FIND v(dout0_189) AT=45.025n

.meas tran vdout0_190ck80 FIND v(dout0_190) AT=45.025n

.meas tran vdout0_191ck80 FIND v(dout0_191) AT=45.025n

.meas tran vdout0_192ck80 FIND v(dout0_192) AT=45.025n

.meas tran vdout0_193ck80 FIND v(dout0_193) AT=45.025n

.meas tran vdout0_194ck80 FIND v(dout0_194) AT=45.025n

.meas tran vdout0_195ck80 FIND v(dout0_195) AT=45.025n

.meas tran vdout0_196ck80 FIND v(dout0_196) AT=45.025n

.meas tran vdout0_197ck80 FIND v(dout0_197) AT=45.025n

.meas tran vdout0_198ck80 FIND v(dout0_198) AT=45.025n

.meas tran vdout0_199ck80 FIND v(dout0_199) AT=45.025n

.meas tran vdout0_200ck80 FIND v(dout0_200) AT=45.025n

.meas tran vdout0_201ck80 FIND v(dout0_201) AT=45.025n

.meas tran vdout0_202ck80 FIND v(dout0_202) AT=45.025n

.meas tran vdout0_203ck80 FIND v(dout0_203) AT=45.025n

.meas tran vdout0_204ck80 FIND v(dout0_204) AT=45.025n

.meas tran vdout0_205ck80 FIND v(dout0_205) AT=45.025n

.meas tran vdout0_206ck80 FIND v(dout0_206) AT=45.025n

.meas tran vdout0_207ck80 FIND v(dout0_207) AT=45.025n

.meas tran vdout0_208ck80 FIND v(dout0_208) AT=45.025n

.meas tran vdout0_209ck80 FIND v(dout0_209) AT=45.025n

.meas tran vdout0_210ck80 FIND v(dout0_210) AT=45.025n

.meas tran vdout0_211ck80 FIND v(dout0_211) AT=45.025n

.meas tran vdout0_212ck80 FIND v(dout0_212) AT=45.025n

.meas tran vdout0_213ck80 FIND v(dout0_213) AT=45.025n

.meas tran vdout0_214ck80 FIND v(dout0_214) AT=45.025n

.meas tran vdout0_215ck80 FIND v(dout0_215) AT=45.025n

.meas tran vdout0_216ck80 FIND v(dout0_216) AT=45.025n

.meas tran vdout0_217ck80 FIND v(dout0_217) AT=45.025n

.meas tran vdout0_218ck80 FIND v(dout0_218) AT=45.025n

.meas tran vdout0_219ck80 FIND v(dout0_219) AT=45.025n

.meas tran vdout0_220ck80 FIND v(dout0_220) AT=45.025n

.meas tran vdout0_221ck80 FIND v(dout0_221) AT=45.025n

.meas tran vdout0_222ck80 FIND v(dout0_222) AT=45.025n

.meas tran vdout0_223ck80 FIND v(dout0_223) AT=45.025n

.meas tran vdout0_224ck80 FIND v(dout0_224) AT=45.025n

.meas tran vdout0_225ck80 FIND v(dout0_225) AT=45.025n

.meas tran vdout0_226ck80 FIND v(dout0_226) AT=45.025n

.meas tran vdout0_227ck80 FIND v(dout0_227) AT=45.025n

.meas tran vdout0_228ck80 FIND v(dout0_228) AT=45.025n

.meas tran vdout0_229ck80 FIND v(dout0_229) AT=45.025n

.meas tran vdout0_230ck80 FIND v(dout0_230) AT=45.025n

.meas tran vdout0_231ck80 FIND v(dout0_231) AT=45.025n

.meas tran vdout0_232ck80 FIND v(dout0_232) AT=45.025n

.meas tran vdout0_233ck80 FIND v(dout0_233) AT=45.025n

.meas tran vdout0_234ck80 FIND v(dout0_234) AT=45.025n

.meas tran vdout0_235ck80 FIND v(dout0_235) AT=45.025n

.meas tran vdout0_236ck80 FIND v(dout0_236) AT=45.025n

.meas tran vdout0_237ck80 FIND v(dout0_237) AT=45.025n

.meas tran vdout0_238ck80 FIND v(dout0_238) AT=45.025n

.meas tran vdout0_239ck80 FIND v(dout0_239) AT=45.025n

.meas tran vdout0_240ck80 FIND v(dout0_240) AT=45.025n

.meas tran vdout0_241ck80 FIND v(dout0_241) AT=45.025n

.meas tran vdout0_242ck80 FIND v(dout0_242) AT=45.025n

.meas tran vdout0_243ck80 FIND v(dout0_243) AT=45.025n

.meas tran vdout0_244ck80 FIND v(dout0_244) AT=45.025n

.meas tran vdout0_245ck80 FIND v(dout0_245) AT=45.025n

.meas tran vdout0_246ck80 FIND v(dout0_246) AT=45.025n

.meas tran vdout0_247ck80 FIND v(dout0_247) AT=45.025n

.meas tran vdout0_248ck80 FIND v(dout0_248) AT=45.025n

.meas tran vdout0_249ck80 FIND v(dout0_249) AT=45.025n

.meas tran vdout0_250ck80 FIND v(dout0_250) AT=45.025n

.meas tran vdout0_251ck80 FIND v(dout0_251) AT=45.025n

.meas tran vdout0_252ck80 FIND v(dout0_252) AT=45.025n

.meas tran vdout0_253ck80 FIND v(dout0_253) AT=45.025n

.meas tran vdout0_254ck80 FIND v(dout0_254) AT=45.025n

.meas tran vdout0_255ck80 FIND v(dout0_255) AT=45.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_128ck90 FIND v(dout0_128) AT=50.025n

.meas tran vdout0_129ck90 FIND v(dout0_129) AT=50.025n

.meas tran vdout0_130ck90 FIND v(dout0_130) AT=50.025n

.meas tran vdout0_131ck90 FIND v(dout0_131) AT=50.025n

.meas tran vdout0_132ck90 FIND v(dout0_132) AT=50.025n

.meas tran vdout0_133ck90 FIND v(dout0_133) AT=50.025n

.meas tran vdout0_134ck90 FIND v(dout0_134) AT=50.025n

.meas tran vdout0_135ck90 FIND v(dout0_135) AT=50.025n

.meas tran vdout0_136ck90 FIND v(dout0_136) AT=50.025n

.meas tran vdout0_137ck90 FIND v(dout0_137) AT=50.025n

.meas tran vdout0_138ck90 FIND v(dout0_138) AT=50.025n

.meas tran vdout0_139ck90 FIND v(dout0_139) AT=50.025n

.meas tran vdout0_140ck90 FIND v(dout0_140) AT=50.025n

.meas tran vdout0_141ck90 FIND v(dout0_141) AT=50.025n

.meas tran vdout0_142ck90 FIND v(dout0_142) AT=50.025n

.meas tran vdout0_143ck90 FIND v(dout0_143) AT=50.025n

.meas tran vdout0_144ck90 FIND v(dout0_144) AT=50.025n

.meas tran vdout0_145ck90 FIND v(dout0_145) AT=50.025n

.meas tran vdout0_146ck90 FIND v(dout0_146) AT=50.025n

.meas tran vdout0_147ck90 FIND v(dout0_147) AT=50.025n

.meas tran vdout0_148ck90 FIND v(dout0_148) AT=50.025n

.meas tran vdout0_149ck90 FIND v(dout0_149) AT=50.025n

.meas tran vdout0_150ck90 FIND v(dout0_150) AT=50.025n

.meas tran vdout0_151ck90 FIND v(dout0_151) AT=50.025n

.meas tran vdout0_152ck90 FIND v(dout0_152) AT=50.025n

.meas tran vdout0_153ck90 FIND v(dout0_153) AT=50.025n

.meas tran vdout0_154ck90 FIND v(dout0_154) AT=50.025n

.meas tran vdout0_155ck90 FIND v(dout0_155) AT=50.025n

.meas tran vdout0_156ck90 FIND v(dout0_156) AT=50.025n

.meas tran vdout0_157ck90 FIND v(dout0_157) AT=50.025n

.meas tran vdout0_158ck90 FIND v(dout0_158) AT=50.025n

.meas tran vdout0_159ck90 FIND v(dout0_159) AT=50.025n

.meas tran vdout0_160ck90 FIND v(dout0_160) AT=50.025n

.meas tran vdout0_161ck90 FIND v(dout0_161) AT=50.025n

.meas tran vdout0_162ck90 FIND v(dout0_162) AT=50.025n

.meas tran vdout0_163ck90 FIND v(dout0_163) AT=50.025n

.meas tran vdout0_164ck90 FIND v(dout0_164) AT=50.025n

.meas tran vdout0_165ck90 FIND v(dout0_165) AT=50.025n

.meas tran vdout0_166ck90 FIND v(dout0_166) AT=50.025n

.meas tran vdout0_167ck90 FIND v(dout0_167) AT=50.025n

.meas tran vdout0_168ck90 FIND v(dout0_168) AT=50.025n

.meas tran vdout0_169ck90 FIND v(dout0_169) AT=50.025n

.meas tran vdout0_170ck90 FIND v(dout0_170) AT=50.025n

.meas tran vdout0_171ck90 FIND v(dout0_171) AT=50.025n

.meas tran vdout0_172ck90 FIND v(dout0_172) AT=50.025n

.meas tran vdout0_173ck90 FIND v(dout0_173) AT=50.025n

.meas tran vdout0_174ck90 FIND v(dout0_174) AT=50.025n

.meas tran vdout0_175ck90 FIND v(dout0_175) AT=50.025n

.meas tran vdout0_176ck90 FIND v(dout0_176) AT=50.025n

.meas tran vdout0_177ck90 FIND v(dout0_177) AT=50.025n

.meas tran vdout0_178ck90 FIND v(dout0_178) AT=50.025n

.meas tran vdout0_179ck90 FIND v(dout0_179) AT=50.025n

.meas tran vdout0_180ck90 FIND v(dout0_180) AT=50.025n

.meas tran vdout0_181ck90 FIND v(dout0_181) AT=50.025n

.meas tran vdout0_182ck90 FIND v(dout0_182) AT=50.025n

.meas tran vdout0_183ck90 FIND v(dout0_183) AT=50.025n

.meas tran vdout0_184ck90 FIND v(dout0_184) AT=50.025n

.meas tran vdout0_185ck90 FIND v(dout0_185) AT=50.025n

.meas tran vdout0_186ck90 FIND v(dout0_186) AT=50.025n

.meas tran vdout0_187ck90 FIND v(dout0_187) AT=50.025n

.meas tran vdout0_188ck90 FIND v(dout0_188) AT=50.025n

.meas tran vdout0_189ck90 FIND v(dout0_189) AT=50.025n

.meas tran vdout0_190ck90 FIND v(dout0_190) AT=50.025n

.meas tran vdout0_191ck90 FIND v(dout0_191) AT=50.025n

.meas tran vdout0_192ck90 FIND v(dout0_192) AT=50.025n

.meas tran vdout0_193ck90 FIND v(dout0_193) AT=50.025n

.meas tran vdout0_194ck90 FIND v(dout0_194) AT=50.025n

.meas tran vdout0_195ck90 FIND v(dout0_195) AT=50.025n

.meas tran vdout0_196ck90 FIND v(dout0_196) AT=50.025n

.meas tran vdout0_197ck90 FIND v(dout0_197) AT=50.025n

.meas tran vdout0_198ck90 FIND v(dout0_198) AT=50.025n

.meas tran vdout0_199ck90 FIND v(dout0_199) AT=50.025n

.meas tran vdout0_200ck90 FIND v(dout0_200) AT=50.025n

.meas tran vdout0_201ck90 FIND v(dout0_201) AT=50.025n

.meas tran vdout0_202ck90 FIND v(dout0_202) AT=50.025n

.meas tran vdout0_203ck90 FIND v(dout0_203) AT=50.025n

.meas tran vdout0_204ck90 FIND v(dout0_204) AT=50.025n

.meas tran vdout0_205ck90 FIND v(dout0_205) AT=50.025n

.meas tran vdout0_206ck90 FIND v(dout0_206) AT=50.025n

.meas tran vdout0_207ck90 FIND v(dout0_207) AT=50.025n

.meas tran vdout0_208ck90 FIND v(dout0_208) AT=50.025n

.meas tran vdout0_209ck90 FIND v(dout0_209) AT=50.025n

.meas tran vdout0_210ck90 FIND v(dout0_210) AT=50.025n

.meas tran vdout0_211ck90 FIND v(dout0_211) AT=50.025n

.meas tran vdout0_212ck90 FIND v(dout0_212) AT=50.025n

.meas tran vdout0_213ck90 FIND v(dout0_213) AT=50.025n

.meas tran vdout0_214ck90 FIND v(dout0_214) AT=50.025n

.meas tran vdout0_215ck90 FIND v(dout0_215) AT=50.025n

.meas tran vdout0_216ck90 FIND v(dout0_216) AT=50.025n

.meas tran vdout0_217ck90 FIND v(dout0_217) AT=50.025n

.meas tran vdout0_218ck90 FIND v(dout0_218) AT=50.025n

.meas tran vdout0_219ck90 FIND v(dout0_219) AT=50.025n

.meas tran vdout0_220ck90 FIND v(dout0_220) AT=50.025n

.meas tran vdout0_221ck90 FIND v(dout0_221) AT=50.025n

.meas tran vdout0_222ck90 FIND v(dout0_222) AT=50.025n

.meas tran vdout0_223ck90 FIND v(dout0_223) AT=50.025n

.meas tran vdout0_224ck90 FIND v(dout0_224) AT=50.025n

.meas tran vdout0_225ck90 FIND v(dout0_225) AT=50.025n

.meas tran vdout0_226ck90 FIND v(dout0_226) AT=50.025n

.meas tran vdout0_227ck90 FIND v(dout0_227) AT=50.025n

.meas tran vdout0_228ck90 FIND v(dout0_228) AT=50.025n

.meas tran vdout0_229ck90 FIND v(dout0_229) AT=50.025n

.meas tran vdout0_230ck90 FIND v(dout0_230) AT=50.025n

.meas tran vdout0_231ck90 FIND v(dout0_231) AT=50.025n

.meas tran vdout0_232ck90 FIND v(dout0_232) AT=50.025n

.meas tran vdout0_233ck90 FIND v(dout0_233) AT=50.025n

.meas tran vdout0_234ck90 FIND v(dout0_234) AT=50.025n

.meas tran vdout0_235ck90 FIND v(dout0_235) AT=50.025n

.meas tran vdout0_236ck90 FIND v(dout0_236) AT=50.025n

.meas tran vdout0_237ck90 FIND v(dout0_237) AT=50.025n

.meas tran vdout0_238ck90 FIND v(dout0_238) AT=50.025n

.meas tran vdout0_239ck90 FIND v(dout0_239) AT=50.025n

.meas tran vdout0_240ck90 FIND v(dout0_240) AT=50.025n

.meas tran vdout0_241ck90 FIND v(dout0_241) AT=50.025n

.meas tran vdout0_242ck90 FIND v(dout0_242) AT=50.025n

.meas tran vdout0_243ck90 FIND v(dout0_243) AT=50.025n

.meas tran vdout0_244ck90 FIND v(dout0_244) AT=50.025n

.meas tran vdout0_245ck90 FIND v(dout0_245) AT=50.025n

.meas tran vdout0_246ck90 FIND v(dout0_246) AT=50.025n

.meas tran vdout0_247ck90 FIND v(dout0_247) AT=50.025n

.meas tran vdout0_248ck90 FIND v(dout0_248) AT=50.025n

.meas tran vdout0_249ck90 FIND v(dout0_249) AT=50.025n

.meas tran vdout0_250ck90 FIND v(dout0_250) AT=50.025n

.meas tran vdout0_251ck90 FIND v(dout0_251) AT=50.025n

.meas tran vdout0_252ck90 FIND v(dout0_252) AT=50.025n

.meas tran vdout0_253ck90 FIND v(dout0_253) AT=50.025n

.meas tran vdout0_254ck90 FIND v(dout0_254) AT=50.025n

.meas tran vdout0_255ck90 FIND v(dout0_255) AT=50.025n

.meas tran vdout0_0ck100 FIND v(dout0_0) AT=55.025n

.meas tran vdout0_1ck100 FIND v(dout0_1) AT=55.025n

.meas tran vdout0_2ck100 FIND v(dout0_2) AT=55.025n

.meas tran vdout0_3ck100 FIND v(dout0_3) AT=55.025n

.meas tran vdout0_4ck100 FIND v(dout0_4) AT=55.025n

.meas tran vdout0_5ck100 FIND v(dout0_5) AT=55.025n

.meas tran vdout0_6ck100 FIND v(dout0_6) AT=55.025n

.meas tran vdout0_7ck100 FIND v(dout0_7) AT=55.025n

.meas tran vdout0_8ck100 FIND v(dout0_8) AT=55.025n

.meas tran vdout0_9ck100 FIND v(dout0_9) AT=55.025n

.meas tran vdout0_10ck100 FIND v(dout0_10) AT=55.025n

.meas tran vdout0_11ck100 FIND v(dout0_11) AT=55.025n

.meas tran vdout0_12ck100 FIND v(dout0_12) AT=55.025n

.meas tran vdout0_13ck100 FIND v(dout0_13) AT=55.025n

.meas tran vdout0_14ck100 FIND v(dout0_14) AT=55.025n

.meas tran vdout0_15ck100 FIND v(dout0_15) AT=55.025n

.meas tran vdout0_16ck100 FIND v(dout0_16) AT=55.025n

.meas tran vdout0_17ck100 FIND v(dout0_17) AT=55.025n

.meas tran vdout0_18ck100 FIND v(dout0_18) AT=55.025n

.meas tran vdout0_19ck100 FIND v(dout0_19) AT=55.025n

.meas tran vdout0_20ck100 FIND v(dout0_20) AT=55.025n

.meas tran vdout0_21ck100 FIND v(dout0_21) AT=55.025n

.meas tran vdout0_22ck100 FIND v(dout0_22) AT=55.025n

.meas tran vdout0_23ck100 FIND v(dout0_23) AT=55.025n

.meas tran vdout0_24ck100 FIND v(dout0_24) AT=55.025n

.meas tran vdout0_25ck100 FIND v(dout0_25) AT=55.025n

.meas tran vdout0_26ck100 FIND v(dout0_26) AT=55.025n

.meas tran vdout0_27ck100 FIND v(dout0_27) AT=55.025n

.meas tran vdout0_28ck100 FIND v(dout0_28) AT=55.025n

.meas tran vdout0_29ck100 FIND v(dout0_29) AT=55.025n

.meas tran vdout0_30ck100 FIND v(dout0_30) AT=55.025n

.meas tran vdout0_31ck100 FIND v(dout0_31) AT=55.025n

.meas tran vdout0_32ck100 FIND v(dout0_32) AT=55.025n

.meas tran vdout0_33ck100 FIND v(dout0_33) AT=55.025n

.meas tran vdout0_34ck100 FIND v(dout0_34) AT=55.025n

.meas tran vdout0_35ck100 FIND v(dout0_35) AT=55.025n

.meas tran vdout0_36ck100 FIND v(dout0_36) AT=55.025n

.meas tran vdout0_37ck100 FIND v(dout0_37) AT=55.025n

.meas tran vdout0_38ck100 FIND v(dout0_38) AT=55.025n

.meas tran vdout0_39ck100 FIND v(dout0_39) AT=55.025n

.meas tran vdout0_40ck100 FIND v(dout0_40) AT=55.025n

.meas tran vdout0_41ck100 FIND v(dout0_41) AT=55.025n

.meas tran vdout0_42ck100 FIND v(dout0_42) AT=55.025n

.meas tran vdout0_43ck100 FIND v(dout0_43) AT=55.025n

.meas tran vdout0_44ck100 FIND v(dout0_44) AT=55.025n

.meas tran vdout0_45ck100 FIND v(dout0_45) AT=55.025n

.meas tran vdout0_46ck100 FIND v(dout0_46) AT=55.025n

.meas tran vdout0_47ck100 FIND v(dout0_47) AT=55.025n

.meas tran vdout0_48ck100 FIND v(dout0_48) AT=55.025n

.meas tran vdout0_49ck100 FIND v(dout0_49) AT=55.025n

.meas tran vdout0_50ck100 FIND v(dout0_50) AT=55.025n

.meas tran vdout0_51ck100 FIND v(dout0_51) AT=55.025n

.meas tran vdout0_52ck100 FIND v(dout0_52) AT=55.025n

.meas tran vdout0_53ck100 FIND v(dout0_53) AT=55.025n

.meas tran vdout0_54ck100 FIND v(dout0_54) AT=55.025n

.meas tran vdout0_55ck100 FIND v(dout0_55) AT=55.025n

.meas tran vdout0_56ck100 FIND v(dout0_56) AT=55.025n

.meas tran vdout0_57ck100 FIND v(dout0_57) AT=55.025n

.meas tran vdout0_58ck100 FIND v(dout0_58) AT=55.025n

.meas tran vdout0_59ck100 FIND v(dout0_59) AT=55.025n

.meas tran vdout0_60ck100 FIND v(dout0_60) AT=55.025n

.meas tran vdout0_61ck100 FIND v(dout0_61) AT=55.025n

.meas tran vdout0_62ck100 FIND v(dout0_62) AT=55.025n

.meas tran vdout0_63ck100 FIND v(dout0_63) AT=55.025n

.meas tran vdout0_64ck100 FIND v(dout0_64) AT=55.025n

.meas tran vdout0_65ck100 FIND v(dout0_65) AT=55.025n

.meas tran vdout0_66ck100 FIND v(dout0_66) AT=55.025n

.meas tran vdout0_67ck100 FIND v(dout0_67) AT=55.025n

.meas tran vdout0_68ck100 FIND v(dout0_68) AT=55.025n

.meas tran vdout0_69ck100 FIND v(dout0_69) AT=55.025n

.meas tran vdout0_70ck100 FIND v(dout0_70) AT=55.025n

.meas tran vdout0_71ck100 FIND v(dout0_71) AT=55.025n

.meas tran vdout0_72ck100 FIND v(dout0_72) AT=55.025n

.meas tran vdout0_73ck100 FIND v(dout0_73) AT=55.025n

.meas tran vdout0_74ck100 FIND v(dout0_74) AT=55.025n

.meas tran vdout0_75ck100 FIND v(dout0_75) AT=55.025n

.meas tran vdout0_76ck100 FIND v(dout0_76) AT=55.025n

.meas tran vdout0_77ck100 FIND v(dout0_77) AT=55.025n

.meas tran vdout0_78ck100 FIND v(dout0_78) AT=55.025n

.meas tran vdout0_79ck100 FIND v(dout0_79) AT=55.025n

.meas tran vdout0_80ck100 FIND v(dout0_80) AT=55.025n

.meas tran vdout0_81ck100 FIND v(dout0_81) AT=55.025n

.meas tran vdout0_82ck100 FIND v(dout0_82) AT=55.025n

.meas tran vdout0_83ck100 FIND v(dout0_83) AT=55.025n

.meas tran vdout0_84ck100 FIND v(dout0_84) AT=55.025n

.meas tran vdout0_85ck100 FIND v(dout0_85) AT=55.025n

.meas tran vdout0_86ck100 FIND v(dout0_86) AT=55.025n

.meas tran vdout0_87ck100 FIND v(dout0_87) AT=55.025n

.meas tran vdout0_88ck100 FIND v(dout0_88) AT=55.025n

.meas tran vdout0_89ck100 FIND v(dout0_89) AT=55.025n

.meas tran vdout0_90ck100 FIND v(dout0_90) AT=55.025n

.meas tran vdout0_91ck100 FIND v(dout0_91) AT=55.025n

.meas tran vdout0_92ck100 FIND v(dout0_92) AT=55.025n

.meas tran vdout0_93ck100 FIND v(dout0_93) AT=55.025n

.meas tran vdout0_94ck100 FIND v(dout0_94) AT=55.025n

.meas tran vdout0_95ck100 FIND v(dout0_95) AT=55.025n

.meas tran vdout0_96ck100 FIND v(dout0_96) AT=55.025n

.meas tran vdout0_97ck100 FIND v(dout0_97) AT=55.025n

.meas tran vdout0_98ck100 FIND v(dout0_98) AT=55.025n

.meas tran vdout0_99ck100 FIND v(dout0_99) AT=55.025n

.meas tran vdout0_100ck100 FIND v(dout0_100) AT=55.025n

.meas tran vdout0_101ck100 FIND v(dout0_101) AT=55.025n

.meas tran vdout0_102ck100 FIND v(dout0_102) AT=55.025n

.meas tran vdout0_103ck100 FIND v(dout0_103) AT=55.025n

.meas tran vdout0_104ck100 FIND v(dout0_104) AT=55.025n

.meas tran vdout0_105ck100 FIND v(dout0_105) AT=55.025n

.meas tran vdout0_106ck100 FIND v(dout0_106) AT=55.025n

.meas tran vdout0_107ck100 FIND v(dout0_107) AT=55.025n

.meas tran vdout0_108ck100 FIND v(dout0_108) AT=55.025n

.meas tran vdout0_109ck100 FIND v(dout0_109) AT=55.025n

.meas tran vdout0_110ck100 FIND v(dout0_110) AT=55.025n

.meas tran vdout0_111ck100 FIND v(dout0_111) AT=55.025n

.meas tran vdout0_112ck100 FIND v(dout0_112) AT=55.025n

.meas tran vdout0_113ck100 FIND v(dout0_113) AT=55.025n

.meas tran vdout0_114ck100 FIND v(dout0_114) AT=55.025n

.meas tran vdout0_115ck100 FIND v(dout0_115) AT=55.025n

.meas tran vdout0_116ck100 FIND v(dout0_116) AT=55.025n

.meas tran vdout0_117ck100 FIND v(dout0_117) AT=55.025n

.meas tran vdout0_118ck100 FIND v(dout0_118) AT=55.025n

.meas tran vdout0_119ck100 FIND v(dout0_119) AT=55.025n

.meas tran vdout0_120ck100 FIND v(dout0_120) AT=55.025n

.meas tran vdout0_121ck100 FIND v(dout0_121) AT=55.025n

.meas tran vdout0_122ck100 FIND v(dout0_122) AT=55.025n

.meas tran vdout0_123ck100 FIND v(dout0_123) AT=55.025n

.meas tran vdout0_124ck100 FIND v(dout0_124) AT=55.025n

.meas tran vdout0_125ck100 FIND v(dout0_125) AT=55.025n

.meas tran vdout0_126ck100 FIND v(dout0_126) AT=55.025n

.meas tran vdout0_127ck100 FIND v(dout0_127) AT=55.025n

.meas tran vdout0_128ck100 FIND v(dout0_128) AT=55.025n

.meas tran vdout0_129ck100 FIND v(dout0_129) AT=55.025n

.meas tran vdout0_130ck100 FIND v(dout0_130) AT=55.025n

.meas tran vdout0_131ck100 FIND v(dout0_131) AT=55.025n

.meas tran vdout0_132ck100 FIND v(dout0_132) AT=55.025n

.meas tran vdout0_133ck100 FIND v(dout0_133) AT=55.025n

.meas tran vdout0_134ck100 FIND v(dout0_134) AT=55.025n

.meas tran vdout0_135ck100 FIND v(dout0_135) AT=55.025n

.meas tran vdout0_136ck100 FIND v(dout0_136) AT=55.025n

.meas tran vdout0_137ck100 FIND v(dout0_137) AT=55.025n

.meas tran vdout0_138ck100 FIND v(dout0_138) AT=55.025n

.meas tran vdout0_139ck100 FIND v(dout0_139) AT=55.025n

.meas tran vdout0_140ck100 FIND v(dout0_140) AT=55.025n

.meas tran vdout0_141ck100 FIND v(dout0_141) AT=55.025n

.meas tran vdout0_142ck100 FIND v(dout0_142) AT=55.025n

.meas tran vdout0_143ck100 FIND v(dout0_143) AT=55.025n

.meas tran vdout0_144ck100 FIND v(dout0_144) AT=55.025n

.meas tran vdout0_145ck100 FIND v(dout0_145) AT=55.025n

.meas tran vdout0_146ck100 FIND v(dout0_146) AT=55.025n

.meas tran vdout0_147ck100 FIND v(dout0_147) AT=55.025n

.meas tran vdout0_148ck100 FIND v(dout0_148) AT=55.025n

.meas tran vdout0_149ck100 FIND v(dout0_149) AT=55.025n

.meas tran vdout0_150ck100 FIND v(dout0_150) AT=55.025n

.meas tran vdout0_151ck100 FIND v(dout0_151) AT=55.025n

.meas tran vdout0_152ck100 FIND v(dout0_152) AT=55.025n

.meas tran vdout0_153ck100 FIND v(dout0_153) AT=55.025n

.meas tran vdout0_154ck100 FIND v(dout0_154) AT=55.025n

.meas tran vdout0_155ck100 FIND v(dout0_155) AT=55.025n

.meas tran vdout0_156ck100 FIND v(dout0_156) AT=55.025n

.meas tran vdout0_157ck100 FIND v(dout0_157) AT=55.025n

.meas tran vdout0_158ck100 FIND v(dout0_158) AT=55.025n

.meas tran vdout0_159ck100 FIND v(dout0_159) AT=55.025n

.meas tran vdout0_160ck100 FIND v(dout0_160) AT=55.025n

.meas tran vdout0_161ck100 FIND v(dout0_161) AT=55.025n

.meas tran vdout0_162ck100 FIND v(dout0_162) AT=55.025n

.meas tran vdout0_163ck100 FIND v(dout0_163) AT=55.025n

.meas tran vdout0_164ck100 FIND v(dout0_164) AT=55.025n

.meas tran vdout0_165ck100 FIND v(dout0_165) AT=55.025n

.meas tran vdout0_166ck100 FIND v(dout0_166) AT=55.025n

.meas tran vdout0_167ck100 FIND v(dout0_167) AT=55.025n

.meas tran vdout0_168ck100 FIND v(dout0_168) AT=55.025n

.meas tran vdout0_169ck100 FIND v(dout0_169) AT=55.025n

.meas tran vdout0_170ck100 FIND v(dout0_170) AT=55.025n

.meas tran vdout0_171ck100 FIND v(dout0_171) AT=55.025n

.meas tran vdout0_172ck100 FIND v(dout0_172) AT=55.025n

.meas tran vdout0_173ck100 FIND v(dout0_173) AT=55.025n

.meas tran vdout0_174ck100 FIND v(dout0_174) AT=55.025n

.meas tran vdout0_175ck100 FIND v(dout0_175) AT=55.025n

.meas tran vdout0_176ck100 FIND v(dout0_176) AT=55.025n

.meas tran vdout0_177ck100 FIND v(dout0_177) AT=55.025n

.meas tran vdout0_178ck100 FIND v(dout0_178) AT=55.025n

.meas tran vdout0_179ck100 FIND v(dout0_179) AT=55.025n

.meas tran vdout0_180ck100 FIND v(dout0_180) AT=55.025n

.meas tran vdout0_181ck100 FIND v(dout0_181) AT=55.025n

.meas tran vdout0_182ck100 FIND v(dout0_182) AT=55.025n

.meas tran vdout0_183ck100 FIND v(dout0_183) AT=55.025n

.meas tran vdout0_184ck100 FIND v(dout0_184) AT=55.025n

.meas tran vdout0_185ck100 FIND v(dout0_185) AT=55.025n

.meas tran vdout0_186ck100 FIND v(dout0_186) AT=55.025n

.meas tran vdout0_187ck100 FIND v(dout0_187) AT=55.025n

.meas tran vdout0_188ck100 FIND v(dout0_188) AT=55.025n

.meas tran vdout0_189ck100 FIND v(dout0_189) AT=55.025n

.meas tran vdout0_190ck100 FIND v(dout0_190) AT=55.025n

.meas tran vdout0_191ck100 FIND v(dout0_191) AT=55.025n

.meas tran vdout0_192ck100 FIND v(dout0_192) AT=55.025n

.meas tran vdout0_193ck100 FIND v(dout0_193) AT=55.025n

.meas tran vdout0_194ck100 FIND v(dout0_194) AT=55.025n

.meas tran vdout0_195ck100 FIND v(dout0_195) AT=55.025n

.meas tran vdout0_196ck100 FIND v(dout0_196) AT=55.025n

.meas tran vdout0_197ck100 FIND v(dout0_197) AT=55.025n

.meas tran vdout0_198ck100 FIND v(dout0_198) AT=55.025n

.meas tran vdout0_199ck100 FIND v(dout0_199) AT=55.025n

.meas tran vdout0_200ck100 FIND v(dout0_200) AT=55.025n

.meas tran vdout0_201ck100 FIND v(dout0_201) AT=55.025n

.meas tran vdout0_202ck100 FIND v(dout0_202) AT=55.025n

.meas tran vdout0_203ck100 FIND v(dout0_203) AT=55.025n

.meas tran vdout0_204ck100 FIND v(dout0_204) AT=55.025n

.meas tran vdout0_205ck100 FIND v(dout0_205) AT=55.025n

.meas tran vdout0_206ck100 FIND v(dout0_206) AT=55.025n

.meas tran vdout0_207ck100 FIND v(dout0_207) AT=55.025n

.meas tran vdout0_208ck100 FIND v(dout0_208) AT=55.025n

.meas tran vdout0_209ck100 FIND v(dout0_209) AT=55.025n

.meas tran vdout0_210ck100 FIND v(dout0_210) AT=55.025n

.meas tran vdout0_211ck100 FIND v(dout0_211) AT=55.025n

.meas tran vdout0_212ck100 FIND v(dout0_212) AT=55.025n

.meas tran vdout0_213ck100 FIND v(dout0_213) AT=55.025n

.meas tran vdout0_214ck100 FIND v(dout0_214) AT=55.025n

.meas tran vdout0_215ck100 FIND v(dout0_215) AT=55.025n

.meas tran vdout0_216ck100 FIND v(dout0_216) AT=55.025n

.meas tran vdout0_217ck100 FIND v(dout0_217) AT=55.025n

.meas tran vdout0_218ck100 FIND v(dout0_218) AT=55.025n

.meas tran vdout0_219ck100 FIND v(dout0_219) AT=55.025n

.meas tran vdout0_220ck100 FIND v(dout0_220) AT=55.025n

.meas tran vdout0_221ck100 FIND v(dout0_221) AT=55.025n

.meas tran vdout0_222ck100 FIND v(dout0_222) AT=55.025n

.meas tran vdout0_223ck100 FIND v(dout0_223) AT=55.025n

.meas tran vdout0_224ck100 FIND v(dout0_224) AT=55.025n

.meas tran vdout0_225ck100 FIND v(dout0_225) AT=55.025n

.meas tran vdout0_226ck100 FIND v(dout0_226) AT=55.025n

.meas tran vdout0_227ck100 FIND v(dout0_227) AT=55.025n

.meas tran vdout0_228ck100 FIND v(dout0_228) AT=55.025n

.meas tran vdout0_229ck100 FIND v(dout0_229) AT=55.025n

.meas tran vdout0_230ck100 FIND v(dout0_230) AT=55.025n

.meas tran vdout0_231ck100 FIND v(dout0_231) AT=55.025n

.meas tran vdout0_232ck100 FIND v(dout0_232) AT=55.025n

.meas tran vdout0_233ck100 FIND v(dout0_233) AT=55.025n

.meas tran vdout0_234ck100 FIND v(dout0_234) AT=55.025n

.meas tran vdout0_235ck100 FIND v(dout0_235) AT=55.025n

.meas tran vdout0_236ck100 FIND v(dout0_236) AT=55.025n

.meas tran vdout0_237ck100 FIND v(dout0_237) AT=55.025n

.meas tran vdout0_238ck100 FIND v(dout0_238) AT=55.025n

.meas tran vdout0_239ck100 FIND v(dout0_239) AT=55.025n

.meas tran vdout0_240ck100 FIND v(dout0_240) AT=55.025n

.meas tran vdout0_241ck100 FIND v(dout0_241) AT=55.025n

.meas tran vdout0_242ck100 FIND v(dout0_242) AT=55.025n

.meas tran vdout0_243ck100 FIND v(dout0_243) AT=55.025n

.meas tran vdout0_244ck100 FIND v(dout0_244) AT=55.025n

.meas tran vdout0_245ck100 FIND v(dout0_245) AT=55.025n

.meas tran vdout0_246ck100 FIND v(dout0_246) AT=55.025n

.meas tran vdout0_247ck100 FIND v(dout0_247) AT=55.025n

.meas tran vdout0_248ck100 FIND v(dout0_248) AT=55.025n

.meas tran vdout0_249ck100 FIND v(dout0_249) AT=55.025n

.meas tran vdout0_250ck100 FIND v(dout0_250) AT=55.025n

.meas tran vdout0_251ck100 FIND v(dout0_251) AT=55.025n

.meas tran vdout0_252ck100 FIND v(dout0_252) AT=55.025n

.meas tran vdout0_253ck100 FIND v(dout0_253) AT=55.025n

.meas tran vdout0_254ck100 FIND v(dout0_254) AT=55.025n

.meas tran vdout0_255ck100 FIND v(dout0_255) AT=55.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_128ck200 FIND v(dout0_128) AT=105.025n

.meas tran vdout0_129ck200 FIND v(dout0_129) AT=105.025n

.meas tran vdout0_130ck200 FIND v(dout0_130) AT=105.025n

.meas tran vdout0_131ck200 FIND v(dout0_131) AT=105.025n

.meas tran vdout0_132ck200 FIND v(dout0_132) AT=105.025n

.meas tran vdout0_133ck200 FIND v(dout0_133) AT=105.025n

.meas tran vdout0_134ck200 FIND v(dout0_134) AT=105.025n

.meas tran vdout0_135ck200 FIND v(dout0_135) AT=105.025n

.meas tran vdout0_136ck200 FIND v(dout0_136) AT=105.025n

.meas tran vdout0_137ck200 FIND v(dout0_137) AT=105.025n

.meas tran vdout0_138ck200 FIND v(dout0_138) AT=105.025n

.meas tran vdout0_139ck200 FIND v(dout0_139) AT=105.025n

.meas tran vdout0_140ck200 FIND v(dout0_140) AT=105.025n

.meas tran vdout0_141ck200 FIND v(dout0_141) AT=105.025n

.meas tran vdout0_142ck200 FIND v(dout0_142) AT=105.025n

.meas tran vdout0_143ck200 FIND v(dout0_143) AT=105.025n

.meas tran vdout0_144ck200 FIND v(dout0_144) AT=105.025n

.meas tran vdout0_145ck200 FIND v(dout0_145) AT=105.025n

.meas tran vdout0_146ck200 FIND v(dout0_146) AT=105.025n

.meas tran vdout0_147ck200 FIND v(dout0_147) AT=105.025n

.meas tran vdout0_148ck200 FIND v(dout0_148) AT=105.025n

.meas tran vdout0_149ck200 FIND v(dout0_149) AT=105.025n

.meas tran vdout0_150ck200 FIND v(dout0_150) AT=105.025n

.meas tran vdout0_151ck200 FIND v(dout0_151) AT=105.025n

.meas tran vdout0_152ck200 FIND v(dout0_152) AT=105.025n

.meas tran vdout0_153ck200 FIND v(dout0_153) AT=105.025n

.meas tran vdout0_154ck200 FIND v(dout0_154) AT=105.025n

.meas tran vdout0_155ck200 FIND v(dout0_155) AT=105.025n

.meas tran vdout0_156ck200 FIND v(dout0_156) AT=105.025n

.meas tran vdout0_157ck200 FIND v(dout0_157) AT=105.025n

.meas tran vdout0_158ck200 FIND v(dout0_158) AT=105.025n

.meas tran vdout0_159ck200 FIND v(dout0_159) AT=105.025n

.meas tran vdout0_160ck200 FIND v(dout0_160) AT=105.025n

.meas tran vdout0_161ck200 FIND v(dout0_161) AT=105.025n

.meas tran vdout0_162ck200 FIND v(dout0_162) AT=105.025n

.meas tran vdout0_163ck200 FIND v(dout0_163) AT=105.025n

.meas tran vdout0_164ck200 FIND v(dout0_164) AT=105.025n

.meas tran vdout0_165ck200 FIND v(dout0_165) AT=105.025n

.meas tran vdout0_166ck200 FIND v(dout0_166) AT=105.025n

.meas tran vdout0_167ck200 FIND v(dout0_167) AT=105.025n

.meas tran vdout0_168ck200 FIND v(dout0_168) AT=105.025n

.meas tran vdout0_169ck200 FIND v(dout0_169) AT=105.025n

.meas tran vdout0_170ck200 FIND v(dout0_170) AT=105.025n

.meas tran vdout0_171ck200 FIND v(dout0_171) AT=105.025n

.meas tran vdout0_172ck200 FIND v(dout0_172) AT=105.025n

.meas tran vdout0_173ck200 FIND v(dout0_173) AT=105.025n

.meas tran vdout0_174ck200 FIND v(dout0_174) AT=105.025n

.meas tran vdout0_175ck200 FIND v(dout0_175) AT=105.025n

.meas tran vdout0_176ck200 FIND v(dout0_176) AT=105.025n

.meas tran vdout0_177ck200 FIND v(dout0_177) AT=105.025n

.meas tran vdout0_178ck200 FIND v(dout0_178) AT=105.025n

.meas tran vdout0_179ck200 FIND v(dout0_179) AT=105.025n

.meas tran vdout0_180ck200 FIND v(dout0_180) AT=105.025n

.meas tran vdout0_181ck200 FIND v(dout0_181) AT=105.025n

.meas tran vdout0_182ck200 FIND v(dout0_182) AT=105.025n

.meas tran vdout0_183ck200 FIND v(dout0_183) AT=105.025n

.meas tran vdout0_184ck200 FIND v(dout0_184) AT=105.025n

.meas tran vdout0_185ck200 FIND v(dout0_185) AT=105.025n

.meas tran vdout0_186ck200 FIND v(dout0_186) AT=105.025n

.meas tran vdout0_187ck200 FIND v(dout0_187) AT=105.025n

.meas tran vdout0_188ck200 FIND v(dout0_188) AT=105.025n

.meas tran vdout0_189ck200 FIND v(dout0_189) AT=105.025n

.meas tran vdout0_190ck200 FIND v(dout0_190) AT=105.025n

.meas tran vdout0_191ck200 FIND v(dout0_191) AT=105.025n

.meas tran vdout0_192ck200 FIND v(dout0_192) AT=105.025n

.meas tran vdout0_193ck200 FIND v(dout0_193) AT=105.025n

.meas tran vdout0_194ck200 FIND v(dout0_194) AT=105.025n

.meas tran vdout0_195ck200 FIND v(dout0_195) AT=105.025n

.meas tran vdout0_196ck200 FIND v(dout0_196) AT=105.025n

.meas tran vdout0_197ck200 FIND v(dout0_197) AT=105.025n

.meas tran vdout0_198ck200 FIND v(dout0_198) AT=105.025n

.meas tran vdout0_199ck200 FIND v(dout0_199) AT=105.025n

.meas tran vdout0_200ck200 FIND v(dout0_200) AT=105.025n

.meas tran vdout0_201ck200 FIND v(dout0_201) AT=105.025n

.meas tran vdout0_202ck200 FIND v(dout0_202) AT=105.025n

.meas tran vdout0_203ck200 FIND v(dout0_203) AT=105.025n

.meas tran vdout0_204ck200 FIND v(dout0_204) AT=105.025n

.meas tran vdout0_205ck200 FIND v(dout0_205) AT=105.025n

.meas tran vdout0_206ck200 FIND v(dout0_206) AT=105.025n

.meas tran vdout0_207ck200 FIND v(dout0_207) AT=105.025n

.meas tran vdout0_208ck200 FIND v(dout0_208) AT=105.025n

.meas tran vdout0_209ck200 FIND v(dout0_209) AT=105.025n

.meas tran vdout0_210ck200 FIND v(dout0_210) AT=105.025n

.meas tran vdout0_211ck200 FIND v(dout0_211) AT=105.025n

.meas tran vdout0_212ck200 FIND v(dout0_212) AT=105.025n

.meas tran vdout0_213ck200 FIND v(dout0_213) AT=105.025n

.meas tran vdout0_214ck200 FIND v(dout0_214) AT=105.025n

.meas tran vdout0_215ck200 FIND v(dout0_215) AT=105.025n

.meas tran vdout0_216ck200 FIND v(dout0_216) AT=105.025n

.meas tran vdout0_217ck200 FIND v(dout0_217) AT=105.025n

.meas tran vdout0_218ck200 FIND v(dout0_218) AT=105.025n

.meas tran vdout0_219ck200 FIND v(dout0_219) AT=105.025n

.meas tran vdout0_220ck200 FIND v(dout0_220) AT=105.025n

.meas tran vdout0_221ck200 FIND v(dout0_221) AT=105.025n

.meas tran vdout0_222ck200 FIND v(dout0_222) AT=105.025n

.meas tran vdout0_223ck200 FIND v(dout0_223) AT=105.025n

.meas tran vdout0_224ck200 FIND v(dout0_224) AT=105.025n

.meas tran vdout0_225ck200 FIND v(dout0_225) AT=105.025n

.meas tran vdout0_226ck200 FIND v(dout0_226) AT=105.025n

.meas tran vdout0_227ck200 FIND v(dout0_227) AT=105.025n

.meas tran vdout0_228ck200 FIND v(dout0_228) AT=105.025n

.meas tran vdout0_229ck200 FIND v(dout0_229) AT=105.025n

.meas tran vdout0_230ck200 FIND v(dout0_230) AT=105.025n

.meas tran vdout0_231ck200 FIND v(dout0_231) AT=105.025n

.meas tran vdout0_232ck200 FIND v(dout0_232) AT=105.025n

.meas tran vdout0_233ck200 FIND v(dout0_233) AT=105.025n

.meas tran vdout0_234ck200 FIND v(dout0_234) AT=105.025n

.meas tran vdout0_235ck200 FIND v(dout0_235) AT=105.025n

.meas tran vdout0_236ck200 FIND v(dout0_236) AT=105.025n

.meas tran vdout0_237ck200 FIND v(dout0_237) AT=105.025n

.meas tran vdout0_238ck200 FIND v(dout0_238) AT=105.025n

.meas tran vdout0_239ck200 FIND v(dout0_239) AT=105.025n

.meas tran vdout0_240ck200 FIND v(dout0_240) AT=105.025n

.meas tran vdout0_241ck200 FIND v(dout0_241) AT=105.025n

.meas tran vdout0_242ck200 FIND v(dout0_242) AT=105.025n

.meas tran vdout0_243ck200 FIND v(dout0_243) AT=105.025n

.meas tran vdout0_244ck200 FIND v(dout0_244) AT=105.025n

.meas tran vdout0_245ck200 FIND v(dout0_245) AT=105.025n

.meas tran vdout0_246ck200 FIND v(dout0_246) AT=105.025n

.meas tran vdout0_247ck200 FIND v(dout0_247) AT=105.025n

.meas tran vdout0_248ck200 FIND v(dout0_248) AT=105.025n

.meas tran vdout0_249ck200 FIND v(dout0_249) AT=105.025n

.meas tran vdout0_250ck200 FIND v(dout0_250) AT=105.025n

.meas tran vdout0_251ck200 FIND v(dout0_251) AT=105.025n

.meas tran vdout0_252ck200 FIND v(dout0_252) AT=105.025n

.meas tran vdout0_253ck200 FIND v(dout0_253) AT=105.025n

.meas tran vdout0_254ck200 FIND v(dout0_254) AT=105.025n

.meas tran vdout0_255ck200 FIND v(dout0_255) AT=105.025n

.meas tran vdout0_0ck210 FIND v(dout0_0) AT=110.025n

.meas tran vdout0_1ck210 FIND v(dout0_1) AT=110.025n

.meas tran vdout0_2ck210 FIND v(dout0_2) AT=110.025n

.meas tran vdout0_3ck210 FIND v(dout0_3) AT=110.025n

.meas tran vdout0_4ck210 FIND v(dout0_4) AT=110.025n

.meas tran vdout0_5ck210 FIND v(dout0_5) AT=110.025n

.meas tran vdout0_6ck210 FIND v(dout0_6) AT=110.025n

.meas tran vdout0_7ck210 FIND v(dout0_7) AT=110.025n

.meas tran vdout0_8ck210 FIND v(dout0_8) AT=110.025n

.meas tran vdout0_9ck210 FIND v(dout0_9) AT=110.025n

.meas tran vdout0_10ck210 FIND v(dout0_10) AT=110.025n

.meas tran vdout0_11ck210 FIND v(dout0_11) AT=110.025n

.meas tran vdout0_12ck210 FIND v(dout0_12) AT=110.025n

.meas tran vdout0_13ck210 FIND v(dout0_13) AT=110.025n

.meas tran vdout0_14ck210 FIND v(dout0_14) AT=110.025n

.meas tran vdout0_15ck210 FIND v(dout0_15) AT=110.025n

.meas tran vdout0_16ck210 FIND v(dout0_16) AT=110.025n

.meas tran vdout0_17ck210 FIND v(dout0_17) AT=110.025n

.meas tran vdout0_18ck210 FIND v(dout0_18) AT=110.025n

.meas tran vdout0_19ck210 FIND v(dout0_19) AT=110.025n

.meas tran vdout0_20ck210 FIND v(dout0_20) AT=110.025n

.meas tran vdout0_21ck210 FIND v(dout0_21) AT=110.025n

.meas tran vdout0_22ck210 FIND v(dout0_22) AT=110.025n

.meas tran vdout0_23ck210 FIND v(dout0_23) AT=110.025n

.meas tran vdout0_24ck210 FIND v(dout0_24) AT=110.025n

.meas tran vdout0_25ck210 FIND v(dout0_25) AT=110.025n

.meas tran vdout0_26ck210 FIND v(dout0_26) AT=110.025n

.meas tran vdout0_27ck210 FIND v(dout0_27) AT=110.025n

.meas tran vdout0_28ck210 FIND v(dout0_28) AT=110.025n

.meas tran vdout0_29ck210 FIND v(dout0_29) AT=110.025n

.meas tran vdout0_30ck210 FIND v(dout0_30) AT=110.025n

.meas tran vdout0_31ck210 FIND v(dout0_31) AT=110.025n

.meas tran vdout0_32ck210 FIND v(dout0_32) AT=110.025n

.meas tran vdout0_33ck210 FIND v(dout0_33) AT=110.025n

.meas tran vdout0_34ck210 FIND v(dout0_34) AT=110.025n

.meas tran vdout0_35ck210 FIND v(dout0_35) AT=110.025n

.meas tran vdout0_36ck210 FIND v(dout0_36) AT=110.025n

.meas tran vdout0_37ck210 FIND v(dout0_37) AT=110.025n

.meas tran vdout0_38ck210 FIND v(dout0_38) AT=110.025n

.meas tran vdout0_39ck210 FIND v(dout0_39) AT=110.025n

.meas tran vdout0_40ck210 FIND v(dout0_40) AT=110.025n

.meas tran vdout0_41ck210 FIND v(dout0_41) AT=110.025n

.meas tran vdout0_42ck210 FIND v(dout0_42) AT=110.025n

.meas tran vdout0_43ck210 FIND v(dout0_43) AT=110.025n

.meas tran vdout0_44ck210 FIND v(dout0_44) AT=110.025n

.meas tran vdout0_45ck210 FIND v(dout0_45) AT=110.025n

.meas tran vdout0_46ck210 FIND v(dout0_46) AT=110.025n

.meas tran vdout0_47ck210 FIND v(dout0_47) AT=110.025n

.meas tran vdout0_48ck210 FIND v(dout0_48) AT=110.025n

.meas tran vdout0_49ck210 FIND v(dout0_49) AT=110.025n

.meas tran vdout0_50ck210 FIND v(dout0_50) AT=110.025n

.meas tran vdout0_51ck210 FIND v(dout0_51) AT=110.025n

.meas tran vdout0_52ck210 FIND v(dout0_52) AT=110.025n

.meas tran vdout0_53ck210 FIND v(dout0_53) AT=110.025n

.meas tran vdout0_54ck210 FIND v(dout0_54) AT=110.025n

.meas tran vdout0_55ck210 FIND v(dout0_55) AT=110.025n

.meas tran vdout0_56ck210 FIND v(dout0_56) AT=110.025n

.meas tran vdout0_57ck210 FIND v(dout0_57) AT=110.025n

.meas tran vdout0_58ck210 FIND v(dout0_58) AT=110.025n

.meas tran vdout0_59ck210 FIND v(dout0_59) AT=110.025n

.meas tran vdout0_60ck210 FIND v(dout0_60) AT=110.025n

.meas tran vdout0_61ck210 FIND v(dout0_61) AT=110.025n

.meas tran vdout0_62ck210 FIND v(dout0_62) AT=110.025n

.meas tran vdout0_63ck210 FIND v(dout0_63) AT=110.025n

.meas tran vdout0_64ck210 FIND v(dout0_64) AT=110.025n

.meas tran vdout0_65ck210 FIND v(dout0_65) AT=110.025n

.meas tran vdout0_66ck210 FIND v(dout0_66) AT=110.025n

.meas tran vdout0_67ck210 FIND v(dout0_67) AT=110.025n

.meas tran vdout0_68ck210 FIND v(dout0_68) AT=110.025n

.meas tran vdout0_69ck210 FIND v(dout0_69) AT=110.025n

.meas tran vdout0_70ck210 FIND v(dout0_70) AT=110.025n

.meas tran vdout0_71ck210 FIND v(dout0_71) AT=110.025n

.meas tran vdout0_72ck210 FIND v(dout0_72) AT=110.025n

.meas tran vdout0_73ck210 FIND v(dout0_73) AT=110.025n

.meas tran vdout0_74ck210 FIND v(dout0_74) AT=110.025n

.meas tran vdout0_75ck210 FIND v(dout0_75) AT=110.025n

.meas tran vdout0_76ck210 FIND v(dout0_76) AT=110.025n

.meas tran vdout0_77ck210 FIND v(dout0_77) AT=110.025n

.meas tran vdout0_78ck210 FIND v(dout0_78) AT=110.025n

.meas tran vdout0_79ck210 FIND v(dout0_79) AT=110.025n

.meas tran vdout0_80ck210 FIND v(dout0_80) AT=110.025n

.meas tran vdout0_81ck210 FIND v(dout0_81) AT=110.025n

.meas tran vdout0_82ck210 FIND v(dout0_82) AT=110.025n

.meas tran vdout0_83ck210 FIND v(dout0_83) AT=110.025n

.meas tran vdout0_84ck210 FIND v(dout0_84) AT=110.025n

.meas tran vdout0_85ck210 FIND v(dout0_85) AT=110.025n

.meas tran vdout0_86ck210 FIND v(dout0_86) AT=110.025n

.meas tran vdout0_87ck210 FIND v(dout0_87) AT=110.025n

.meas tran vdout0_88ck210 FIND v(dout0_88) AT=110.025n

.meas tran vdout0_89ck210 FIND v(dout0_89) AT=110.025n

.meas tran vdout0_90ck210 FIND v(dout0_90) AT=110.025n

.meas tran vdout0_91ck210 FIND v(dout0_91) AT=110.025n

.meas tran vdout0_92ck210 FIND v(dout0_92) AT=110.025n

.meas tran vdout0_93ck210 FIND v(dout0_93) AT=110.025n

.meas tran vdout0_94ck210 FIND v(dout0_94) AT=110.025n

.meas tran vdout0_95ck210 FIND v(dout0_95) AT=110.025n

.meas tran vdout0_96ck210 FIND v(dout0_96) AT=110.025n

.meas tran vdout0_97ck210 FIND v(dout0_97) AT=110.025n

.meas tran vdout0_98ck210 FIND v(dout0_98) AT=110.025n

.meas tran vdout0_99ck210 FIND v(dout0_99) AT=110.025n

.meas tran vdout0_100ck210 FIND v(dout0_100) AT=110.025n

.meas tran vdout0_101ck210 FIND v(dout0_101) AT=110.025n

.meas tran vdout0_102ck210 FIND v(dout0_102) AT=110.025n

.meas tran vdout0_103ck210 FIND v(dout0_103) AT=110.025n

.meas tran vdout0_104ck210 FIND v(dout0_104) AT=110.025n

.meas tran vdout0_105ck210 FIND v(dout0_105) AT=110.025n

.meas tran vdout0_106ck210 FIND v(dout0_106) AT=110.025n

.meas tran vdout0_107ck210 FIND v(dout0_107) AT=110.025n

.meas tran vdout0_108ck210 FIND v(dout0_108) AT=110.025n

.meas tran vdout0_109ck210 FIND v(dout0_109) AT=110.025n

.meas tran vdout0_110ck210 FIND v(dout0_110) AT=110.025n

.meas tran vdout0_111ck210 FIND v(dout0_111) AT=110.025n

.meas tran vdout0_112ck210 FIND v(dout0_112) AT=110.025n

.meas tran vdout0_113ck210 FIND v(dout0_113) AT=110.025n

.meas tran vdout0_114ck210 FIND v(dout0_114) AT=110.025n

.meas tran vdout0_115ck210 FIND v(dout0_115) AT=110.025n

.meas tran vdout0_116ck210 FIND v(dout0_116) AT=110.025n

.meas tran vdout0_117ck210 FIND v(dout0_117) AT=110.025n

.meas tran vdout0_118ck210 FIND v(dout0_118) AT=110.025n

.meas tran vdout0_119ck210 FIND v(dout0_119) AT=110.025n

.meas tran vdout0_120ck210 FIND v(dout0_120) AT=110.025n

.meas tran vdout0_121ck210 FIND v(dout0_121) AT=110.025n

.meas tran vdout0_122ck210 FIND v(dout0_122) AT=110.025n

.meas tran vdout0_123ck210 FIND v(dout0_123) AT=110.025n

.meas tran vdout0_124ck210 FIND v(dout0_124) AT=110.025n

.meas tran vdout0_125ck210 FIND v(dout0_125) AT=110.025n

.meas tran vdout0_126ck210 FIND v(dout0_126) AT=110.025n

.meas tran vdout0_127ck210 FIND v(dout0_127) AT=110.025n

.meas tran vdout0_128ck210 FIND v(dout0_128) AT=110.025n

.meas tran vdout0_129ck210 FIND v(dout0_129) AT=110.025n

.meas tran vdout0_130ck210 FIND v(dout0_130) AT=110.025n

.meas tran vdout0_131ck210 FIND v(dout0_131) AT=110.025n

.meas tran vdout0_132ck210 FIND v(dout0_132) AT=110.025n

.meas tran vdout0_133ck210 FIND v(dout0_133) AT=110.025n

.meas tran vdout0_134ck210 FIND v(dout0_134) AT=110.025n

.meas tran vdout0_135ck210 FIND v(dout0_135) AT=110.025n

.meas tran vdout0_136ck210 FIND v(dout0_136) AT=110.025n

.meas tran vdout0_137ck210 FIND v(dout0_137) AT=110.025n

.meas tran vdout0_138ck210 FIND v(dout0_138) AT=110.025n

.meas tran vdout0_139ck210 FIND v(dout0_139) AT=110.025n

.meas tran vdout0_140ck210 FIND v(dout0_140) AT=110.025n

.meas tran vdout0_141ck210 FIND v(dout0_141) AT=110.025n

.meas tran vdout0_142ck210 FIND v(dout0_142) AT=110.025n

.meas tran vdout0_143ck210 FIND v(dout0_143) AT=110.025n

.meas tran vdout0_144ck210 FIND v(dout0_144) AT=110.025n

.meas tran vdout0_145ck210 FIND v(dout0_145) AT=110.025n

.meas tran vdout0_146ck210 FIND v(dout0_146) AT=110.025n

.meas tran vdout0_147ck210 FIND v(dout0_147) AT=110.025n

.meas tran vdout0_148ck210 FIND v(dout0_148) AT=110.025n

.meas tran vdout0_149ck210 FIND v(dout0_149) AT=110.025n

.meas tran vdout0_150ck210 FIND v(dout0_150) AT=110.025n

.meas tran vdout0_151ck210 FIND v(dout0_151) AT=110.025n

.meas tran vdout0_152ck210 FIND v(dout0_152) AT=110.025n

.meas tran vdout0_153ck210 FIND v(dout0_153) AT=110.025n

.meas tran vdout0_154ck210 FIND v(dout0_154) AT=110.025n

.meas tran vdout0_155ck210 FIND v(dout0_155) AT=110.025n

.meas tran vdout0_156ck210 FIND v(dout0_156) AT=110.025n

.meas tran vdout0_157ck210 FIND v(dout0_157) AT=110.025n

.meas tran vdout0_158ck210 FIND v(dout0_158) AT=110.025n

.meas tran vdout0_159ck210 FIND v(dout0_159) AT=110.025n

.meas tran vdout0_160ck210 FIND v(dout0_160) AT=110.025n

.meas tran vdout0_161ck210 FIND v(dout0_161) AT=110.025n

.meas tran vdout0_162ck210 FIND v(dout0_162) AT=110.025n

.meas tran vdout0_163ck210 FIND v(dout0_163) AT=110.025n

.meas tran vdout0_164ck210 FIND v(dout0_164) AT=110.025n

.meas tran vdout0_165ck210 FIND v(dout0_165) AT=110.025n

.meas tran vdout0_166ck210 FIND v(dout0_166) AT=110.025n

.meas tran vdout0_167ck210 FIND v(dout0_167) AT=110.025n

.meas tran vdout0_168ck210 FIND v(dout0_168) AT=110.025n

.meas tran vdout0_169ck210 FIND v(dout0_169) AT=110.025n

.meas tran vdout0_170ck210 FIND v(dout0_170) AT=110.025n

.meas tran vdout0_171ck210 FIND v(dout0_171) AT=110.025n

.meas tran vdout0_172ck210 FIND v(dout0_172) AT=110.025n

.meas tran vdout0_173ck210 FIND v(dout0_173) AT=110.025n

.meas tran vdout0_174ck210 FIND v(dout0_174) AT=110.025n

.meas tran vdout0_175ck210 FIND v(dout0_175) AT=110.025n

.meas tran vdout0_176ck210 FIND v(dout0_176) AT=110.025n

.meas tran vdout0_177ck210 FIND v(dout0_177) AT=110.025n

.meas tran vdout0_178ck210 FIND v(dout0_178) AT=110.025n

.meas tran vdout0_179ck210 FIND v(dout0_179) AT=110.025n

.meas tran vdout0_180ck210 FIND v(dout0_180) AT=110.025n

.meas tran vdout0_181ck210 FIND v(dout0_181) AT=110.025n

.meas tran vdout0_182ck210 FIND v(dout0_182) AT=110.025n

.meas tran vdout0_183ck210 FIND v(dout0_183) AT=110.025n

.meas tran vdout0_184ck210 FIND v(dout0_184) AT=110.025n

.meas tran vdout0_185ck210 FIND v(dout0_185) AT=110.025n

.meas tran vdout0_186ck210 FIND v(dout0_186) AT=110.025n

.meas tran vdout0_187ck210 FIND v(dout0_187) AT=110.025n

.meas tran vdout0_188ck210 FIND v(dout0_188) AT=110.025n

.meas tran vdout0_189ck210 FIND v(dout0_189) AT=110.025n

.meas tran vdout0_190ck210 FIND v(dout0_190) AT=110.025n

.meas tran vdout0_191ck210 FIND v(dout0_191) AT=110.025n

.meas tran vdout0_192ck210 FIND v(dout0_192) AT=110.025n

.meas tran vdout0_193ck210 FIND v(dout0_193) AT=110.025n

.meas tran vdout0_194ck210 FIND v(dout0_194) AT=110.025n

.meas tran vdout0_195ck210 FIND v(dout0_195) AT=110.025n

.meas tran vdout0_196ck210 FIND v(dout0_196) AT=110.025n

.meas tran vdout0_197ck210 FIND v(dout0_197) AT=110.025n

.meas tran vdout0_198ck210 FIND v(dout0_198) AT=110.025n

.meas tran vdout0_199ck210 FIND v(dout0_199) AT=110.025n

.meas tran vdout0_200ck210 FIND v(dout0_200) AT=110.025n

.meas tran vdout0_201ck210 FIND v(dout0_201) AT=110.025n

.meas tran vdout0_202ck210 FIND v(dout0_202) AT=110.025n

.meas tran vdout0_203ck210 FIND v(dout0_203) AT=110.025n

.meas tran vdout0_204ck210 FIND v(dout0_204) AT=110.025n

.meas tran vdout0_205ck210 FIND v(dout0_205) AT=110.025n

.meas tran vdout0_206ck210 FIND v(dout0_206) AT=110.025n

.meas tran vdout0_207ck210 FIND v(dout0_207) AT=110.025n

.meas tran vdout0_208ck210 FIND v(dout0_208) AT=110.025n

.meas tran vdout0_209ck210 FIND v(dout0_209) AT=110.025n

.meas tran vdout0_210ck210 FIND v(dout0_210) AT=110.025n

.meas tran vdout0_211ck210 FIND v(dout0_211) AT=110.025n

.meas tran vdout0_212ck210 FIND v(dout0_212) AT=110.025n

.meas tran vdout0_213ck210 FIND v(dout0_213) AT=110.025n

.meas tran vdout0_214ck210 FIND v(dout0_214) AT=110.025n

.meas tran vdout0_215ck210 FIND v(dout0_215) AT=110.025n

.meas tran vdout0_216ck210 FIND v(dout0_216) AT=110.025n

.meas tran vdout0_217ck210 FIND v(dout0_217) AT=110.025n

.meas tran vdout0_218ck210 FIND v(dout0_218) AT=110.025n

.meas tran vdout0_219ck210 FIND v(dout0_219) AT=110.025n

.meas tran vdout0_220ck210 FIND v(dout0_220) AT=110.025n

.meas tran vdout0_221ck210 FIND v(dout0_221) AT=110.025n

.meas tran vdout0_222ck210 FIND v(dout0_222) AT=110.025n

.meas tran vdout0_223ck210 FIND v(dout0_223) AT=110.025n

.meas tran vdout0_224ck210 FIND v(dout0_224) AT=110.025n

.meas tran vdout0_225ck210 FIND v(dout0_225) AT=110.025n

.meas tran vdout0_226ck210 FIND v(dout0_226) AT=110.025n

.meas tran vdout0_227ck210 FIND v(dout0_227) AT=110.025n

.meas tran vdout0_228ck210 FIND v(dout0_228) AT=110.025n

.meas tran vdout0_229ck210 FIND v(dout0_229) AT=110.025n

.meas tran vdout0_230ck210 FIND v(dout0_230) AT=110.025n

.meas tran vdout0_231ck210 FIND v(dout0_231) AT=110.025n

.meas tran vdout0_232ck210 FIND v(dout0_232) AT=110.025n

.meas tran vdout0_233ck210 FIND v(dout0_233) AT=110.025n

.meas tran vdout0_234ck210 FIND v(dout0_234) AT=110.025n

.meas tran vdout0_235ck210 FIND v(dout0_235) AT=110.025n

.meas tran vdout0_236ck210 FIND v(dout0_236) AT=110.025n

.meas tran vdout0_237ck210 FIND v(dout0_237) AT=110.025n

.meas tran vdout0_238ck210 FIND v(dout0_238) AT=110.025n

.meas tran vdout0_239ck210 FIND v(dout0_239) AT=110.025n

.meas tran vdout0_240ck210 FIND v(dout0_240) AT=110.025n

.meas tran vdout0_241ck210 FIND v(dout0_241) AT=110.025n

.meas tran vdout0_242ck210 FIND v(dout0_242) AT=110.025n

.meas tran vdout0_243ck210 FIND v(dout0_243) AT=110.025n

.meas tran vdout0_244ck210 FIND v(dout0_244) AT=110.025n

.meas tran vdout0_245ck210 FIND v(dout0_245) AT=110.025n

.meas tran vdout0_246ck210 FIND v(dout0_246) AT=110.025n

.meas tran vdout0_247ck210 FIND v(dout0_247) AT=110.025n

.meas tran vdout0_248ck210 FIND v(dout0_248) AT=110.025n

.meas tran vdout0_249ck210 FIND v(dout0_249) AT=110.025n

.meas tran vdout0_250ck210 FIND v(dout0_250) AT=110.025n

.meas tran vdout0_251ck210 FIND v(dout0_251) AT=110.025n

.meas tran vdout0_252ck210 FIND v(dout0_252) AT=110.025n

.meas tran vdout0_253ck210 FIND v(dout0_253) AT=110.025n

.meas tran vdout0_254ck210 FIND v(dout0_254) AT=110.025n

.meas tran vdout0_255ck210 FIND v(dout0_255) AT=110.025n

.meas tran vdout0_0ck220 FIND v(dout0_0) AT=115.025n

.meas tran vdout0_1ck220 FIND v(dout0_1) AT=115.025n

.meas tran vdout0_2ck220 FIND v(dout0_2) AT=115.025n

.meas tran vdout0_3ck220 FIND v(dout0_3) AT=115.025n

.meas tran vdout0_4ck220 FIND v(dout0_4) AT=115.025n

.meas tran vdout0_5ck220 FIND v(dout0_5) AT=115.025n

.meas tran vdout0_6ck220 FIND v(dout0_6) AT=115.025n

.meas tran vdout0_7ck220 FIND v(dout0_7) AT=115.025n

.meas tran vdout0_8ck220 FIND v(dout0_8) AT=115.025n

.meas tran vdout0_9ck220 FIND v(dout0_9) AT=115.025n

.meas tran vdout0_10ck220 FIND v(dout0_10) AT=115.025n

.meas tran vdout0_11ck220 FIND v(dout0_11) AT=115.025n

.meas tran vdout0_12ck220 FIND v(dout0_12) AT=115.025n

.meas tran vdout0_13ck220 FIND v(dout0_13) AT=115.025n

.meas tran vdout0_14ck220 FIND v(dout0_14) AT=115.025n

.meas tran vdout0_15ck220 FIND v(dout0_15) AT=115.025n

.meas tran vdout0_16ck220 FIND v(dout0_16) AT=115.025n

.meas tran vdout0_17ck220 FIND v(dout0_17) AT=115.025n

.meas tran vdout0_18ck220 FIND v(dout0_18) AT=115.025n

.meas tran vdout0_19ck220 FIND v(dout0_19) AT=115.025n

.meas tran vdout0_20ck220 FIND v(dout0_20) AT=115.025n

.meas tran vdout0_21ck220 FIND v(dout0_21) AT=115.025n

.meas tran vdout0_22ck220 FIND v(dout0_22) AT=115.025n

.meas tran vdout0_23ck220 FIND v(dout0_23) AT=115.025n

.meas tran vdout0_24ck220 FIND v(dout0_24) AT=115.025n

.meas tran vdout0_25ck220 FIND v(dout0_25) AT=115.025n

.meas tran vdout0_26ck220 FIND v(dout0_26) AT=115.025n

.meas tran vdout0_27ck220 FIND v(dout0_27) AT=115.025n

.meas tran vdout0_28ck220 FIND v(dout0_28) AT=115.025n

.meas tran vdout0_29ck220 FIND v(dout0_29) AT=115.025n

.meas tran vdout0_30ck220 FIND v(dout0_30) AT=115.025n

.meas tran vdout0_31ck220 FIND v(dout0_31) AT=115.025n

.meas tran vdout0_32ck220 FIND v(dout0_32) AT=115.025n

.meas tran vdout0_33ck220 FIND v(dout0_33) AT=115.025n

.meas tran vdout0_34ck220 FIND v(dout0_34) AT=115.025n

.meas tran vdout0_35ck220 FIND v(dout0_35) AT=115.025n

.meas tran vdout0_36ck220 FIND v(dout0_36) AT=115.025n

.meas tran vdout0_37ck220 FIND v(dout0_37) AT=115.025n

.meas tran vdout0_38ck220 FIND v(dout0_38) AT=115.025n

.meas tran vdout0_39ck220 FIND v(dout0_39) AT=115.025n

.meas tran vdout0_40ck220 FIND v(dout0_40) AT=115.025n

.meas tran vdout0_41ck220 FIND v(dout0_41) AT=115.025n

.meas tran vdout0_42ck220 FIND v(dout0_42) AT=115.025n

.meas tran vdout0_43ck220 FIND v(dout0_43) AT=115.025n

.meas tran vdout0_44ck220 FIND v(dout0_44) AT=115.025n

.meas tran vdout0_45ck220 FIND v(dout0_45) AT=115.025n

.meas tran vdout0_46ck220 FIND v(dout0_46) AT=115.025n

.meas tran vdout0_47ck220 FIND v(dout0_47) AT=115.025n

.meas tran vdout0_48ck220 FIND v(dout0_48) AT=115.025n

.meas tran vdout0_49ck220 FIND v(dout0_49) AT=115.025n

.meas tran vdout0_50ck220 FIND v(dout0_50) AT=115.025n

.meas tran vdout0_51ck220 FIND v(dout0_51) AT=115.025n

.meas tran vdout0_52ck220 FIND v(dout0_52) AT=115.025n

.meas tran vdout0_53ck220 FIND v(dout0_53) AT=115.025n

.meas tran vdout0_54ck220 FIND v(dout0_54) AT=115.025n

.meas tran vdout0_55ck220 FIND v(dout0_55) AT=115.025n

.meas tran vdout0_56ck220 FIND v(dout0_56) AT=115.025n

.meas tran vdout0_57ck220 FIND v(dout0_57) AT=115.025n

.meas tran vdout0_58ck220 FIND v(dout0_58) AT=115.025n

.meas tran vdout0_59ck220 FIND v(dout0_59) AT=115.025n

.meas tran vdout0_60ck220 FIND v(dout0_60) AT=115.025n

.meas tran vdout0_61ck220 FIND v(dout0_61) AT=115.025n

.meas tran vdout0_62ck220 FIND v(dout0_62) AT=115.025n

.meas tran vdout0_63ck220 FIND v(dout0_63) AT=115.025n

.meas tran vdout0_64ck220 FIND v(dout0_64) AT=115.025n

.meas tran vdout0_65ck220 FIND v(dout0_65) AT=115.025n

.meas tran vdout0_66ck220 FIND v(dout0_66) AT=115.025n

.meas tran vdout0_67ck220 FIND v(dout0_67) AT=115.025n

.meas tran vdout0_68ck220 FIND v(dout0_68) AT=115.025n

.meas tran vdout0_69ck220 FIND v(dout0_69) AT=115.025n

.meas tran vdout0_70ck220 FIND v(dout0_70) AT=115.025n

.meas tran vdout0_71ck220 FIND v(dout0_71) AT=115.025n

.meas tran vdout0_72ck220 FIND v(dout0_72) AT=115.025n

.meas tran vdout0_73ck220 FIND v(dout0_73) AT=115.025n

.meas tran vdout0_74ck220 FIND v(dout0_74) AT=115.025n

.meas tran vdout0_75ck220 FIND v(dout0_75) AT=115.025n

.meas tran vdout0_76ck220 FIND v(dout0_76) AT=115.025n

.meas tran vdout0_77ck220 FIND v(dout0_77) AT=115.025n

.meas tran vdout0_78ck220 FIND v(dout0_78) AT=115.025n

.meas tran vdout0_79ck220 FIND v(dout0_79) AT=115.025n

.meas tran vdout0_80ck220 FIND v(dout0_80) AT=115.025n

.meas tran vdout0_81ck220 FIND v(dout0_81) AT=115.025n

.meas tran vdout0_82ck220 FIND v(dout0_82) AT=115.025n

.meas tran vdout0_83ck220 FIND v(dout0_83) AT=115.025n

.meas tran vdout0_84ck220 FIND v(dout0_84) AT=115.025n

.meas tran vdout0_85ck220 FIND v(dout0_85) AT=115.025n

.meas tran vdout0_86ck220 FIND v(dout0_86) AT=115.025n

.meas tran vdout0_87ck220 FIND v(dout0_87) AT=115.025n

.meas tran vdout0_88ck220 FIND v(dout0_88) AT=115.025n

.meas tran vdout0_89ck220 FIND v(dout0_89) AT=115.025n

.meas tran vdout0_90ck220 FIND v(dout0_90) AT=115.025n

.meas tran vdout0_91ck220 FIND v(dout0_91) AT=115.025n

.meas tran vdout0_92ck220 FIND v(dout0_92) AT=115.025n

.meas tran vdout0_93ck220 FIND v(dout0_93) AT=115.025n

.meas tran vdout0_94ck220 FIND v(dout0_94) AT=115.025n

.meas tran vdout0_95ck220 FIND v(dout0_95) AT=115.025n

.meas tran vdout0_96ck220 FIND v(dout0_96) AT=115.025n

.meas tran vdout0_97ck220 FIND v(dout0_97) AT=115.025n

.meas tran vdout0_98ck220 FIND v(dout0_98) AT=115.025n

.meas tran vdout0_99ck220 FIND v(dout0_99) AT=115.025n

.meas tran vdout0_100ck220 FIND v(dout0_100) AT=115.025n

.meas tran vdout0_101ck220 FIND v(dout0_101) AT=115.025n

.meas tran vdout0_102ck220 FIND v(dout0_102) AT=115.025n

.meas tran vdout0_103ck220 FIND v(dout0_103) AT=115.025n

.meas tran vdout0_104ck220 FIND v(dout0_104) AT=115.025n

.meas tran vdout0_105ck220 FIND v(dout0_105) AT=115.025n

.meas tran vdout0_106ck220 FIND v(dout0_106) AT=115.025n

.meas tran vdout0_107ck220 FIND v(dout0_107) AT=115.025n

.meas tran vdout0_108ck220 FIND v(dout0_108) AT=115.025n

.meas tran vdout0_109ck220 FIND v(dout0_109) AT=115.025n

.meas tran vdout0_110ck220 FIND v(dout0_110) AT=115.025n

.meas tran vdout0_111ck220 FIND v(dout0_111) AT=115.025n

.meas tran vdout0_112ck220 FIND v(dout0_112) AT=115.025n

.meas tran vdout0_113ck220 FIND v(dout0_113) AT=115.025n

.meas tran vdout0_114ck220 FIND v(dout0_114) AT=115.025n

.meas tran vdout0_115ck220 FIND v(dout0_115) AT=115.025n

.meas tran vdout0_116ck220 FIND v(dout0_116) AT=115.025n

.meas tran vdout0_117ck220 FIND v(dout0_117) AT=115.025n

.meas tran vdout0_118ck220 FIND v(dout0_118) AT=115.025n

.meas tran vdout0_119ck220 FIND v(dout0_119) AT=115.025n

.meas tran vdout0_120ck220 FIND v(dout0_120) AT=115.025n

.meas tran vdout0_121ck220 FIND v(dout0_121) AT=115.025n

.meas tran vdout0_122ck220 FIND v(dout0_122) AT=115.025n

.meas tran vdout0_123ck220 FIND v(dout0_123) AT=115.025n

.meas tran vdout0_124ck220 FIND v(dout0_124) AT=115.025n

.meas tran vdout0_125ck220 FIND v(dout0_125) AT=115.025n

.meas tran vdout0_126ck220 FIND v(dout0_126) AT=115.025n

.meas tran vdout0_127ck220 FIND v(dout0_127) AT=115.025n

.meas tran vdout0_128ck220 FIND v(dout0_128) AT=115.025n

.meas tran vdout0_129ck220 FIND v(dout0_129) AT=115.025n

.meas tran vdout0_130ck220 FIND v(dout0_130) AT=115.025n

.meas tran vdout0_131ck220 FIND v(dout0_131) AT=115.025n

.meas tran vdout0_132ck220 FIND v(dout0_132) AT=115.025n

.meas tran vdout0_133ck220 FIND v(dout0_133) AT=115.025n

.meas tran vdout0_134ck220 FIND v(dout0_134) AT=115.025n

.meas tran vdout0_135ck220 FIND v(dout0_135) AT=115.025n

.meas tran vdout0_136ck220 FIND v(dout0_136) AT=115.025n

.meas tran vdout0_137ck220 FIND v(dout0_137) AT=115.025n

.meas tran vdout0_138ck220 FIND v(dout0_138) AT=115.025n

.meas tran vdout0_139ck220 FIND v(dout0_139) AT=115.025n

.meas tran vdout0_140ck220 FIND v(dout0_140) AT=115.025n

.meas tran vdout0_141ck220 FIND v(dout0_141) AT=115.025n

.meas tran vdout0_142ck220 FIND v(dout0_142) AT=115.025n

.meas tran vdout0_143ck220 FIND v(dout0_143) AT=115.025n

.meas tran vdout0_144ck220 FIND v(dout0_144) AT=115.025n

.meas tran vdout0_145ck220 FIND v(dout0_145) AT=115.025n

.meas tran vdout0_146ck220 FIND v(dout0_146) AT=115.025n

.meas tran vdout0_147ck220 FIND v(dout0_147) AT=115.025n

.meas tran vdout0_148ck220 FIND v(dout0_148) AT=115.025n

.meas tran vdout0_149ck220 FIND v(dout0_149) AT=115.025n

.meas tran vdout0_150ck220 FIND v(dout0_150) AT=115.025n

.meas tran vdout0_151ck220 FIND v(dout0_151) AT=115.025n

.meas tran vdout0_152ck220 FIND v(dout0_152) AT=115.025n

.meas tran vdout0_153ck220 FIND v(dout0_153) AT=115.025n

.meas tran vdout0_154ck220 FIND v(dout0_154) AT=115.025n

.meas tran vdout0_155ck220 FIND v(dout0_155) AT=115.025n

.meas tran vdout0_156ck220 FIND v(dout0_156) AT=115.025n

.meas tran vdout0_157ck220 FIND v(dout0_157) AT=115.025n

.meas tran vdout0_158ck220 FIND v(dout0_158) AT=115.025n

.meas tran vdout0_159ck220 FIND v(dout0_159) AT=115.025n

.meas tran vdout0_160ck220 FIND v(dout0_160) AT=115.025n

.meas tran vdout0_161ck220 FIND v(dout0_161) AT=115.025n

.meas tran vdout0_162ck220 FIND v(dout0_162) AT=115.025n

.meas tran vdout0_163ck220 FIND v(dout0_163) AT=115.025n

.meas tran vdout0_164ck220 FIND v(dout0_164) AT=115.025n

.meas tran vdout0_165ck220 FIND v(dout0_165) AT=115.025n

.meas tran vdout0_166ck220 FIND v(dout0_166) AT=115.025n

.meas tran vdout0_167ck220 FIND v(dout0_167) AT=115.025n

.meas tran vdout0_168ck220 FIND v(dout0_168) AT=115.025n

.meas tran vdout0_169ck220 FIND v(dout0_169) AT=115.025n

.meas tran vdout0_170ck220 FIND v(dout0_170) AT=115.025n

.meas tran vdout0_171ck220 FIND v(dout0_171) AT=115.025n

.meas tran vdout0_172ck220 FIND v(dout0_172) AT=115.025n

.meas tran vdout0_173ck220 FIND v(dout0_173) AT=115.025n

.meas tran vdout0_174ck220 FIND v(dout0_174) AT=115.025n

.meas tran vdout0_175ck220 FIND v(dout0_175) AT=115.025n

.meas tran vdout0_176ck220 FIND v(dout0_176) AT=115.025n

.meas tran vdout0_177ck220 FIND v(dout0_177) AT=115.025n

.meas tran vdout0_178ck220 FIND v(dout0_178) AT=115.025n

.meas tran vdout0_179ck220 FIND v(dout0_179) AT=115.025n

.meas tran vdout0_180ck220 FIND v(dout0_180) AT=115.025n

.meas tran vdout0_181ck220 FIND v(dout0_181) AT=115.025n

.meas tran vdout0_182ck220 FIND v(dout0_182) AT=115.025n

.meas tran vdout0_183ck220 FIND v(dout0_183) AT=115.025n

.meas tran vdout0_184ck220 FIND v(dout0_184) AT=115.025n

.meas tran vdout0_185ck220 FIND v(dout0_185) AT=115.025n

.meas tran vdout0_186ck220 FIND v(dout0_186) AT=115.025n

.meas tran vdout0_187ck220 FIND v(dout0_187) AT=115.025n

.meas tran vdout0_188ck220 FIND v(dout0_188) AT=115.025n

.meas tran vdout0_189ck220 FIND v(dout0_189) AT=115.025n

.meas tran vdout0_190ck220 FIND v(dout0_190) AT=115.025n

.meas tran vdout0_191ck220 FIND v(dout0_191) AT=115.025n

.meas tran vdout0_192ck220 FIND v(dout0_192) AT=115.025n

.meas tran vdout0_193ck220 FIND v(dout0_193) AT=115.025n

.meas tran vdout0_194ck220 FIND v(dout0_194) AT=115.025n

.meas tran vdout0_195ck220 FIND v(dout0_195) AT=115.025n

.meas tran vdout0_196ck220 FIND v(dout0_196) AT=115.025n

.meas tran vdout0_197ck220 FIND v(dout0_197) AT=115.025n

.meas tran vdout0_198ck220 FIND v(dout0_198) AT=115.025n

.meas tran vdout0_199ck220 FIND v(dout0_199) AT=115.025n

.meas tran vdout0_200ck220 FIND v(dout0_200) AT=115.025n

.meas tran vdout0_201ck220 FIND v(dout0_201) AT=115.025n

.meas tran vdout0_202ck220 FIND v(dout0_202) AT=115.025n

.meas tran vdout0_203ck220 FIND v(dout0_203) AT=115.025n

.meas tran vdout0_204ck220 FIND v(dout0_204) AT=115.025n

.meas tran vdout0_205ck220 FIND v(dout0_205) AT=115.025n

.meas tran vdout0_206ck220 FIND v(dout0_206) AT=115.025n

.meas tran vdout0_207ck220 FIND v(dout0_207) AT=115.025n

.meas tran vdout0_208ck220 FIND v(dout0_208) AT=115.025n

.meas tran vdout0_209ck220 FIND v(dout0_209) AT=115.025n

.meas tran vdout0_210ck220 FIND v(dout0_210) AT=115.025n

.meas tran vdout0_211ck220 FIND v(dout0_211) AT=115.025n

.meas tran vdout0_212ck220 FIND v(dout0_212) AT=115.025n

.meas tran vdout0_213ck220 FIND v(dout0_213) AT=115.025n

.meas tran vdout0_214ck220 FIND v(dout0_214) AT=115.025n

.meas tran vdout0_215ck220 FIND v(dout0_215) AT=115.025n

.meas tran vdout0_216ck220 FIND v(dout0_216) AT=115.025n

.meas tran vdout0_217ck220 FIND v(dout0_217) AT=115.025n

.meas tran vdout0_218ck220 FIND v(dout0_218) AT=115.025n

.meas tran vdout0_219ck220 FIND v(dout0_219) AT=115.025n

.meas tran vdout0_220ck220 FIND v(dout0_220) AT=115.025n

.meas tran vdout0_221ck220 FIND v(dout0_221) AT=115.025n

.meas tran vdout0_222ck220 FIND v(dout0_222) AT=115.025n

.meas tran vdout0_223ck220 FIND v(dout0_223) AT=115.025n

.meas tran vdout0_224ck220 FIND v(dout0_224) AT=115.025n

.meas tran vdout0_225ck220 FIND v(dout0_225) AT=115.025n

.meas tran vdout0_226ck220 FIND v(dout0_226) AT=115.025n

.meas tran vdout0_227ck220 FIND v(dout0_227) AT=115.025n

.meas tran vdout0_228ck220 FIND v(dout0_228) AT=115.025n

.meas tran vdout0_229ck220 FIND v(dout0_229) AT=115.025n

.meas tran vdout0_230ck220 FIND v(dout0_230) AT=115.025n

.meas tran vdout0_231ck220 FIND v(dout0_231) AT=115.025n

.meas tran vdout0_232ck220 FIND v(dout0_232) AT=115.025n

.meas tran vdout0_233ck220 FIND v(dout0_233) AT=115.025n

.meas tran vdout0_234ck220 FIND v(dout0_234) AT=115.025n

.meas tran vdout0_235ck220 FIND v(dout0_235) AT=115.025n

.meas tran vdout0_236ck220 FIND v(dout0_236) AT=115.025n

.meas tran vdout0_237ck220 FIND v(dout0_237) AT=115.025n

.meas tran vdout0_238ck220 FIND v(dout0_238) AT=115.025n

.meas tran vdout0_239ck220 FIND v(dout0_239) AT=115.025n

.meas tran vdout0_240ck220 FIND v(dout0_240) AT=115.025n

.meas tran vdout0_241ck220 FIND v(dout0_241) AT=115.025n

.meas tran vdout0_242ck220 FIND v(dout0_242) AT=115.025n

.meas tran vdout0_243ck220 FIND v(dout0_243) AT=115.025n

.meas tran vdout0_244ck220 FIND v(dout0_244) AT=115.025n

.meas tran vdout0_245ck220 FIND v(dout0_245) AT=115.025n

.meas tran vdout0_246ck220 FIND v(dout0_246) AT=115.025n

.meas tran vdout0_247ck220 FIND v(dout0_247) AT=115.025n

.meas tran vdout0_248ck220 FIND v(dout0_248) AT=115.025n

.meas tran vdout0_249ck220 FIND v(dout0_249) AT=115.025n

.meas tran vdout0_250ck220 FIND v(dout0_250) AT=115.025n

.meas tran vdout0_251ck220 FIND v(dout0_251) AT=115.025n

.meas tran vdout0_252ck220 FIND v(dout0_252) AT=115.025n

.meas tran vdout0_253ck220 FIND v(dout0_253) AT=115.025n

.meas tran vdout0_254ck220 FIND v(dout0_254) AT=115.025n

.meas tran vdout0_255ck220 FIND v(dout0_255) AT=115.025n

.meas tran vdout0_0ck240 FIND v(dout0_0) AT=125.025n

.meas tran vdout0_1ck240 FIND v(dout0_1) AT=125.025n

.meas tran vdout0_2ck240 FIND v(dout0_2) AT=125.025n

.meas tran vdout0_3ck240 FIND v(dout0_3) AT=125.025n

.meas tran vdout0_4ck240 FIND v(dout0_4) AT=125.025n

.meas tran vdout0_5ck240 FIND v(dout0_5) AT=125.025n

.meas tran vdout0_6ck240 FIND v(dout0_6) AT=125.025n

.meas tran vdout0_7ck240 FIND v(dout0_7) AT=125.025n

.meas tran vdout0_8ck240 FIND v(dout0_8) AT=125.025n

.meas tran vdout0_9ck240 FIND v(dout0_9) AT=125.025n

.meas tran vdout0_10ck240 FIND v(dout0_10) AT=125.025n

.meas tran vdout0_11ck240 FIND v(dout0_11) AT=125.025n

.meas tran vdout0_12ck240 FIND v(dout0_12) AT=125.025n

.meas tran vdout0_13ck240 FIND v(dout0_13) AT=125.025n

.meas tran vdout0_14ck240 FIND v(dout0_14) AT=125.025n

.meas tran vdout0_15ck240 FIND v(dout0_15) AT=125.025n

.meas tran vdout0_16ck240 FIND v(dout0_16) AT=125.025n

.meas tran vdout0_17ck240 FIND v(dout0_17) AT=125.025n

.meas tran vdout0_18ck240 FIND v(dout0_18) AT=125.025n

.meas tran vdout0_19ck240 FIND v(dout0_19) AT=125.025n

.meas tran vdout0_20ck240 FIND v(dout0_20) AT=125.025n

.meas tran vdout0_21ck240 FIND v(dout0_21) AT=125.025n

.meas tran vdout0_22ck240 FIND v(dout0_22) AT=125.025n

.meas tran vdout0_23ck240 FIND v(dout0_23) AT=125.025n

.meas tran vdout0_24ck240 FIND v(dout0_24) AT=125.025n

.meas tran vdout0_25ck240 FIND v(dout0_25) AT=125.025n

.meas tran vdout0_26ck240 FIND v(dout0_26) AT=125.025n

.meas tran vdout0_27ck240 FIND v(dout0_27) AT=125.025n

.meas tran vdout0_28ck240 FIND v(dout0_28) AT=125.025n

.meas tran vdout0_29ck240 FIND v(dout0_29) AT=125.025n

.meas tran vdout0_30ck240 FIND v(dout0_30) AT=125.025n

.meas tran vdout0_31ck240 FIND v(dout0_31) AT=125.025n

.meas tran vdout0_32ck240 FIND v(dout0_32) AT=125.025n

.meas tran vdout0_33ck240 FIND v(dout0_33) AT=125.025n

.meas tran vdout0_34ck240 FIND v(dout0_34) AT=125.025n

.meas tran vdout0_35ck240 FIND v(dout0_35) AT=125.025n

.meas tran vdout0_36ck240 FIND v(dout0_36) AT=125.025n

.meas tran vdout0_37ck240 FIND v(dout0_37) AT=125.025n

.meas tran vdout0_38ck240 FIND v(dout0_38) AT=125.025n

.meas tran vdout0_39ck240 FIND v(dout0_39) AT=125.025n

.meas tran vdout0_40ck240 FIND v(dout0_40) AT=125.025n

.meas tran vdout0_41ck240 FIND v(dout0_41) AT=125.025n

.meas tran vdout0_42ck240 FIND v(dout0_42) AT=125.025n

.meas tran vdout0_43ck240 FIND v(dout0_43) AT=125.025n

.meas tran vdout0_44ck240 FIND v(dout0_44) AT=125.025n

.meas tran vdout0_45ck240 FIND v(dout0_45) AT=125.025n

.meas tran vdout0_46ck240 FIND v(dout0_46) AT=125.025n

.meas tran vdout0_47ck240 FIND v(dout0_47) AT=125.025n

.meas tran vdout0_48ck240 FIND v(dout0_48) AT=125.025n

.meas tran vdout0_49ck240 FIND v(dout0_49) AT=125.025n

.meas tran vdout0_50ck240 FIND v(dout0_50) AT=125.025n

.meas tran vdout0_51ck240 FIND v(dout0_51) AT=125.025n

.meas tran vdout0_52ck240 FIND v(dout0_52) AT=125.025n

.meas tran vdout0_53ck240 FIND v(dout0_53) AT=125.025n

.meas tran vdout0_54ck240 FIND v(dout0_54) AT=125.025n

.meas tran vdout0_55ck240 FIND v(dout0_55) AT=125.025n

.meas tran vdout0_56ck240 FIND v(dout0_56) AT=125.025n

.meas tran vdout0_57ck240 FIND v(dout0_57) AT=125.025n

.meas tran vdout0_58ck240 FIND v(dout0_58) AT=125.025n

.meas tran vdout0_59ck240 FIND v(dout0_59) AT=125.025n

.meas tran vdout0_60ck240 FIND v(dout0_60) AT=125.025n

.meas tran vdout0_61ck240 FIND v(dout0_61) AT=125.025n

.meas tran vdout0_62ck240 FIND v(dout0_62) AT=125.025n

.meas tran vdout0_63ck240 FIND v(dout0_63) AT=125.025n

.meas tran vdout0_64ck240 FIND v(dout0_64) AT=125.025n

.meas tran vdout0_65ck240 FIND v(dout0_65) AT=125.025n

.meas tran vdout0_66ck240 FIND v(dout0_66) AT=125.025n

.meas tran vdout0_67ck240 FIND v(dout0_67) AT=125.025n

.meas tran vdout0_68ck240 FIND v(dout0_68) AT=125.025n

.meas tran vdout0_69ck240 FIND v(dout0_69) AT=125.025n

.meas tran vdout0_70ck240 FIND v(dout0_70) AT=125.025n

.meas tran vdout0_71ck240 FIND v(dout0_71) AT=125.025n

.meas tran vdout0_72ck240 FIND v(dout0_72) AT=125.025n

.meas tran vdout0_73ck240 FIND v(dout0_73) AT=125.025n

.meas tran vdout0_74ck240 FIND v(dout0_74) AT=125.025n

.meas tran vdout0_75ck240 FIND v(dout0_75) AT=125.025n

.meas tran vdout0_76ck240 FIND v(dout0_76) AT=125.025n

.meas tran vdout0_77ck240 FIND v(dout0_77) AT=125.025n

.meas tran vdout0_78ck240 FIND v(dout0_78) AT=125.025n

.meas tran vdout0_79ck240 FIND v(dout0_79) AT=125.025n

.meas tran vdout0_80ck240 FIND v(dout0_80) AT=125.025n

.meas tran vdout0_81ck240 FIND v(dout0_81) AT=125.025n

.meas tran vdout0_82ck240 FIND v(dout0_82) AT=125.025n

.meas tran vdout0_83ck240 FIND v(dout0_83) AT=125.025n

.meas tran vdout0_84ck240 FIND v(dout0_84) AT=125.025n

.meas tran vdout0_85ck240 FIND v(dout0_85) AT=125.025n

.meas tran vdout0_86ck240 FIND v(dout0_86) AT=125.025n

.meas tran vdout0_87ck240 FIND v(dout0_87) AT=125.025n

.meas tran vdout0_88ck240 FIND v(dout0_88) AT=125.025n

.meas tran vdout0_89ck240 FIND v(dout0_89) AT=125.025n

.meas tran vdout0_90ck240 FIND v(dout0_90) AT=125.025n

.meas tran vdout0_91ck240 FIND v(dout0_91) AT=125.025n

.meas tran vdout0_92ck240 FIND v(dout0_92) AT=125.025n

.meas tran vdout0_93ck240 FIND v(dout0_93) AT=125.025n

.meas tran vdout0_94ck240 FIND v(dout0_94) AT=125.025n

.meas tran vdout0_95ck240 FIND v(dout0_95) AT=125.025n

.meas tran vdout0_96ck240 FIND v(dout0_96) AT=125.025n

.meas tran vdout0_97ck240 FIND v(dout0_97) AT=125.025n

.meas tran vdout0_98ck240 FIND v(dout0_98) AT=125.025n

.meas tran vdout0_99ck240 FIND v(dout0_99) AT=125.025n

.meas tran vdout0_100ck240 FIND v(dout0_100) AT=125.025n

.meas tran vdout0_101ck240 FIND v(dout0_101) AT=125.025n

.meas tran vdout0_102ck240 FIND v(dout0_102) AT=125.025n

.meas tran vdout0_103ck240 FIND v(dout0_103) AT=125.025n

.meas tran vdout0_104ck240 FIND v(dout0_104) AT=125.025n

.meas tran vdout0_105ck240 FIND v(dout0_105) AT=125.025n

.meas tran vdout0_106ck240 FIND v(dout0_106) AT=125.025n

.meas tran vdout0_107ck240 FIND v(dout0_107) AT=125.025n

.meas tran vdout0_108ck240 FIND v(dout0_108) AT=125.025n

.meas tran vdout0_109ck240 FIND v(dout0_109) AT=125.025n

.meas tran vdout0_110ck240 FIND v(dout0_110) AT=125.025n

.meas tran vdout0_111ck240 FIND v(dout0_111) AT=125.025n

.meas tran vdout0_112ck240 FIND v(dout0_112) AT=125.025n

.meas tran vdout0_113ck240 FIND v(dout0_113) AT=125.025n

.meas tran vdout0_114ck240 FIND v(dout0_114) AT=125.025n

.meas tran vdout0_115ck240 FIND v(dout0_115) AT=125.025n

.meas tran vdout0_116ck240 FIND v(dout0_116) AT=125.025n

.meas tran vdout0_117ck240 FIND v(dout0_117) AT=125.025n

.meas tran vdout0_118ck240 FIND v(dout0_118) AT=125.025n

.meas tran vdout0_119ck240 FIND v(dout0_119) AT=125.025n

.meas tran vdout0_120ck240 FIND v(dout0_120) AT=125.025n

.meas tran vdout0_121ck240 FIND v(dout0_121) AT=125.025n

.meas tran vdout0_122ck240 FIND v(dout0_122) AT=125.025n

.meas tran vdout0_123ck240 FIND v(dout0_123) AT=125.025n

.meas tran vdout0_124ck240 FIND v(dout0_124) AT=125.025n

.meas tran vdout0_125ck240 FIND v(dout0_125) AT=125.025n

.meas tran vdout0_126ck240 FIND v(dout0_126) AT=125.025n

.meas tran vdout0_127ck240 FIND v(dout0_127) AT=125.025n

.meas tran vdout0_128ck240 FIND v(dout0_128) AT=125.025n

.meas tran vdout0_129ck240 FIND v(dout0_129) AT=125.025n

.meas tran vdout0_130ck240 FIND v(dout0_130) AT=125.025n

.meas tran vdout0_131ck240 FIND v(dout0_131) AT=125.025n

.meas tran vdout0_132ck240 FIND v(dout0_132) AT=125.025n

.meas tran vdout0_133ck240 FIND v(dout0_133) AT=125.025n

.meas tran vdout0_134ck240 FIND v(dout0_134) AT=125.025n

.meas tran vdout0_135ck240 FIND v(dout0_135) AT=125.025n

.meas tran vdout0_136ck240 FIND v(dout0_136) AT=125.025n

.meas tran vdout0_137ck240 FIND v(dout0_137) AT=125.025n

.meas tran vdout0_138ck240 FIND v(dout0_138) AT=125.025n

.meas tran vdout0_139ck240 FIND v(dout0_139) AT=125.025n

.meas tran vdout0_140ck240 FIND v(dout0_140) AT=125.025n

.meas tran vdout0_141ck240 FIND v(dout0_141) AT=125.025n

.meas tran vdout0_142ck240 FIND v(dout0_142) AT=125.025n

.meas tran vdout0_143ck240 FIND v(dout0_143) AT=125.025n

.meas tran vdout0_144ck240 FIND v(dout0_144) AT=125.025n

.meas tran vdout0_145ck240 FIND v(dout0_145) AT=125.025n

.meas tran vdout0_146ck240 FIND v(dout0_146) AT=125.025n

.meas tran vdout0_147ck240 FIND v(dout0_147) AT=125.025n

.meas tran vdout0_148ck240 FIND v(dout0_148) AT=125.025n

.meas tran vdout0_149ck240 FIND v(dout0_149) AT=125.025n

.meas tran vdout0_150ck240 FIND v(dout0_150) AT=125.025n

.meas tran vdout0_151ck240 FIND v(dout0_151) AT=125.025n

.meas tran vdout0_152ck240 FIND v(dout0_152) AT=125.025n

.meas tran vdout0_153ck240 FIND v(dout0_153) AT=125.025n

.meas tran vdout0_154ck240 FIND v(dout0_154) AT=125.025n

.meas tran vdout0_155ck240 FIND v(dout0_155) AT=125.025n

.meas tran vdout0_156ck240 FIND v(dout0_156) AT=125.025n

.meas tran vdout0_157ck240 FIND v(dout0_157) AT=125.025n

.meas tran vdout0_158ck240 FIND v(dout0_158) AT=125.025n

.meas tran vdout0_159ck240 FIND v(dout0_159) AT=125.025n

.meas tran vdout0_160ck240 FIND v(dout0_160) AT=125.025n

.meas tran vdout0_161ck240 FIND v(dout0_161) AT=125.025n

.meas tran vdout0_162ck240 FIND v(dout0_162) AT=125.025n

.meas tran vdout0_163ck240 FIND v(dout0_163) AT=125.025n

.meas tran vdout0_164ck240 FIND v(dout0_164) AT=125.025n

.meas tran vdout0_165ck240 FIND v(dout0_165) AT=125.025n

.meas tran vdout0_166ck240 FIND v(dout0_166) AT=125.025n

.meas tran vdout0_167ck240 FIND v(dout0_167) AT=125.025n

.meas tran vdout0_168ck240 FIND v(dout0_168) AT=125.025n

.meas tran vdout0_169ck240 FIND v(dout0_169) AT=125.025n

.meas tran vdout0_170ck240 FIND v(dout0_170) AT=125.025n

.meas tran vdout0_171ck240 FIND v(dout0_171) AT=125.025n

.meas tran vdout0_172ck240 FIND v(dout0_172) AT=125.025n

.meas tran vdout0_173ck240 FIND v(dout0_173) AT=125.025n

.meas tran vdout0_174ck240 FIND v(dout0_174) AT=125.025n

.meas tran vdout0_175ck240 FIND v(dout0_175) AT=125.025n

.meas tran vdout0_176ck240 FIND v(dout0_176) AT=125.025n

.meas tran vdout0_177ck240 FIND v(dout0_177) AT=125.025n

.meas tran vdout0_178ck240 FIND v(dout0_178) AT=125.025n

.meas tran vdout0_179ck240 FIND v(dout0_179) AT=125.025n

.meas tran vdout0_180ck240 FIND v(dout0_180) AT=125.025n

.meas tran vdout0_181ck240 FIND v(dout0_181) AT=125.025n

.meas tran vdout0_182ck240 FIND v(dout0_182) AT=125.025n

.meas tran vdout0_183ck240 FIND v(dout0_183) AT=125.025n

.meas tran vdout0_184ck240 FIND v(dout0_184) AT=125.025n

.meas tran vdout0_185ck240 FIND v(dout0_185) AT=125.025n

.meas tran vdout0_186ck240 FIND v(dout0_186) AT=125.025n

.meas tran vdout0_187ck240 FIND v(dout0_187) AT=125.025n

.meas tran vdout0_188ck240 FIND v(dout0_188) AT=125.025n

.meas tran vdout0_189ck240 FIND v(dout0_189) AT=125.025n

.meas tran vdout0_190ck240 FIND v(dout0_190) AT=125.025n

.meas tran vdout0_191ck240 FIND v(dout0_191) AT=125.025n

.meas tran vdout0_192ck240 FIND v(dout0_192) AT=125.025n

.meas tran vdout0_193ck240 FIND v(dout0_193) AT=125.025n

.meas tran vdout0_194ck240 FIND v(dout0_194) AT=125.025n

.meas tran vdout0_195ck240 FIND v(dout0_195) AT=125.025n

.meas tran vdout0_196ck240 FIND v(dout0_196) AT=125.025n

.meas tran vdout0_197ck240 FIND v(dout0_197) AT=125.025n

.meas tran vdout0_198ck240 FIND v(dout0_198) AT=125.025n

.meas tran vdout0_199ck240 FIND v(dout0_199) AT=125.025n

.meas tran vdout0_200ck240 FIND v(dout0_200) AT=125.025n

.meas tran vdout0_201ck240 FIND v(dout0_201) AT=125.025n

.meas tran vdout0_202ck240 FIND v(dout0_202) AT=125.025n

.meas tran vdout0_203ck240 FIND v(dout0_203) AT=125.025n

.meas tran vdout0_204ck240 FIND v(dout0_204) AT=125.025n

.meas tran vdout0_205ck240 FIND v(dout0_205) AT=125.025n

.meas tran vdout0_206ck240 FIND v(dout0_206) AT=125.025n

.meas tran vdout0_207ck240 FIND v(dout0_207) AT=125.025n

.meas tran vdout0_208ck240 FIND v(dout0_208) AT=125.025n

.meas tran vdout0_209ck240 FIND v(dout0_209) AT=125.025n

.meas tran vdout0_210ck240 FIND v(dout0_210) AT=125.025n

.meas tran vdout0_211ck240 FIND v(dout0_211) AT=125.025n

.meas tran vdout0_212ck240 FIND v(dout0_212) AT=125.025n

.meas tran vdout0_213ck240 FIND v(dout0_213) AT=125.025n

.meas tran vdout0_214ck240 FIND v(dout0_214) AT=125.025n

.meas tran vdout0_215ck240 FIND v(dout0_215) AT=125.025n

.meas tran vdout0_216ck240 FIND v(dout0_216) AT=125.025n

.meas tran vdout0_217ck240 FIND v(dout0_217) AT=125.025n

.meas tran vdout0_218ck240 FIND v(dout0_218) AT=125.025n

.meas tran vdout0_219ck240 FIND v(dout0_219) AT=125.025n

.meas tran vdout0_220ck240 FIND v(dout0_220) AT=125.025n

.meas tran vdout0_221ck240 FIND v(dout0_221) AT=125.025n

.meas tran vdout0_222ck240 FIND v(dout0_222) AT=125.025n

.meas tran vdout0_223ck240 FIND v(dout0_223) AT=125.025n

.meas tran vdout0_224ck240 FIND v(dout0_224) AT=125.025n

.meas tran vdout0_225ck240 FIND v(dout0_225) AT=125.025n

.meas tran vdout0_226ck240 FIND v(dout0_226) AT=125.025n

.meas tran vdout0_227ck240 FIND v(dout0_227) AT=125.025n

.meas tran vdout0_228ck240 FIND v(dout0_228) AT=125.025n

.meas tran vdout0_229ck240 FIND v(dout0_229) AT=125.025n

.meas tran vdout0_230ck240 FIND v(dout0_230) AT=125.025n

.meas tran vdout0_231ck240 FIND v(dout0_231) AT=125.025n

.meas tran vdout0_232ck240 FIND v(dout0_232) AT=125.025n

.meas tran vdout0_233ck240 FIND v(dout0_233) AT=125.025n

.meas tran vdout0_234ck240 FIND v(dout0_234) AT=125.025n

.meas tran vdout0_235ck240 FIND v(dout0_235) AT=125.025n

.meas tran vdout0_236ck240 FIND v(dout0_236) AT=125.025n

.meas tran vdout0_237ck240 FIND v(dout0_237) AT=125.025n

.meas tran vdout0_238ck240 FIND v(dout0_238) AT=125.025n

.meas tran vdout0_239ck240 FIND v(dout0_239) AT=125.025n

.meas tran vdout0_240ck240 FIND v(dout0_240) AT=125.025n

.meas tran vdout0_241ck240 FIND v(dout0_241) AT=125.025n

.meas tran vdout0_242ck240 FIND v(dout0_242) AT=125.025n

.meas tran vdout0_243ck240 FIND v(dout0_243) AT=125.025n

.meas tran vdout0_244ck240 FIND v(dout0_244) AT=125.025n

.meas tran vdout0_245ck240 FIND v(dout0_245) AT=125.025n

.meas tran vdout0_246ck240 FIND v(dout0_246) AT=125.025n

.meas tran vdout0_247ck240 FIND v(dout0_247) AT=125.025n

.meas tran vdout0_248ck240 FIND v(dout0_248) AT=125.025n

.meas tran vdout0_249ck240 FIND v(dout0_249) AT=125.025n

.meas tran vdout0_250ck240 FIND v(dout0_250) AT=125.025n

.meas tran vdout0_251ck240 FIND v(dout0_251) AT=125.025n

.meas tran vdout0_252ck240 FIND v(dout0_252) AT=125.025n

.meas tran vdout0_253ck240 FIND v(dout0_253) AT=125.025n

.meas tran vdout0_254ck240 FIND v(dout0_254) AT=125.025n

.meas tran vdout0_255ck240 FIND v(dout0_255) AT=125.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_128ck280 FIND v(dout0_128) AT=145.025n

.meas tran vdout0_129ck280 FIND v(dout0_129) AT=145.025n

.meas tran vdout0_130ck280 FIND v(dout0_130) AT=145.025n

.meas tran vdout0_131ck280 FIND v(dout0_131) AT=145.025n

.meas tran vdout0_132ck280 FIND v(dout0_132) AT=145.025n

.meas tran vdout0_133ck280 FIND v(dout0_133) AT=145.025n

.meas tran vdout0_134ck280 FIND v(dout0_134) AT=145.025n

.meas tran vdout0_135ck280 FIND v(dout0_135) AT=145.025n

.meas tran vdout0_136ck280 FIND v(dout0_136) AT=145.025n

.meas tran vdout0_137ck280 FIND v(dout0_137) AT=145.025n

.meas tran vdout0_138ck280 FIND v(dout0_138) AT=145.025n

.meas tran vdout0_139ck280 FIND v(dout0_139) AT=145.025n

.meas tran vdout0_140ck280 FIND v(dout0_140) AT=145.025n

.meas tran vdout0_141ck280 FIND v(dout0_141) AT=145.025n

.meas tran vdout0_142ck280 FIND v(dout0_142) AT=145.025n

.meas tran vdout0_143ck280 FIND v(dout0_143) AT=145.025n

.meas tran vdout0_144ck280 FIND v(dout0_144) AT=145.025n

.meas tran vdout0_145ck280 FIND v(dout0_145) AT=145.025n

.meas tran vdout0_146ck280 FIND v(dout0_146) AT=145.025n

.meas tran vdout0_147ck280 FIND v(dout0_147) AT=145.025n

.meas tran vdout0_148ck280 FIND v(dout0_148) AT=145.025n

.meas tran vdout0_149ck280 FIND v(dout0_149) AT=145.025n

.meas tran vdout0_150ck280 FIND v(dout0_150) AT=145.025n

.meas tran vdout0_151ck280 FIND v(dout0_151) AT=145.025n

.meas tran vdout0_152ck280 FIND v(dout0_152) AT=145.025n

.meas tran vdout0_153ck280 FIND v(dout0_153) AT=145.025n

.meas tran vdout0_154ck280 FIND v(dout0_154) AT=145.025n

.meas tran vdout0_155ck280 FIND v(dout0_155) AT=145.025n

.meas tran vdout0_156ck280 FIND v(dout0_156) AT=145.025n

.meas tran vdout0_157ck280 FIND v(dout0_157) AT=145.025n

.meas tran vdout0_158ck280 FIND v(dout0_158) AT=145.025n

.meas tran vdout0_159ck280 FIND v(dout0_159) AT=145.025n

.meas tran vdout0_160ck280 FIND v(dout0_160) AT=145.025n

.meas tran vdout0_161ck280 FIND v(dout0_161) AT=145.025n

.meas tran vdout0_162ck280 FIND v(dout0_162) AT=145.025n

.meas tran vdout0_163ck280 FIND v(dout0_163) AT=145.025n

.meas tran vdout0_164ck280 FIND v(dout0_164) AT=145.025n

.meas tran vdout0_165ck280 FIND v(dout0_165) AT=145.025n

.meas tran vdout0_166ck280 FIND v(dout0_166) AT=145.025n

.meas tran vdout0_167ck280 FIND v(dout0_167) AT=145.025n

.meas tran vdout0_168ck280 FIND v(dout0_168) AT=145.025n

.meas tran vdout0_169ck280 FIND v(dout0_169) AT=145.025n

.meas tran vdout0_170ck280 FIND v(dout0_170) AT=145.025n

.meas tran vdout0_171ck280 FIND v(dout0_171) AT=145.025n

.meas tran vdout0_172ck280 FIND v(dout0_172) AT=145.025n

.meas tran vdout0_173ck280 FIND v(dout0_173) AT=145.025n

.meas tran vdout0_174ck280 FIND v(dout0_174) AT=145.025n

.meas tran vdout0_175ck280 FIND v(dout0_175) AT=145.025n

.meas tran vdout0_176ck280 FIND v(dout0_176) AT=145.025n

.meas tran vdout0_177ck280 FIND v(dout0_177) AT=145.025n

.meas tran vdout0_178ck280 FIND v(dout0_178) AT=145.025n

.meas tran vdout0_179ck280 FIND v(dout0_179) AT=145.025n

.meas tran vdout0_180ck280 FIND v(dout0_180) AT=145.025n

.meas tran vdout0_181ck280 FIND v(dout0_181) AT=145.025n

.meas tran vdout0_182ck280 FIND v(dout0_182) AT=145.025n

.meas tran vdout0_183ck280 FIND v(dout0_183) AT=145.025n

.meas tran vdout0_184ck280 FIND v(dout0_184) AT=145.025n

.meas tran vdout0_185ck280 FIND v(dout0_185) AT=145.025n

.meas tran vdout0_186ck280 FIND v(dout0_186) AT=145.025n

.meas tran vdout0_187ck280 FIND v(dout0_187) AT=145.025n

.meas tran vdout0_188ck280 FIND v(dout0_188) AT=145.025n

.meas tran vdout0_189ck280 FIND v(dout0_189) AT=145.025n

.meas tran vdout0_190ck280 FIND v(dout0_190) AT=145.025n

.meas tran vdout0_191ck280 FIND v(dout0_191) AT=145.025n

.meas tran vdout0_192ck280 FIND v(dout0_192) AT=145.025n

.meas tran vdout0_193ck280 FIND v(dout0_193) AT=145.025n

.meas tran vdout0_194ck280 FIND v(dout0_194) AT=145.025n

.meas tran vdout0_195ck280 FIND v(dout0_195) AT=145.025n

.meas tran vdout0_196ck280 FIND v(dout0_196) AT=145.025n

.meas tran vdout0_197ck280 FIND v(dout0_197) AT=145.025n

.meas tran vdout0_198ck280 FIND v(dout0_198) AT=145.025n

.meas tran vdout0_199ck280 FIND v(dout0_199) AT=145.025n

.meas tran vdout0_200ck280 FIND v(dout0_200) AT=145.025n

.meas tran vdout0_201ck280 FIND v(dout0_201) AT=145.025n

.meas tran vdout0_202ck280 FIND v(dout0_202) AT=145.025n

.meas tran vdout0_203ck280 FIND v(dout0_203) AT=145.025n

.meas tran vdout0_204ck280 FIND v(dout0_204) AT=145.025n

.meas tran vdout0_205ck280 FIND v(dout0_205) AT=145.025n

.meas tran vdout0_206ck280 FIND v(dout0_206) AT=145.025n

.meas tran vdout0_207ck280 FIND v(dout0_207) AT=145.025n

.meas tran vdout0_208ck280 FIND v(dout0_208) AT=145.025n

.meas tran vdout0_209ck280 FIND v(dout0_209) AT=145.025n

.meas tran vdout0_210ck280 FIND v(dout0_210) AT=145.025n

.meas tran vdout0_211ck280 FIND v(dout0_211) AT=145.025n

.meas tran vdout0_212ck280 FIND v(dout0_212) AT=145.025n

.meas tran vdout0_213ck280 FIND v(dout0_213) AT=145.025n

.meas tran vdout0_214ck280 FIND v(dout0_214) AT=145.025n

.meas tran vdout0_215ck280 FIND v(dout0_215) AT=145.025n

.meas tran vdout0_216ck280 FIND v(dout0_216) AT=145.025n

.meas tran vdout0_217ck280 FIND v(dout0_217) AT=145.025n

.meas tran vdout0_218ck280 FIND v(dout0_218) AT=145.025n

.meas tran vdout0_219ck280 FIND v(dout0_219) AT=145.025n

.meas tran vdout0_220ck280 FIND v(dout0_220) AT=145.025n

.meas tran vdout0_221ck280 FIND v(dout0_221) AT=145.025n

.meas tran vdout0_222ck280 FIND v(dout0_222) AT=145.025n

.meas tran vdout0_223ck280 FIND v(dout0_223) AT=145.025n

.meas tran vdout0_224ck280 FIND v(dout0_224) AT=145.025n

.meas tran vdout0_225ck280 FIND v(dout0_225) AT=145.025n

.meas tran vdout0_226ck280 FIND v(dout0_226) AT=145.025n

.meas tran vdout0_227ck280 FIND v(dout0_227) AT=145.025n

.meas tran vdout0_228ck280 FIND v(dout0_228) AT=145.025n

.meas tran vdout0_229ck280 FIND v(dout0_229) AT=145.025n

.meas tran vdout0_230ck280 FIND v(dout0_230) AT=145.025n

.meas tran vdout0_231ck280 FIND v(dout0_231) AT=145.025n

.meas tran vdout0_232ck280 FIND v(dout0_232) AT=145.025n

.meas tran vdout0_233ck280 FIND v(dout0_233) AT=145.025n

.meas tran vdout0_234ck280 FIND v(dout0_234) AT=145.025n

.meas tran vdout0_235ck280 FIND v(dout0_235) AT=145.025n

.meas tran vdout0_236ck280 FIND v(dout0_236) AT=145.025n

.meas tran vdout0_237ck280 FIND v(dout0_237) AT=145.025n

.meas tran vdout0_238ck280 FIND v(dout0_238) AT=145.025n

.meas tran vdout0_239ck280 FIND v(dout0_239) AT=145.025n

.meas tran vdout0_240ck280 FIND v(dout0_240) AT=145.025n

.meas tran vdout0_241ck280 FIND v(dout0_241) AT=145.025n

.meas tran vdout0_242ck280 FIND v(dout0_242) AT=145.025n

.meas tran vdout0_243ck280 FIND v(dout0_243) AT=145.025n

.meas tran vdout0_244ck280 FIND v(dout0_244) AT=145.025n

.meas tran vdout0_245ck280 FIND v(dout0_245) AT=145.025n

.meas tran vdout0_246ck280 FIND v(dout0_246) AT=145.025n

.meas tran vdout0_247ck280 FIND v(dout0_247) AT=145.025n

.meas tran vdout0_248ck280 FIND v(dout0_248) AT=145.025n

.meas tran vdout0_249ck280 FIND v(dout0_249) AT=145.025n

.meas tran vdout0_250ck280 FIND v(dout0_250) AT=145.025n

.meas tran vdout0_251ck280 FIND v(dout0_251) AT=145.025n

.meas tran vdout0_252ck280 FIND v(dout0_252) AT=145.025n

.meas tran vdout0_253ck280 FIND v(dout0_253) AT=145.025n

.meas tran vdout0_254ck280 FIND v(dout0_254) AT=145.025n

.meas tran vdout0_255ck280 FIND v(dout0_255) AT=145.025n

.meas tran vdout0_0ck300 FIND v(dout0_0) AT=155.025n

.meas tran vdout0_1ck300 FIND v(dout0_1) AT=155.025n

.meas tran vdout0_2ck300 FIND v(dout0_2) AT=155.025n

.meas tran vdout0_3ck300 FIND v(dout0_3) AT=155.025n

.meas tran vdout0_4ck300 FIND v(dout0_4) AT=155.025n

.meas tran vdout0_5ck300 FIND v(dout0_5) AT=155.025n

.meas tran vdout0_6ck300 FIND v(dout0_6) AT=155.025n

.meas tran vdout0_7ck300 FIND v(dout0_7) AT=155.025n

.meas tran vdout0_8ck300 FIND v(dout0_8) AT=155.025n

.meas tran vdout0_9ck300 FIND v(dout0_9) AT=155.025n

.meas tran vdout0_10ck300 FIND v(dout0_10) AT=155.025n

.meas tran vdout0_11ck300 FIND v(dout0_11) AT=155.025n

.meas tran vdout0_12ck300 FIND v(dout0_12) AT=155.025n

.meas tran vdout0_13ck300 FIND v(dout0_13) AT=155.025n

.meas tran vdout0_14ck300 FIND v(dout0_14) AT=155.025n

.meas tran vdout0_15ck300 FIND v(dout0_15) AT=155.025n

.meas tran vdout0_16ck300 FIND v(dout0_16) AT=155.025n

.meas tran vdout0_17ck300 FIND v(dout0_17) AT=155.025n

.meas tran vdout0_18ck300 FIND v(dout0_18) AT=155.025n

.meas tran vdout0_19ck300 FIND v(dout0_19) AT=155.025n

.meas tran vdout0_20ck300 FIND v(dout0_20) AT=155.025n

.meas tran vdout0_21ck300 FIND v(dout0_21) AT=155.025n

.meas tran vdout0_22ck300 FIND v(dout0_22) AT=155.025n

.meas tran vdout0_23ck300 FIND v(dout0_23) AT=155.025n

.meas tran vdout0_24ck300 FIND v(dout0_24) AT=155.025n

.meas tran vdout0_25ck300 FIND v(dout0_25) AT=155.025n

.meas tran vdout0_26ck300 FIND v(dout0_26) AT=155.025n

.meas tran vdout0_27ck300 FIND v(dout0_27) AT=155.025n

.meas tran vdout0_28ck300 FIND v(dout0_28) AT=155.025n

.meas tran vdout0_29ck300 FIND v(dout0_29) AT=155.025n

.meas tran vdout0_30ck300 FIND v(dout0_30) AT=155.025n

.meas tran vdout0_31ck300 FIND v(dout0_31) AT=155.025n

.meas tran vdout0_32ck300 FIND v(dout0_32) AT=155.025n

.meas tran vdout0_33ck300 FIND v(dout0_33) AT=155.025n

.meas tran vdout0_34ck300 FIND v(dout0_34) AT=155.025n

.meas tran vdout0_35ck300 FIND v(dout0_35) AT=155.025n

.meas tran vdout0_36ck300 FIND v(dout0_36) AT=155.025n

.meas tran vdout0_37ck300 FIND v(dout0_37) AT=155.025n

.meas tran vdout0_38ck300 FIND v(dout0_38) AT=155.025n

.meas tran vdout0_39ck300 FIND v(dout0_39) AT=155.025n

.meas tran vdout0_40ck300 FIND v(dout0_40) AT=155.025n

.meas tran vdout0_41ck300 FIND v(dout0_41) AT=155.025n

.meas tran vdout0_42ck300 FIND v(dout0_42) AT=155.025n

.meas tran vdout0_43ck300 FIND v(dout0_43) AT=155.025n

.meas tran vdout0_44ck300 FIND v(dout0_44) AT=155.025n

.meas tran vdout0_45ck300 FIND v(dout0_45) AT=155.025n

.meas tran vdout0_46ck300 FIND v(dout0_46) AT=155.025n

.meas tran vdout0_47ck300 FIND v(dout0_47) AT=155.025n

.meas tran vdout0_48ck300 FIND v(dout0_48) AT=155.025n

.meas tran vdout0_49ck300 FIND v(dout0_49) AT=155.025n

.meas tran vdout0_50ck300 FIND v(dout0_50) AT=155.025n

.meas tran vdout0_51ck300 FIND v(dout0_51) AT=155.025n

.meas tran vdout0_52ck300 FIND v(dout0_52) AT=155.025n

.meas tran vdout0_53ck300 FIND v(dout0_53) AT=155.025n

.meas tran vdout0_54ck300 FIND v(dout0_54) AT=155.025n

.meas tran vdout0_55ck300 FIND v(dout0_55) AT=155.025n

.meas tran vdout0_56ck300 FIND v(dout0_56) AT=155.025n

.meas tran vdout0_57ck300 FIND v(dout0_57) AT=155.025n

.meas tran vdout0_58ck300 FIND v(dout0_58) AT=155.025n

.meas tran vdout0_59ck300 FIND v(dout0_59) AT=155.025n

.meas tran vdout0_60ck300 FIND v(dout0_60) AT=155.025n

.meas tran vdout0_61ck300 FIND v(dout0_61) AT=155.025n

.meas tran vdout0_62ck300 FIND v(dout0_62) AT=155.025n

.meas tran vdout0_63ck300 FIND v(dout0_63) AT=155.025n

.meas tran vdout0_64ck300 FIND v(dout0_64) AT=155.025n

.meas tran vdout0_65ck300 FIND v(dout0_65) AT=155.025n

.meas tran vdout0_66ck300 FIND v(dout0_66) AT=155.025n

.meas tran vdout0_67ck300 FIND v(dout0_67) AT=155.025n

.meas tran vdout0_68ck300 FIND v(dout0_68) AT=155.025n

.meas tran vdout0_69ck300 FIND v(dout0_69) AT=155.025n

.meas tran vdout0_70ck300 FIND v(dout0_70) AT=155.025n

.meas tran vdout0_71ck300 FIND v(dout0_71) AT=155.025n

.meas tran vdout0_72ck300 FIND v(dout0_72) AT=155.025n

.meas tran vdout0_73ck300 FIND v(dout0_73) AT=155.025n

.meas tran vdout0_74ck300 FIND v(dout0_74) AT=155.025n

.meas tran vdout0_75ck300 FIND v(dout0_75) AT=155.025n

.meas tran vdout0_76ck300 FIND v(dout0_76) AT=155.025n

.meas tran vdout0_77ck300 FIND v(dout0_77) AT=155.025n

.meas tran vdout0_78ck300 FIND v(dout0_78) AT=155.025n

.meas tran vdout0_79ck300 FIND v(dout0_79) AT=155.025n

.meas tran vdout0_80ck300 FIND v(dout0_80) AT=155.025n

.meas tran vdout0_81ck300 FIND v(dout0_81) AT=155.025n

.meas tran vdout0_82ck300 FIND v(dout0_82) AT=155.025n

.meas tran vdout0_83ck300 FIND v(dout0_83) AT=155.025n

.meas tran vdout0_84ck300 FIND v(dout0_84) AT=155.025n

.meas tran vdout0_85ck300 FIND v(dout0_85) AT=155.025n

.meas tran vdout0_86ck300 FIND v(dout0_86) AT=155.025n

.meas tran vdout0_87ck300 FIND v(dout0_87) AT=155.025n

.meas tran vdout0_88ck300 FIND v(dout0_88) AT=155.025n

.meas tran vdout0_89ck300 FIND v(dout0_89) AT=155.025n

.meas tran vdout0_90ck300 FIND v(dout0_90) AT=155.025n

.meas tran vdout0_91ck300 FIND v(dout0_91) AT=155.025n

.meas tran vdout0_92ck300 FIND v(dout0_92) AT=155.025n

.meas tran vdout0_93ck300 FIND v(dout0_93) AT=155.025n

.meas tran vdout0_94ck300 FIND v(dout0_94) AT=155.025n

.meas tran vdout0_95ck300 FIND v(dout0_95) AT=155.025n

.meas tran vdout0_96ck300 FIND v(dout0_96) AT=155.025n

.meas tran vdout0_97ck300 FIND v(dout0_97) AT=155.025n

.meas tran vdout0_98ck300 FIND v(dout0_98) AT=155.025n

.meas tran vdout0_99ck300 FIND v(dout0_99) AT=155.025n

.meas tran vdout0_100ck300 FIND v(dout0_100) AT=155.025n

.meas tran vdout0_101ck300 FIND v(dout0_101) AT=155.025n

.meas tran vdout0_102ck300 FIND v(dout0_102) AT=155.025n

.meas tran vdout0_103ck300 FIND v(dout0_103) AT=155.025n

.meas tran vdout0_104ck300 FIND v(dout0_104) AT=155.025n

.meas tran vdout0_105ck300 FIND v(dout0_105) AT=155.025n

.meas tran vdout0_106ck300 FIND v(dout0_106) AT=155.025n

.meas tran vdout0_107ck300 FIND v(dout0_107) AT=155.025n

.meas tran vdout0_108ck300 FIND v(dout0_108) AT=155.025n

.meas tran vdout0_109ck300 FIND v(dout0_109) AT=155.025n

.meas tran vdout0_110ck300 FIND v(dout0_110) AT=155.025n

.meas tran vdout0_111ck300 FIND v(dout0_111) AT=155.025n

.meas tran vdout0_112ck300 FIND v(dout0_112) AT=155.025n

.meas tran vdout0_113ck300 FIND v(dout0_113) AT=155.025n

.meas tran vdout0_114ck300 FIND v(dout0_114) AT=155.025n

.meas tran vdout0_115ck300 FIND v(dout0_115) AT=155.025n

.meas tran vdout0_116ck300 FIND v(dout0_116) AT=155.025n

.meas tran vdout0_117ck300 FIND v(dout0_117) AT=155.025n

.meas tran vdout0_118ck300 FIND v(dout0_118) AT=155.025n

.meas tran vdout0_119ck300 FIND v(dout0_119) AT=155.025n

.meas tran vdout0_120ck300 FIND v(dout0_120) AT=155.025n

.meas tran vdout0_121ck300 FIND v(dout0_121) AT=155.025n

.meas tran vdout0_122ck300 FIND v(dout0_122) AT=155.025n

.meas tran vdout0_123ck300 FIND v(dout0_123) AT=155.025n

.meas tran vdout0_124ck300 FIND v(dout0_124) AT=155.025n

.meas tran vdout0_125ck300 FIND v(dout0_125) AT=155.025n

.meas tran vdout0_126ck300 FIND v(dout0_126) AT=155.025n

.meas tran vdout0_127ck300 FIND v(dout0_127) AT=155.025n

.meas tran vdout0_128ck300 FIND v(dout0_128) AT=155.025n

.meas tran vdout0_129ck300 FIND v(dout0_129) AT=155.025n

.meas tran vdout0_130ck300 FIND v(dout0_130) AT=155.025n

.meas tran vdout0_131ck300 FIND v(dout0_131) AT=155.025n

.meas tran vdout0_132ck300 FIND v(dout0_132) AT=155.025n

.meas tran vdout0_133ck300 FIND v(dout0_133) AT=155.025n

.meas tran vdout0_134ck300 FIND v(dout0_134) AT=155.025n

.meas tran vdout0_135ck300 FIND v(dout0_135) AT=155.025n

.meas tran vdout0_136ck300 FIND v(dout0_136) AT=155.025n

.meas tran vdout0_137ck300 FIND v(dout0_137) AT=155.025n

.meas tran vdout0_138ck300 FIND v(dout0_138) AT=155.025n

.meas tran vdout0_139ck300 FIND v(dout0_139) AT=155.025n

.meas tran vdout0_140ck300 FIND v(dout0_140) AT=155.025n

.meas tran vdout0_141ck300 FIND v(dout0_141) AT=155.025n

.meas tran vdout0_142ck300 FIND v(dout0_142) AT=155.025n

.meas tran vdout0_143ck300 FIND v(dout0_143) AT=155.025n

.meas tran vdout0_144ck300 FIND v(dout0_144) AT=155.025n

.meas tran vdout0_145ck300 FIND v(dout0_145) AT=155.025n

.meas tran vdout0_146ck300 FIND v(dout0_146) AT=155.025n

.meas tran vdout0_147ck300 FIND v(dout0_147) AT=155.025n

.meas tran vdout0_148ck300 FIND v(dout0_148) AT=155.025n

.meas tran vdout0_149ck300 FIND v(dout0_149) AT=155.025n

.meas tran vdout0_150ck300 FIND v(dout0_150) AT=155.025n

.meas tran vdout0_151ck300 FIND v(dout0_151) AT=155.025n

.meas tran vdout0_152ck300 FIND v(dout0_152) AT=155.025n

.meas tran vdout0_153ck300 FIND v(dout0_153) AT=155.025n

.meas tran vdout0_154ck300 FIND v(dout0_154) AT=155.025n

.meas tran vdout0_155ck300 FIND v(dout0_155) AT=155.025n

.meas tran vdout0_156ck300 FIND v(dout0_156) AT=155.025n

.meas tran vdout0_157ck300 FIND v(dout0_157) AT=155.025n

.meas tran vdout0_158ck300 FIND v(dout0_158) AT=155.025n

.meas tran vdout0_159ck300 FIND v(dout0_159) AT=155.025n

.meas tran vdout0_160ck300 FIND v(dout0_160) AT=155.025n

.meas tran vdout0_161ck300 FIND v(dout0_161) AT=155.025n

.meas tran vdout0_162ck300 FIND v(dout0_162) AT=155.025n

.meas tran vdout0_163ck300 FIND v(dout0_163) AT=155.025n

.meas tran vdout0_164ck300 FIND v(dout0_164) AT=155.025n

.meas tran vdout0_165ck300 FIND v(dout0_165) AT=155.025n

.meas tran vdout0_166ck300 FIND v(dout0_166) AT=155.025n

.meas tran vdout0_167ck300 FIND v(dout0_167) AT=155.025n

.meas tran vdout0_168ck300 FIND v(dout0_168) AT=155.025n

.meas tran vdout0_169ck300 FIND v(dout0_169) AT=155.025n

.meas tran vdout0_170ck300 FIND v(dout0_170) AT=155.025n

.meas tran vdout0_171ck300 FIND v(dout0_171) AT=155.025n

.meas tran vdout0_172ck300 FIND v(dout0_172) AT=155.025n

.meas tran vdout0_173ck300 FIND v(dout0_173) AT=155.025n

.meas tran vdout0_174ck300 FIND v(dout0_174) AT=155.025n

.meas tran vdout0_175ck300 FIND v(dout0_175) AT=155.025n

.meas tran vdout0_176ck300 FIND v(dout0_176) AT=155.025n

.meas tran vdout0_177ck300 FIND v(dout0_177) AT=155.025n

.meas tran vdout0_178ck300 FIND v(dout0_178) AT=155.025n

.meas tran vdout0_179ck300 FIND v(dout0_179) AT=155.025n

.meas tran vdout0_180ck300 FIND v(dout0_180) AT=155.025n

.meas tran vdout0_181ck300 FIND v(dout0_181) AT=155.025n

.meas tran vdout0_182ck300 FIND v(dout0_182) AT=155.025n

.meas tran vdout0_183ck300 FIND v(dout0_183) AT=155.025n

.meas tran vdout0_184ck300 FIND v(dout0_184) AT=155.025n

.meas tran vdout0_185ck300 FIND v(dout0_185) AT=155.025n

.meas tran vdout0_186ck300 FIND v(dout0_186) AT=155.025n

.meas tran vdout0_187ck300 FIND v(dout0_187) AT=155.025n

.meas tran vdout0_188ck300 FIND v(dout0_188) AT=155.025n

.meas tran vdout0_189ck300 FIND v(dout0_189) AT=155.025n

.meas tran vdout0_190ck300 FIND v(dout0_190) AT=155.025n

.meas tran vdout0_191ck300 FIND v(dout0_191) AT=155.025n

.meas tran vdout0_192ck300 FIND v(dout0_192) AT=155.025n

.meas tran vdout0_193ck300 FIND v(dout0_193) AT=155.025n

.meas tran vdout0_194ck300 FIND v(dout0_194) AT=155.025n

.meas tran vdout0_195ck300 FIND v(dout0_195) AT=155.025n

.meas tran vdout0_196ck300 FIND v(dout0_196) AT=155.025n

.meas tran vdout0_197ck300 FIND v(dout0_197) AT=155.025n

.meas tran vdout0_198ck300 FIND v(dout0_198) AT=155.025n

.meas tran vdout0_199ck300 FIND v(dout0_199) AT=155.025n

.meas tran vdout0_200ck300 FIND v(dout0_200) AT=155.025n

.meas tran vdout0_201ck300 FIND v(dout0_201) AT=155.025n

.meas tran vdout0_202ck300 FIND v(dout0_202) AT=155.025n

.meas tran vdout0_203ck300 FIND v(dout0_203) AT=155.025n

.meas tran vdout0_204ck300 FIND v(dout0_204) AT=155.025n

.meas tran vdout0_205ck300 FIND v(dout0_205) AT=155.025n

.meas tran vdout0_206ck300 FIND v(dout0_206) AT=155.025n

.meas tran vdout0_207ck300 FIND v(dout0_207) AT=155.025n

.meas tran vdout0_208ck300 FIND v(dout0_208) AT=155.025n

.meas tran vdout0_209ck300 FIND v(dout0_209) AT=155.025n

.meas tran vdout0_210ck300 FIND v(dout0_210) AT=155.025n

.meas tran vdout0_211ck300 FIND v(dout0_211) AT=155.025n

.meas tran vdout0_212ck300 FIND v(dout0_212) AT=155.025n

.meas tran vdout0_213ck300 FIND v(dout0_213) AT=155.025n

.meas tran vdout0_214ck300 FIND v(dout0_214) AT=155.025n

.meas tran vdout0_215ck300 FIND v(dout0_215) AT=155.025n

.meas tran vdout0_216ck300 FIND v(dout0_216) AT=155.025n

.meas tran vdout0_217ck300 FIND v(dout0_217) AT=155.025n

.meas tran vdout0_218ck300 FIND v(dout0_218) AT=155.025n

.meas tran vdout0_219ck300 FIND v(dout0_219) AT=155.025n

.meas tran vdout0_220ck300 FIND v(dout0_220) AT=155.025n

.meas tran vdout0_221ck300 FIND v(dout0_221) AT=155.025n

.meas tran vdout0_222ck300 FIND v(dout0_222) AT=155.025n

.meas tran vdout0_223ck300 FIND v(dout0_223) AT=155.025n

.meas tran vdout0_224ck300 FIND v(dout0_224) AT=155.025n

.meas tran vdout0_225ck300 FIND v(dout0_225) AT=155.025n

.meas tran vdout0_226ck300 FIND v(dout0_226) AT=155.025n

.meas tran vdout0_227ck300 FIND v(dout0_227) AT=155.025n

.meas tran vdout0_228ck300 FIND v(dout0_228) AT=155.025n

.meas tran vdout0_229ck300 FIND v(dout0_229) AT=155.025n

.meas tran vdout0_230ck300 FIND v(dout0_230) AT=155.025n

.meas tran vdout0_231ck300 FIND v(dout0_231) AT=155.025n

.meas tran vdout0_232ck300 FIND v(dout0_232) AT=155.025n

.meas tran vdout0_233ck300 FIND v(dout0_233) AT=155.025n

.meas tran vdout0_234ck300 FIND v(dout0_234) AT=155.025n

.meas tran vdout0_235ck300 FIND v(dout0_235) AT=155.025n

.meas tran vdout0_236ck300 FIND v(dout0_236) AT=155.025n

.meas tran vdout0_237ck300 FIND v(dout0_237) AT=155.025n

.meas tran vdout0_238ck300 FIND v(dout0_238) AT=155.025n

.meas tran vdout0_239ck300 FIND v(dout0_239) AT=155.025n

.meas tran vdout0_240ck300 FIND v(dout0_240) AT=155.025n

.meas tran vdout0_241ck300 FIND v(dout0_241) AT=155.025n

.meas tran vdout0_242ck300 FIND v(dout0_242) AT=155.025n

.meas tran vdout0_243ck300 FIND v(dout0_243) AT=155.025n

.meas tran vdout0_244ck300 FIND v(dout0_244) AT=155.025n

.meas tran vdout0_245ck300 FIND v(dout0_245) AT=155.025n

.meas tran vdout0_246ck300 FIND v(dout0_246) AT=155.025n

.meas tran vdout0_247ck300 FIND v(dout0_247) AT=155.025n

.meas tran vdout0_248ck300 FIND v(dout0_248) AT=155.025n

.meas tran vdout0_249ck300 FIND v(dout0_249) AT=155.025n

.meas tran vdout0_250ck300 FIND v(dout0_250) AT=155.025n

.meas tran vdout0_251ck300 FIND v(dout0_251) AT=155.025n

.meas tran vdout0_252ck300 FIND v(dout0_252) AT=155.025n

.meas tran vdout0_253ck300 FIND v(dout0_253) AT=155.025n

.meas tran vdout0_254ck300 FIND v(dout0_254) AT=155.025n

.meas tran vdout0_255ck300 FIND v(dout0_255) AT=155.025n

.meas tran vdout0_0ck330 FIND v(dout0_0) AT=170.025n

.meas tran vdout0_1ck330 FIND v(dout0_1) AT=170.025n

.meas tran vdout0_2ck330 FIND v(dout0_2) AT=170.025n

.meas tran vdout0_3ck330 FIND v(dout0_3) AT=170.025n

.meas tran vdout0_4ck330 FIND v(dout0_4) AT=170.025n

.meas tran vdout0_5ck330 FIND v(dout0_5) AT=170.025n

.meas tran vdout0_6ck330 FIND v(dout0_6) AT=170.025n

.meas tran vdout0_7ck330 FIND v(dout0_7) AT=170.025n

.meas tran vdout0_8ck330 FIND v(dout0_8) AT=170.025n

.meas tran vdout0_9ck330 FIND v(dout0_9) AT=170.025n

.meas tran vdout0_10ck330 FIND v(dout0_10) AT=170.025n

.meas tran vdout0_11ck330 FIND v(dout0_11) AT=170.025n

.meas tran vdout0_12ck330 FIND v(dout0_12) AT=170.025n

.meas tran vdout0_13ck330 FIND v(dout0_13) AT=170.025n

.meas tran vdout0_14ck330 FIND v(dout0_14) AT=170.025n

.meas tran vdout0_15ck330 FIND v(dout0_15) AT=170.025n

.meas tran vdout0_16ck330 FIND v(dout0_16) AT=170.025n

.meas tran vdout0_17ck330 FIND v(dout0_17) AT=170.025n

.meas tran vdout0_18ck330 FIND v(dout0_18) AT=170.025n

.meas tran vdout0_19ck330 FIND v(dout0_19) AT=170.025n

.meas tran vdout0_20ck330 FIND v(dout0_20) AT=170.025n

.meas tran vdout0_21ck330 FIND v(dout0_21) AT=170.025n

.meas tran vdout0_22ck330 FIND v(dout0_22) AT=170.025n

.meas tran vdout0_23ck330 FIND v(dout0_23) AT=170.025n

.meas tran vdout0_24ck330 FIND v(dout0_24) AT=170.025n

.meas tran vdout0_25ck330 FIND v(dout0_25) AT=170.025n

.meas tran vdout0_26ck330 FIND v(dout0_26) AT=170.025n

.meas tran vdout0_27ck330 FIND v(dout0_27) AT=170.025n

.meas tran vdout0_28ck330 FIND v(dout0_28) AT=170.025n

.meas tran vdout0_29ck330 FIND v(dout0_29) AT=170.025n

.meas tran vdout0_30ck330 FIND v(dout0_30) AT=170.025n

.meas tran vdout0_31ck330 FIND v(dout0_31) AT=170.025n

.meas tran vdout0_32ck330 FIND v(dout0_32) AT=170.025n

.meas tran vdout0_33ck330 FIND v(dout0_33) AT=170.025n

.meas tran vdout0_34ck330 FIND v(dout0_34) AT=170.025n

.meas tran vdout0_35ck330 FIND v(dout0_35) AT=170.025n

.meas tran vdout0_36ck330 FIND v(dout0_36) AT=170.025n

.meas tran vdout0_37ck330 FIND v(dout0_37) AT=170.025n

.meas tran vdout0_38ck330 FIND v(dout0_38) AT=170.025n

.meas tran vdout0_39ck330 FIND v(dout0_39) AT=170.025n

.meas tran vdout0_40ck330 FIND v(dout0_40) AT=170.025n

.meas tran vdout0_41ck330 FIND v(dout0_41) AT=170.025n

.meas tran vdout0_42ck330 FIND v(dout0_42) AT=170.025n

.meas tran vdout0_43ck330 FIND v(dout0_43) AT=170.025n

.meas tran vdout0_44ck330 FIND v(dout0_44) AT=170.025n

.meas tran vdout0_45ck330 FIND v(dout0_45) AT=170.025n

.meas tran vdout0_46ck330 FIND v(dout0_46) AT=170.025n

.meas tran vdout0_47ck330 FIND v(dout0_47) AT=170.025n

.meas tran vdout0_48ck330 FIND v(dout0_48) AT=170.025n

.meas tran vdout0_49ck330 FIND v(dout0_49) AT=170.025n

.meas tran vdout0_50ck330 FIND v(dout0_50) AT=170.025n

.meas tran vdout0_51ck330 FIND v(dout0_51) AT=170.025n

.meas tran vdout0_52ck330 FIND v(dout0_52) AT=170.025n

.meas tran vdout0_53ck330 FIND v(dout0_53) AT=170.025n

.meas tran vdout0_54ck330 FIND v(dout0_54) AT=170.025n

.meas tran vdout0_55ck330 FIND v(dout0_55) AT=170.025n

.meas tran vdout0_56ck330 FIND v(dout0_56) AT=170.025n

.meas tran vdout0_57ck330 FIND v(dout0_57) AT=170.025n

.meas tran vdout0_58ck330 FIND v(dout0_58) AT=170.025n

.meas tran vdout0_59ck330 FIND v(dout0_59) AT=170.025n

.meas tran vdout0_60ck330 FIND v(dout0_60) AT=170.025n

.meas tran vdout0_61ck330 FIND v(dout0_61) AT=170.025n

.meas tran vdout0_62ck330 FIND v(dout0_62) AT=170.025n

.meas tran vdout0_63ck330 FIND v(dout0_63) AT=170.025n

.meas tran vdout0_64ck330 FIND v(dout0_64) AT=170.025n

.meas tran vdout0_65ck330 FIND v(dout0_65) AT=170.025n

.meas tran vdout0_66ck330 FIND v(dout0_66) AT=170.025n

.meas tran vdout0_67ck330 FIND v(dout0_67) AT=170.025n

.meas tran vdout0_68ck330 FIND v(dout0_68) AT=170.025n

.meas tran vdout0_69ck330 FIND v(dout0_69) AT=170.025n

.meas tran vdout0_70ck330 FIND v(dout0_70) AT=170.025n

.meas tran vdout0_71ck330 FIND v(dout0_71) AT=170.025n

.meas tran vdout0_72ck330 FIND v(dout0_72) AT=170.025n

.meas tran vdout0_73ck330 FIND v(dout0_73) AT=170.025n

.meas tran vdout0_74ck330 FIND v(dout0_74) AT=170.025n

.meas tran vdout0_75ck330 FIND v(dout0_75) AT=170.025n

.meas tran vdout0_76ck330 FIND v(dout0_76) AT=170.025n

.meas tran vdout0_77ck330 FIND v(dout0_77) AT=170.025n

.meas tran vdout0_78ck330 FIND v(dout0_78) AT=170.025n

.meas tran vdout0_79ck330 FIND v(dout0_79) AT=170.025n

.meas tran vdout0_80ck330 FIND v(dout0_80) AT=170.025n

.meas tran vdout0_81ck330 FIND v(dout0_81) AT=170.025n

.meas tran vdout0_82ck330 FIND v(dout0_82) AT=170.025n

.meas tran vdout0_83ck330 FIND v(dout0_83) AT=170.025n

.meas tran vdout0_84ck330 FIND v(dout0_84) AT=170.025n

.meas tran vdout0_85ck330 FIND v(dout0_85) AT=170.025n

.meas tran vdout0_86ck330 FIND v(dout0_86) AT=170.025n

.meas tran vdout0_87ck330 FIND v(dout0_87) AT=170.025n

.meas tran vdout0_88ck330 FIND v(dout0_88) AT=170.025n

.meas tran vdout0_89ck330 FIND v(dout0_89) AT=170.025n

.meas tran vdout0_90ck330 FIND v(dout0_90) AT=170.025n

.meas tran vdout0_91ck330 FIND v(dout0_91) AT=170.025n

.meas tran vdout0_92ck330 FIND v(dout0_92) AT=170.025n

.meas tran vdout0_93ck330 FIND v(dout0_93) AT=170.025n

.meas tran vdout0_94ck330 FIND v(dout0_94) AT=170.025n

.meas tran vdout0_95ck330 FIND v(dout0_95) AT=170.025n

.meas tran vdout0_96ck330 FIND v(dout0_96) AT=170.025n

.meas tran vdout0_97ck330 FIND v(dout0_97) AT=170.025n

.meas tran vdout0_98ck330 FIND v(dout0_98) AT=170.025n

.meas tran vdout0_99ck330 FIND v(dout0_99) AT=170.025n

.meas tran vdout0_100ck330 FIND v(dout0_100) AT=170.025n

.meas tran vdout0_101ck330 FIND v(dout0_101) AT=170.025n

.meas tran vdout0_102ck330 FIND v(dout0_102) AT=170.025n

.meas tran vdout0_103ck330 FIND v(dout0_103) AT=170.025n

.meas tran vdout0_104ck330 FIND v(dout0_104) AT=170.025n

.meas tran vdout0_105ck330 FIND v(dout0_105) AT=170.025n

.meas tran vdout0_106ck330 FIND v(dout0_106) AT=170.025n

.meas tran vdout0_107ck330 FIND v(dout0_107) AT=170.025n

.meas tran vdout0_108ck330 FIND v(dout0_108) AT=170.025n

.meas tran vdout0_109ck330 FIND v(dout0_109) AT=170.025n

.meas tran vdout0_110ck330 FIND v(dout0_110) AT=170.025n

.meas tran vdout0_111ck330 FIND v(dout0_111) AT=170.025n

.meas tran vdout0_112ck330 FIND v(dout0_112) AT=170.025n

.meas tran vdout0_113ck330 FIND v(dout0_113) AT=170.025n

.meas tran vdout0_114ck330 FIND v(dout0_114) AT=170.025n

.meas tran vdout0_115ck330 FIND v(dout0_115) AT=170.025n

.meas tran vdout0_116ck330 FIND v(dout0_116) AT=170.025n

.meas tran vdout0_117ck330 FIND v(dout0_117) AT=170.025n

.meas tran vdout0_118ck330 FIND v(dout0_118) AT=170.025n

.meas tran vdout0_119ck330 FIND v(dout0_119) AT=170.025n

.meas tran vdout0_120ck330 FIND v(dout0_120) AT=170.025n

.meas tran vdout0_121ck330 FIND v(dout0_121) AT=170.025n

.meas tran vdout0_122ck330 FIND v(dout0_122) AT=170.025n

.meas tran vdout0_123ck330 FIND v(dout0_123) AT=170.025n

.meas tran vdout0_124ck330 FIND v(dout0_124) AT=170.025n

.meas tran vdout0_125ck330 FIND v(dout0_125) AT=170.025n

.meas tran vdout0_126ck330 FIND v(dout0_126) AT=170.025n

.meas tran vdout0_127ck330 FIND v(dout0_127) AT=170.025n

.meas tran vdout0_128ck330 FIND v(dout0_128) AT=170.025n

.meas tran vdout0_129ck330 FIND v(dout0_129) AT=170.025n

.meas tran vdout0_130ck330 FIND v(dout0_130) AT=170.025n

.meas tran vdout0_131ck330 FIND v(dout0_131) AT=170.025n

.meas tran vdout0_132ck330 FIND v(dout0_132) AT=170.025n

.meas tran vdout0_133ck330 FIND v(dout0_133) AT=170.025n

.meas tran vdout0_134ck330 FIND v(dout0_134) AT=170.025n

.meas tran vdout0_135ck330 FIND v(dout0_135) AT=170.025n

.meas tran vdout0_136ck330 FIND v(dout0_136) AT=170.025n

.meas tran vdout0_137ck330 FIND v(dout0_137) AT=170.025n

.meas tran vdout0_138ck330 FIND v(dout0_138) AT=170.025n

.meas tran vdout0_139ck330 FIND v(dout0_139) AT=170.025n

.meas tran vdout0_140ck330 FIND v(dout0_140) AT=170.025n

.meas tran vdout0_141ck330 FIND v(dout0_141) AT=170.025n

.meas tran vdout0_142ck330 FIND v(dout0_142) AT=170.025n

.meas tran vdout0_143ck330 FIND v(dout0_143) AT=170.025n

.meas tran vdout0_144ck330 FIND v(dout0_144) AT=170.025n

.meas tran vdout0_145ck330 FIND v(dout0_145) AT=170.025n

.meas tran vdout0_146ck330 FIND v(dout0_146) AT=170.025n

.meas tran vdout0_147ck330 FIND v(dout0_147) AT=170.025n

.meas tran vdout0_148ck330 FIND v(dout0_148) AT=170.025n

.meas tran vdout0_149ck330 FIND v(dout0_149) AT=170.025n

.meas tran vdout0_150ck330 FIND v(dout0_150) AT=170.025n

.meas tran vdout0_151ck330 FIND v(dout0_151) AT=170.025n

.meas tran vdout0_152ck330 FIND v(dout0_152) AT=170.025n

.meas tran vdout0_153ck330 FIND v(dout0_153) AT=170.025n

.meas tran vdout0_154ck330 FIND v(dout0_154) AT=170.025n

.meas tran vdout0_155ck330 FIND v(dout0_155) AT=170.025n

.meas tran vdout0_156ck330 FIND v(dout0_156) AT=170.025n

.meas tran vdout0_157ck330 FIND v(dout0_157) AT=170.025n

.meas tran vdout0_158ck330 FIND v(dout0_158) AT=170.025n

.meas tran vdout0_159ck330 FIND v(dout0_159) AT=170.025n

.meas tran vdout0_160ck330 FIND v(dout0_160) AT=170.025n

.meas tran vdout0_161ck330 FIND v(dout0_161) AT=170.025n

.meas tran vdout0_162ck330 FIND v(dout0_162) AT=170.025n

.meas tran vdout0_163ck330 FIND v(dout0_163) AT=170.025n

.meas tran vdout0_164ck330 FIND v(dout0_164) AT=170.025n

.meas tran vdout0_165ck330 FIND v(dout0_165) AT=170.025n

.meas tran vdout0_166ck330 FIND v(dout0_166) AT=170.025n

.meas tran vdout0_167ck330 FIND v(dout0_167) AT=170.025n

.meas tran vdout0_168ck330 FIND v(dout0_168) AT=170.025n

.meas tran vdout0_169ck330 FIND v(dout0_169) AT=170.025n

.meas tran vdout0_170ck330 FIND v(dout0_170) AT=170.025n

.meas tran vdout0_171ck330 FIND v(dout0_171) AT=170.025n

.meas tran vdout0_172ck330 FIND v(dout0_172) AT=170.025n

.meas tran vdout0_173ck330 FIND v(dout0_173) AT=170.025n

.meas tran vdout0_174ck330 FIND v(dout0_174) AT=170.025n

.meas tran vdout0_175ck330 FIND v(dout0_175) AT=170.025n

.meas tran vdout0_176ck330 FIND v(dout0_176) AT=170.025n

.meas tran vdout0_177ck330 FIND v(dout0_177) AT=170.025n

.meas tran vdout0_178ck330 FIND v(dout0_178) AT=170.025n

.meas tran vdout0_179ck330 FIND v(dout0_179) AT=170.025n

.meas tran vdout0_180ck330 FIND v(dout0_180) AT=170.025n

.meas tran vdout0_181ck330 FIND v(dout0_181) AT=170.025n

.meas tran vdout0_182ck330 FIND v(dout0_182) AT=170.025n

.meas tran vdout0_183ck330 FIND v(dout0_183) AT=170.025n

.meas tran vdout0_184ck330 FIND v(dout0_184) AT=170.025n

.meas tran vdout0_185ck330 FIND v(dout0_185) AT=170.025n

.meas tran vdout0_186ck330 FIND v(dout0_186) AT=170.025n

.meas tran vdout0_187ck330 FIND v(dout0_187) AT=170.025n

.meas tran vdout0_188ck330 FIND v(dout0_188) AT=170.025n

.meas tran vdout0_189ck330 FIND v(dout0_189) AT=170.025n

.meas tran vdout0_190ck330 FIND v(dout0_190) AT=170.025n

.meas tran vdout0_191ck330 FIND v(dout0_191) AT=170.025n

.meas tran vdout0_192ck330 FIND v(dout0_192) AT=170.025n

.meas tran vdout0_193ck330 FIND v(dout0_193) AT=170.025n

.meas tran vdout0_194ck330 FIND v(dout0_194) AT=170.025n

.meas tran vdout0_195ck330 FIND v(dout0_195) AT=170.025n

.meas tran vdout0_196ck330 FIND v(dout0_196) AT=170.025n

.meas tran vdout0_197ck330 FIND v(dout0_197) AT=170.025n

.meas tran vdout0_198ck330 FIND v(dout0_198) AT=170.025n

.meas tran vdout0_199ck330 FIND v(dout0_199) AT=170.025n

.meas tran vdout0_200ck330 FIND v(dout0_200) AT=170.025n

.meas tran vdout0_201ck330 FIND v(dout0_201) AT=170.025n

.meas tran vdout0_202ck330 FIND v(dout0_202) AT=170.025n

.meas tran vdout0_203ck330 FIND v(dout0_203) AT=170.025n

.meas tran vdout0_204ck330 FIND v(dout0_204) AT=170.025n

.meas tran vdout0_205ck330 FIND v(dout0_205) AT=170.025n

.meas tran vdout0_206ck330 FIND v(dout0_206) AT=170.025n

.meas tran vdout0_207ck330 FIND v(dout0_207) AT=170.025n

.meas tran vdout0_208ck330 FIND v(dout0_208) AT=170.025n

.meas tran vdout0_209ck330 FIND v(dout0_209) AT=170.025n

.meas tran vdout0_210ck330 FIND v(dout0_210) AT=170.025n

.meas tran vdout0_211ck330 FIND v(dout0_211) AT=170.025n

.meas tran vdout0_212ck330 FIND v(dout0_212) AT=170.025n

.meas tran vdout0_213ck330 FIND v(dout0_213) AT=170.025n

.meas tran vdout0_214ck330 FIND v(dout0_214) AT=170.025n

.meas tran vdout0_215ck330 FIND v(dout0_215) AT=170.025n

.meas tran vdout0_216ck330 FIND v(dout0_216) AT=170.025n

.meas tran vdout0_217ck330 FIND v(dout0_217) AT=170.025n

.meas tran vdout0_218ck330 FIND v(dout0_218) AT=170.025n

.meas tran vdout0_219ck330 FIND v(dout0_219) AT=170.025n

.meas tran vdout0_220ck330 FIND v(dout0_220) AT=170.025n

.meas tran vdout0_221ck330 FIND v(dout0_221) AT=170.025n

.meas tran vdout0_222ck330 FIND v(dout0_222) AT=170.025n

.meas tran vdout0_223ck330 FIND v(dout0_223) AT=170.025n

.meas tran vdout0_224ck330 FIND v(dout0_224) AT=170.025n

.meas tran vdout0_225ck330 FIND v(dout0_225) AT=170.025n

.meas tran vdout0_226ck330 FIND v(dout0_226) AT=170.025n

.meas tran vdout0_227ck330 FIND v(dout0_227) AT=170.025n

.meas tran vdout0_228ck330 FIND v(dout0_228) AT=170.025n

.meas tran vdout0_229ck330 FIND v(dout0_229) AT=170.025n

.meas tran vdout0_230ck330 FIND v(dout0_230) AT=170.025n

.meas tran vdout0_231ck330 FIND v(dout0_231) AT=170.025n

.meas tran vdout0_232ck330 FIND v(dout0_232) AT=170.025n

.meas tran vdout0_233ck330 FIND v(dout0_233) AT=170.025n

.meas tran vdout0_234ck330 FIND v(dout0_234) AT=170.025n

.meas tran vdout0_235ck330 FIND v(dout0_235) AT=170.025n

.meas tran vdout0_236ck330 FIND v(dout0_236) AT=170.025n

.meas tran vdout0_237ck330 FIND v(dout0_237) AT=170.025n

.meas tran vdout0_238ck330 FIND v(dout0_238) AT=170.025n

.meas tran vdout0_239ck330 FIND v(dout0_239) AT=170.025n

.meas tran vdout0_240ck330 FIND v(dout0_240) AT=170.025n

.meas tran vdout0_241ck330 FIND v(dout0_241) AT=170.025n

.meas tran vdout0_242ck330 FIND v(dout0_242) AT=170.025n

.meas tran vdout0_243ck330 FIND v(dout0_243) AT=170.025n

.meas tran vdout0_244ck330 FIND v(dout0_244) AT=170.025n

.meas tran vdout0_245ck330 FIND v(dout0_245) AT=170.025n

.meas tran vdout0_246ck330 FIND v(dout0_246) AT=170.025n

.meas tran vdout0_247ck330 FIND v(dout0_247) AT=170.025n

.meas tran vdout0_248ck330 FIND v(dout0_248) AT=170.025n

.meas tran vdout0_249ck330 FIND v(dout0_249) AT=170.025n

.meas tran vdout0_250ck330 FIND v(dout0_250) AT=170.025n

.meas tran vdout0_251ck330 FIND v(dout0_251) AT=170.025n

.meas tran vdout0_252ck330 FIND v(dout0_252) AT=170.025n

.meas tran vdout0_253ck330 FIND v(dout0_253) AT=170.025n

.meas tran vdout0_254ck330 FIND v(dout0_254) AT=170.025n

.meas tran vdout0_255ck330 FIND v(dout0_255) AT=170.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_128ck350 FIND v(dout0_128) AT=180.025n

.meas tran vdout0_129ck350 FIND v(dout0_129) AT=180.025n

.meas tran vdout0_130ck350 FIND v(dout0_130) AT=180.025n

.meas tran vdout0_131ck350 FIND v(dout0_131) AT=180.025n

.meas tran vdout0_132ck350 FIND v(dout0_132) AT=180.025n

.meas tran vdout0_133ck350 FIND v(dout0_133) AT=180.025n

.meas tran vdout0_134ck350 FIND v(dout0_134) AT=180.025n

.meas tran vdout0_135ck350 FIND v(dout0_135) AT=180.025n

.meas tran vdout0_136ck350 FIND v(dout0_136) AT=180.025n

.meas tran vdout0_137ck350 FIND v(dout0_137) AT=180.025n

.meas tran vdout0_138ck350 FIND v(dout0_138) AT=180.025n

.meas tran vdout0_139ck350 FIND v(dout0_139) AT=180.025n

.meas tran vdout0_140ck350 FIND v(dout0_140) AT=180.025n

.meas tran vdout0_141ck350 FIND v(dout0_141) AT=180.025n

.meas tran vdout0_142ck350 FIND v(dout0_142) AT=180.025n

.meas tran vdout0_143ck350 FIND v(dout0_143) AT=180.025n

.meas tran vdout0_144ck350 FIND v(dout0_144) AT=180.025n

.meas tran vdout0_145ck350 FIND v(dout0_145) AT=180.025n

.meas tran vdout0_146ck350 FIND v(dout0_146) AT=180.025n

.meas tran vdout0_147ck350 FIND v(dout0_147) AT=180.025n

.meas tran vdout0_148ck350 FIND v(dout0_148) AT=180.025n

.meas tran vdout0_149ck350 FIND v(dout0_149) AT=180.025n

.meas tran vdout0_150ck350 FIND v(dout0_150) AT=180.025n

.meas tran vdout0_151ck350 FIND v(dout0_151) AT=180.025n

.meas tran vdout0_152ck350 FIND v(dout0_152) AT=180.025n

.meas tran vdout0_153ck350 FIND v(dout0_153) AT=180.025n

.meas tran vdout0_154ck350 FIND v(dout0_154) AT=180.025n

.meas tran vdout0_155ck350 FIND v(dout0_155) AT=180.025n

.meas tran vdout0_156ck350 FIND v(dout0_156) AT=180.025n

.meas tran vdout0_157ck350 FIND v(dout0_157) AT=180.025n

.meas tran vdout0_158ck350 FIND v(dout0_158) AT=180.025n

.meas tran vdout0_159ck350 FIND v(dout0_159) AT=180.025n

.meas tran vdout0_160ck350 FIND v(dout0_160) AT=180.025n

.meas tran vdout0_161ck350 FIND v(dout0_161) AT=180.025n

.meas tran vdout0_162ck350 FIND v(dout0_162) AT=180.025n

.meas tran vdout0_163ck350 FIND v(dout0_163) AT=180.025n

.meas tran vdout0_164ck350 FIND v(dout0_164) AT=180.025n

.meas tran vdout0_165ck350 FIND v(dout0_165) AT=180.025n

.meas tran vdout0_166ck350 FIND v(dout0_166) AT=180.025n

.meas tran vdout0_167ck350 FIND v(dout0_167) AT=180.025n

.meas tran vdout0_168ck350 FIND v(dout0_168) AT=180.025n

.meas tran vdout0_169ck350 FIND v(dout0_169) AT=180.025n

.meas tran vdout0_170ck350 FIND v(dout0_170) AT=180.025n

.meas tran vdout0_171ck350 FIND v(dout0_171) AT=180.025n

.meas tran vdout0_172ck350 FIND v(dout0_172) AT=180.025n

.meas tran vdout0_173ck350 FIND v(dout0_173) AT=180.025n

.meas tran vdout0_174ck350 FIND v(dout0_174) AT=180.025n

.meas tran vdout0_175ck350 FIND v(dout0_175) AT=180.025n

.meas tran vdout0_176ck350 FIND v(dout0_176) AT=180.025n

.meas tran vdout0_177ck350 FIND v(dout0_177) AT=180.025n

.meas tran vdout0_178ck350 FIND v(dout0_178) AT=180.025n

.meas tran vdout0_179ck350 FIND v(dout0_179) AT=180.025n

.meas tran vdout0_180ck350 FIND v(dout0_180) AT=180.025n

.meas tran vdout0_181ck350 FIND v(dout0_181) AT=180.025n

.meas tran vdout0_182ck350 FIND v(dout0_182) AT=180.025n

.meas tran vdout0_183ck350 FIND v(dout0_183) AT=180.025n

.meas tran vdout0_184ck350 FIND v(dout0_184) AT=180.025n

.meas tran vdout0_185ck350 FIND v(dout0_185) AT=180.025n

.meas tran vdout0_186ck350 FIND v(dout0_186) AT=180.025n

.meas tran vdout0_187ck350 FIND v(dout0_187) AT=180.025n

.meas tran vdout0_188ck350 FIND v(dout0_188) AT=180.025n

.meas tran vdout0_189ck350 FIND v(dout0_189) AT=180.025n

.meas tran vdout0_190ck350 FIND v(dout0_190) AT=180.025n

.meas tran vdout0_191ck350 FIND v(dout0_191) AT=180.025n

.meas tran vdout0_192ck350 FIND v(dout0_192) AT=180.025n

.meas tran vdout0_193ck350 FIND v(dout0_193) AT=180.025n

.meas tran vdout0_194ck350 FIND v(dout0_194) AT=180.025n

.meas tran vdout0_195ck350 FIND v(dout0_195) AT=180.025n

.meas tran vdout0_196ck350 FIND v(dout0_196) AT=180.025n

.meas tran vdout0_197ck350 FIND v(dout0_197) AT=180.025n

.meas tran vdout0_198ck350 FIND v(dout0_198) AT=180.025n

.meas tran vdout0_199ck350 FIND v(dout0_199) AT=180.025n

.meas tran vdout0_200ck350 FIND v(dout0_200) AT=180.025n

.meas tran vdout0_201ck350 FIND v(dout0_201) AT=180.025n

.meas tran vdout0_202ck350 FIND v(dout0_202) AT=180.025n

.meas tran vdout0_203ck350 FIND v(dout0_203) AT=180.025n

.meas tran vdout0_204ck350 FIND v(dout0_204) AT=180.025n

.meas tran vdout0_205ck350 FIND v(dout0_205) AT=180.025n

.meas tran vdout0_206ck350 FIND v(dout0_206) AT=180.025n

.meas tran vdout0_207ck350 FIND v(dout0_207) AT=180.025n

.meas tran vdout0_208ck350 FIND v(dout0_208) AT=180.025n

.meas tran vdout0_209ck350 FIND v(dout0_209) AT=180.025n

.meas tran vdout0_210ck350 FIND v(dout0_210) AT=180.025n

.meas tran vdout0_211ck350 FIND v(dout0_211) AT=180.025n

.meas tran vdout0_212ck350 FIND v(dout0_212) AT=180.025n

.meas tran vdout0_213ck350 FIND v(dout0_213) AT=180.025n

.meas tran vdout0_214ck350 FIND v(dout0_214) AT=180.025n

.meas tran vdout0_215ck350 FIND v(dout0_215) AT=180.025n

.meas tran vdout0_216ck350 FIND v(dout0_216) AT=180.025n

.meas tran vdout0_217ck350 FIND v(dout0_217) AT=180.025n

.meas tran vdout0_218ck350 FIND v(dout0_218) AT=180.025n

.meas tran vdout0_219ck350 FIND v(dout0_219) AT=180.025n

.meas tran vdout0_220ck350 FIND v(dout0_220) AT=180.025n

.meas tran vdout0_221ck350 FIND v(dout0_221) AT=180.025n

.meas tran vdout0_222ck350 FIND v(dout0_222) AT=180.025n

.meas tran vdout0_223ck350 FIND v(dout0_223) AT=180.025n

.meas tran vdout0_224ck350 FIND v(dout0_224) AT=180.025n

.meas tran vdout0_225ck350 FIND v(dout0_225) AT=180.025n

.meas tran vdout0_226ck350 FIND v(dout0_226) AT=180.025n

.meas tran vdout0_227ck350 FIND v(dout0_227) AT=180.025n

.meas tran vdout0_228ck350 FIND v(dout0_228) AT=180.025n

.meas tran vdout0_229ck350 FIND v(dout0_229) AT=180.025n

.meas tran vdout0_230ck350 FIND v(dout0_230) AT=180.025n

.meas tran vdout0_231ck350 FIND v(dout0_231) AT=180.025n

.meas tran vdout0_232ck350 FIND v(dout0_232) AT=180.025n

.meas tran vdout0_233ck350 FIND v(dout0_233) AT=180.025n

.meas tran vdout0_234ck350 FIND v(dout0_234) AT=180.025n

.meas tran vdout0_235ck350 FIND v(dout0_235) AT=180.025n

.meas tran vdout0_236ck350 FIND v(dout0_236) AT=180.025n

.meas tran vdout0_237ck350 FIND v(dout0_237) AT=180.025n

.meas tran vdout0_238ck350 FIND v(dout0_238) AT=180.025n

.meas tran vdout0_239ck350 FIND v(dout0_239) AT=180.025n

.meas tran vdout0_240ck350 FIND v(dout0_240) AT=180.025n

.meas tran vdout0_241ck350 FIND v(dout0_241) AT=180.025n

.meas tran vdout0_242ck350 FIND v(dout0_242) AT=180.025n

.meas tran vdout0_243ck350 FIND v(dout0_243) AT=180.025n

.meas tran vdout0_244ck350 FIND v(dout0_244) AT=180.025n

.meas tran vdout0_245ck350 FIND v(dout0_245) AT=180.025n

.meas tran vdout0_246ck350 FIND v(dout0_246) AT=180.025n

.meas tran vdout0_247ck350 FIND v(dout0_247) AT=180.025n

.meas tran vdout0_248ck350 FIND v(dout0_248) AT=180.025n

.meas tran vdout0_249ck350 FIND v(dout0_249) AT=180.025n

.meas tran vdout0_250ck350 FIND v(dout0_250) AT=180.025n

.meas tran vdout0_251ck350 FIND v(dout0_251) AT=180.025n

.meas tran vdout0_252ck350 FIND v(dout0_252) AT=180.025n

.meas tran vdout0_253ck350 FIND v(dout0_253) AT=180.025n

.meas tran vdout0_254ck350 FIND v(dout0_254) AT=180.025n

.meas tran vdout0_255ck350 FIND v(dout0_255) AT=180.025n

.meas tran vdout0_0ck360 FIND v(dout0_0) AT=185.025n

.meas tran vdout0_1ck360 FIND v(dout0_1) AT=185.025n

.meas tran vdout0_2ck360 FIND v(dout0_2) AT=185.025n

.meas tran vdout0_3ck360 FIND v(dout0_3) AT=185.025n

.meas tran vdout0_4ck360 FIND v(dout0_4) AT=185.025n

.meas tran vdout0_5ck360 FIND v(dout0_5) AT=185.025n

.meas tran vdout0_6ck360 FIND v(dout0_6) AT=185.025n

.meas tran vdout0_7ck360 FIND v(dout0_7) AT=185.025n

.meas tran vdout0_8ck360 FIND v(dout0_8) AT=185.025n

.meas tran vdout0_9ck360 FIND v(dout0_9) AT=185.025n

.meas tran vdout0_10ck360 FIND v(dout0_10) AT=185.025n

.meas tran vdout0_11ck360 FIND v(dout0_11) AT=185.025n

.meas tran vdout0_12ck360 FIND v(dout0_12) AT=185.025n

.meas tran vdout0_13ck360 FIND v(dout0_13) AT=185.025n

.meas tran vdout0_14ck360 FIND v(dout0_14) AT=185.025n

.meas tran vdout0_15ck360 FIND v(dout0_15) AT=185.025n

.meas tran vdout0_16ck360 FIND v(dout0_16) AT=185.025n

.meas tran vdout0_17ck360 FIND v(dout0_17) AT=185.025n

.meas tran vdout0_18ck360 FIND v(dout0_18) AT=185.025n

.meas tran vdout0_19ck360 FIND v(dout0_19) AT=185.025n

.meas tran vdout0_20ck360 FIND v(dout0_20) AT=185.025n

.meas tran vdout0_21ck360 FIND v(dout0_21) AT=185.025n

.meas tran vdout0_22ck360 FIND v(dout0_22) AT=185.025n

.meas tran vdout0_23ck360 FIND v(dout0_23) AT=185.025n

.meas tran vdout0_24ck360 FIND v(dout0_24) AT=185.025n

.meas tran vdout0_25ck360 FIND v(dout0_25) AT=185.025n

.meas tran vdout0_26ck360 FIND v(dout0_26) AT=185.025n

.meas tran vdout0_27ck360 FIND v(dout0_27) AT=185.025n

.meas tran vdout0_28ck360 FIND v(dout0_28) AT=185.025n

.meas tran vdout0_29ck360 FIND v(dout0_29) AT=185.025n

.meas tran vdout0_30ck360 FIND v(dout0_30) AT=185.025n

.meas tran vdout0_31ck360 FIND v(dout0_31) AT=185.025n

.meas tran vdout0_32ck360 FIND v(dout0_32) AT=185.025n

.meas tran vdout0_33ck360 FIND v(dout0_33) AT=185.025n

.meas tran vdout0_34ck360 FIND v(dout0_34) AT=185.025n

.meas tran vdout0_35ck360 FIND v(dout0_35) AT=185.025n

.meas tran vdout0_36ck360 FIND v(dout0_36) AT=185.025n

.meas tran vdout0_37ck360 FIND v(dout0_37) AT=185.025n

.meas tran vdout0_38ck360 FIND v(dout0_38) AT=185.025n

.meas tran vdout0_39ck360 FIND v(dout0_39) AT=185.025n

.meas tran vdout0_40ck360 FIND v(dout0_40) AT=185.025n

.meas tran vdout0_41ck360 FIND v(dout0_41) AT=185.025n

.meas tran vdout0_42ck360 FIND v(dout0_42) AT=185.025n

.meas tran vdout0_43ck360 FIND v(dout0_43) AT=185.025n

.meas tran vdout0_44ck360 FIND v(dout0_44) AT=185.025n

.meas tran vdout0_45ck360 FIND v(dout0_45) AT=185.025n

.meas tran vdout0_46ck360 FIND v(dout0_46) AT=185.025n

.meas tran vdout0_47ck360 FIND v(dout0_47) AT=185.025n

.meas tran vdout0_48ck360 FIND v(dout0_48) AT=185.025n

.meas tran vdout0_49ck360 FIND v(dout0_49) AT=185.025n

.meas tran vdout0_50ck360 FIND v(dout0_50) AT=185.025n

.meas tran vdout0_51ck360 FIND v(dout0_51) AT=185.025n

.meas tran vdout0_52ck360 FIND v(dout0_52) AT=185.025n

.meas tran vdout0_53ck360 FIND v(dout0_53) AT=185.025n

.meas tran vdout0_54ck360 FIND v(dout0_54) AT=185.025n

.meas tran vdout0_55ck360 FIND v(dout0_55) AT=185.025n

.meas tran vdout0_56ck360 FIND v(dout0_56) AT=185.025n

.meas tran vdout0_57ck360 FIND v(dout0_57) AT=185.025n

.meas tran vdout0_58ck360 FIND v(dout0_58) AT=185.025n

.meas tran vdout0_59ck360 FIND v(dout0_59) AT=185.025n

.meas tran vdout0_60ck360 FIND v(dout0_60) AT=185.025n

.meas tran vdout0_61ck360 FIND v(dout0_61) AT=185.025n

.meas tran vdout0_62ck360 FIND v(dout0_62) AT=185.025n

.meas tran vdout0_63ck360 FIND v(dout0_63) AT=185.025n

.meas tran vdout0_64ck360 FIND v(dout0_64) AT=185.025n

.meas tran vdout0_65ck360 FIND v(dout0_65) AT=185.025n

.meas tran vdout0_66ck360 FIND v(dout0_66) AT=185.025n

.meas tran vdout0_67ck360 FIND v(dout0_67) AT=185.025n

.meas tran vdout0_68ck360 FIND v(dout0_68) AT=185.025n

.meas tran vdout0_69ck360 FIND v(dout0_69) AT=185.025n

.meas tran vdout0_70ck360 FIND v(dout0_70) AT=185.025n

.meas tran vdout0_71ck360 FIND v(dout0_71) AT=185.025n

.meas tran vdout0_72ck360 FIND v(dout0_72) AT=185.025n

.meas tran vdout0_73ck360 FIND v(dout0_73) AT=185.025n

.meas tran vdout0_74ck360 FIND v(dout0_74) AT=185.025n

.meas tran vdout0_75ck360 FIND v(dout0_75) AT=185.025n

.meas tran vdout0_76ck360 FIND v(dout0_76) AT=185.025n

.meas tran vdout0_77ck360 FIND v(dout0_77) AT=185.025n

.meas tran vdout0_78ck360 FIND v(dout0_78) AT=185.025n

.meas tran vdout0_79ck360 FIND v(dout0_79) AT=185.025n

.meas tran vdout0_80ck360 FIND v(dout0_80) AT=185.025n

.meas tran vdout0_81ck360 FIND v(dout0_81) AT=185.025n

.meas tran vdout0_82ck360 FIND v(dout0_82) AT=185.025n

.meas tran vdout0_83ck360 FIND v(dout0_83) AT=185.025n

.meas tran vdout0_84ck360 FIND v(dout0_84) AT=185.025n

.meas tran vdout0_85ck360 FIND v(dout0_85) AT=185.025n

.meas tran vdout0_86ck360 FIND v(dout0_86) AT=185.025n

.meas tran vdout0_87ck360 FIND v(dout0_87) AT=185.025n

.meas tran vdout0_88ck360 FIND v(dout0_88) AT=185.025n

.meas tran vdout0_89ck360 FIND v(dout0_89) AT=185.025n

.meas tran vdout0_90ck360 FIND v(dout0_90) AT=185.025n

.meas tran vdout0_91ck360 FIND v(dout0_91) AT=185.025n

.meas tran vdout0_92ck360 FIND v(dout0_92) AT=185.025n

.meas tran vdout0_93ck360 FIND v(dout0_93) AT=185.025n

.meas tran vdout0_94ck360 FIND v(dout0_94) AT=185.025n

.meas tran vdout0_95ck360 FIND v(dout0_95) AT=185.025n

.meas tran vdout0_96ck360 FIND v(dout0_96) AT=185.025n

.meas tran vdout0_97ck360 FIND v(dout0_97) AT=185.025n

.meas tran vdout0_98ck360 FIND v(dout0_98) AT=185.025n

.meas tran vdout0_99ck360 FIND v(dout0_99) AT=185.025n

.meas tran vdout0_100ck360 FIND v(dout0_100) AT=185.025n

.meas tran vdout0_101ck360 FIND v(dout0_101) AT=185.025n

.meas tran vdout0_102ck360 FIND v(dout0_102) AT=185.025n

.meas tran vdout0_103ck360 FIND v(dout0_103) AT=185.025n

.meas tran vdout0_104ck360 FIND v(dout0_104) AT=185.025n

.meas tran vdout0_105ck360 FIND v(dout0_105) AT=185.025n

.meas tran vdout0_106ck360 FIND v(dout0_106) AT=185.025n

.meas tran vdout0_107ck360 FIND v(dout0_107) AT=185.025n

.meas tran vdout0_108ck360 FIND v(dout0_108) AT=185.025n

.meas tran vdout0_109ck360 FIND v(dout0_109) AT=185.025n

.meas tran vdout0_110ck360 FIND v(dout0_110) AT=185.025n

.meas tran vdout0_111ck360 FIND v(dout0_111) AT=185.025n

.meas tran vdout0_112ck360 FIND v(dout0_112) AT=185.025n

.meas tran vdout0_113ck360 FIND v(dout0_113) AT=185.025n

.meas tran vdout0_114ck360 FIND v(dout0_114) AT=185.025n

.meas tran vdout0_115ck360 FIND v(dout0_115) AT=185.025n

.meas tran vdout0_116ck360 FIND v(dout0_116) AT=185.025n

.meas tran vdout0_117ck360 FIND v(dout0_117) AT=185.025n

.meas tran vdout0_118ck360 FIND v(dout0_118) AT=185.025n

.meas tran vdout0_119ck360 FIND v(dout0_119) AT=185.025n

.meas tran vdout0_120ck360 FIND v(dout0_120) AT=185.025n

.meas tran vdout0_121ck360 FIND v(dout0_121) AT=185.025n

.meas tran vdout0_122ck360 FIND v(dout0_122) AT=185.025n

.meas tran vdout0_123ck360 FIND v(dout0_123) AT=185.025n

.meas tran vdout0_124ck360 FIND v(dout0_124) AT=185.025n

.meas tran vdout0_125ck360 FIND v(dout0_125) AT=185.025n

.meas tran vdout0_126ck360 FIND v(dout0_126) AT=185.025n

.meas tran vdout0_127ck360 FIND v(dout0_127) AT=185.025n

.meas tran vdout0_128ck360 FIND v(dout0_128) AT=185.025n

.meas tran vdout0_129ck360 FIND v(dout0_129) AT=185.025n

.meas tran vdout0_130ck360 FIND v(dout0_130) AT=185.025n

.meas tran vdout0_131ck360 FIND v(dout0_131) AT=185.025n

.meas tran vdout0_132ck360 FIND v(dout0_132) AT=185.025n

.meas tran vdout0_133ck360 FIND v(dout0_133) AT=185.025n

.meas tran vdout0_134ck360 FIND v(dout0_134) AT=185.025n

.meas tran vdout0_135ck360 FIND v(dout0_135) AT=185.025n

.meas tran vdout0_136ck360 FIND v(dout0_136) AT=185.025n

.meas tran vdout0_137ck360 FIND v(dout0_137) AT=185.025n

.meas tran vdout0_138ck360 FIND v(dout0_138) AT=185.025n

.meas tran vdout0_139ck360 FIND v(dout0_139) AT=185.025n

.meas tran vdout0_140ck360 FIND v(dout0_140) AT=185.025n

.meas tran vdout0_141ck360 FIND v(dout0_141) AT=185.025n

.meas tran vdout0_142ck360 FIND v(dout0_142) AT=185.025n

.meas tran vdout0_143ck360 FIND v(dout0_143) AT=185.025n

.meas tran vdout0_144ck360 FIND v(dout0_144) AT=185.025n

.meas tran vdout0_145ck360 FIND v(dout0_145) AT=185.025n

.meas tran vdout0_146ck360 FIND v(dout0_146) AT=185.025n

.meas tran vdout0_147ck360 FIND v(dout0_147) AT=185.025n

.meas tran vdout0_148ck360 FIND v(dout0_148) AT=185.025n

.meas tran vdout0_149ck360 FIND v(dout0_149) AT=185.025n

.meas tran vdout0_150ck360 FIND v(dout0_150) AT=185.025n

.meas tran vdout0_151ck360 FIND v(dout0_151) AT=185.025n

.meas tran vdout0_152ck360 FIND v(dout0_152) AT=185.025n

.meas tran vdout0_153ck360 FIND v(dout0_153) AT=185.025n

.meas tran vdout0_154ck360 FIND v(dout0_154) AT=185.025n

.meas tran vdout0_155ck360 FIND v(dout0_155) AT=185.025n

.meas tran vdout0_156ck360 FIND v(dout0_156) AT=185.025n

.meas tran vdout0_157ck360 FIND v(dout0_157) AT=185.025n

.meas tran vdout0_158ck360 FIND v(dout0_158) AT=185.025n

.meas tran vdout0_159ck360 FIND v(dout0_159) AT=185.025n

.meas tran vdout0_160ck360 FIND v(dout0_160) AT=185.025n

.meas tran vdout0_161ck360 FIND v(dout0_161) AT=185.025n

.meas tran vdout0_162ck360 FIND v(dout0_162) AT=185.025n

.meas tran vdout0_163ck360 FIND v(dout0_163) AT=185.025n

.meas tran vdout0_164ck360 FIND v(dout0_164) AT=185.025n

.meas tran vdout0_165ck360 FIND v(dout0_165) AT=185.025n

.meas tran vdout0_166ck360 FIND v(dout0_166) AT=185.025n

.meas tran vdout0_167ck360 FIND v(dout0_167) AT=185.025n

.meas tran vdout0_168ck360 FIND v(dout0_168) AT=185.025n

.meas tran vdout0_169ck360 FIND v(dout0_169) AT=185.025n

.meas tran vdout0_170ck360 FIND v(dout0_170) AT=185.025n

.meas tran vdout0_171ck360 FIND v(dout0_171) AT=185.025n

.meas tran vdout0_172ck360 FIND v(dout0_172) AT=185.025n

.meas tran vdout0_173ck360 FIND v(dout0_173) AT=185.025n

.meas tran vdout0_174ck360 FIND v(dout0_174) AT=185.025n

.meas tran vdout0_175ck360 FIND v(dout0_175) AT=185.025n

.meas tran vdout0_176ck360 FIND v(dout0_176) AT=185.025n

.meas tran vdout0_177ck360 FIND v(dout0_177) AT=185.025n

.meas tran vdout0_178ck360 FIND v(dout0_178) AT=185.025n

.meas tran vdout0_179ck360 FIND v(dout0_179) AT=185.025n

.meas tran vdout0_180ck360 FIND v(dout0_180) AT=185.025n

.meas tran vdout0_181ck360 FIND v(dout0_181) AT=185.025n

.meas tran vdout0_182ck360 FIND v(dout0_182) AT=185.025n

.meas tran vdout0_183ck360 FIND v(dout0_183) AT=185.025n

.meas tran vdout0_184ck360 FIND v(dout0_184) AT=185.025n

.meas tran vdout0_185ck360 FIND v(dout0_185) AT=185.025n

.meas tran vdout0_186ck360 FIND v(dout0_186) AT=185.025n

.meas tran vdout0_187ck360 FIND v(dout0_187) AT=185.025n

.meas tran vdout0_188ck360 FIND v(dout0_188) AT=185.025n

.meas tran vdout0_189ck360 FIND v(dout0_189) AT=185.025n

.meas tran vdout0_190ck360 FIND v(dout0_190) AT=185.025n

.meas tran vdout0_191ck360 FIND v(dout0_191) AT=185.025n

.meas tran vdout0_192ck360 FIND v(dout0_192) AT=185.025n

.meas tran vdout0_193ck360 FIND v(dout0_193) AT=185.025n

.meas tran vdout0_194ck360 FIND v(dout0_194) AT=185.025n

.meas tran vdout0_195ck360 FIND v(dout0_195) AT=185.025n

.meas tran vdout0_196ck360 FIND v(dout0_196) AT=185.025n

.meas tran vdout0_197ck360 FIND v(dout0_197) AT=185.025n

.meas tran vdout0_198ck360 FIND v(dout0_198) AT=185.025n

.meas tran vdout0_199ck360 FIND v(dout0_199) AT=185.025n

.meas tran vdout0_200ck360 FIND v(dout0_200) AT=185.025n

.meas tran vdout0_201ck360 FIND v(dout0_201) AT=185.025n

.meas tran vdout0_202ck360 FIND v(dout0_202) AT=185.025n

.meas tran vdout0_203ck360 FIND v(dout0_203) AT=185.025n

.meas tran vdout0_204ck360 FIND v(dout0_204) AT=185.025n

.meas tran vdout0_205ck360 FIND v(dout0_205) AT=185.025n

.meas tran vdout0_206ck360 FIND v(dout0_206) AT=185.025n

.meas tran vdout0_207ck360 FIND v(dout0_207) AT=185.025n

.meas tran vdout0_208ck360 FIND v(dout0_208) AT=185.025n

.meas tran vdout0_209ck360 FIND v(dout0_209) AT=185.025n

.meas tran vdout0_210ck360 FIND v(dout0_210) AT=185.025n

.meas tran vdout0_211ck360 FIND v(dout0_211) AT=185.025n

.meas tran vdout0_212ck360 FIND v(dout0_212) AT=185.025n

.meas tran vdout0_213ck360 FIND v(dout0_213) AT=185.025n

.meas tran vdout0_214ck360 FIND v(dout0_214) AT=185.025n

.meas tran vdout0_215ck360 FIND v(dout0_215) AT=185.025n

.meas tran vdout0_216ck360 FIND v(dout0_216) AT=185.025n

.meas tran vdout0_217ck360 FIND v(dout0_217) AT=185.025n

.meas tran vdout0_218ck360 FIND v(dout0_218) AT=185.025n

.meas tran vdout0_219ck360 FIND v(dout0_219) AT=185.025n

.meas tran vdout0_220ck360 FIND v(dout0_220) AT=185.025n

.meas tran vdout0_221ck360 FIND v(dout0_221) AT=185.025n

.meas tran vdout0_222ck360 FIND v(dout0_222) AT=185.025n

.meas tran vdout0_223ck360 FIND v(dout0_223) AT=185.025n

.meas tran vdout0_224ck360 FIND v(dout0_224) AT=185.025n

.meas tran vdout0_225ck360 FIND v(dout0_225) AT=185.025n

.meas tran vdout0_226ck360 FIND v(dout0_226) AT=185.025n

.meas tran vdout0_227ck360 FIND v(dout0_227) AT=185.025n

.meas tran vdout0_228ck360 FIND v(dout0_228) AT=185.025n

.meas tran vdout0_229ck360 FIND v(dout0_229) AT=185.025n

.meas tran vdout0_230ck360 FIND v(dout0_230) AT=185.025n

.meas tran vdout0_231ck360 FIND v(dout0_231) AT=185.025n

.meas tran vdout0_232ck360 FIND v(dout0_232) AT=185.025n

.meas tran vdout0_233ck360 FIND v(dout0_233) AT=185.025n

.meas tran vdout0_234ck360 FIND v(dout0_234) AT=185.025n

.meas tran vdout0_235ck360 FIND v(dout0_235) AT=185.025n

.meas tran vdout0_236ck360 FIND v(dout0_236) AT=185.025n

.meas tran vdout0_237ck360 FIND v(dout0_237) AT=185.025n

.meas tran vdout0_238ck360 FIND v(dout0_238) AT=185.025n

.meas tran vdout0_239ck360 FIND v(dout0_239) AT=185.025n

.meas tran vdout0_240ck360 FIND v(dout0_240) AT=185.025n

.meas tran vdout0_241ck360 FIND v(dout0_241) AT=185.025n

.meas tran vdout0_242ck360 FIND v(dout0_242) AT=185.025n

.meas tran vdout0_243ck360 FIND v(dout0_243) AT=185.025n

.meas tran vdout0_244ck360 FIND v(dout0_244) AT=185.025n

.meas tran vdout0_245ck360 FIND v(dout0_245) AT=185.025n

.meas tran vdout0_246ck360 FIND v(dout0_246) AT=185.025n

.meas tran vdout0_247ck360 FIND v(dout0_247) AT=185.025n

.meas tran vdout0_248ck360 FIND v(dout0_248) AT=185.025n

.meas tran vdout0_249ck360 FIND v(dout0_249) AT=185.025n

.meas tran vdout0_250ck360 FIND v(dout0_250) AT=185.025n

.meas tran vdout0_251ck360 FIND v(dout0_251) AT=185.025n

.meas tran vdout0_252ck360 FIND v(dout0_252) AT=185.025n

.meas tran vdout0_253ck360 FIND v(dout0_253) AT=185.025n

.meas tran vdout0_254ck360 FIND v(dout0_254) AT=185.025n

.meas tran vdout0_255ck360 FIND v(dout0_255) AT=185.025n

.meas tran vdout0_0ck370 FIND v(dout0_0) AT=190.025n

.meas tran vdout0_1ck370 FIND v(dout0_1) AT=190.025n

.meas tran vdout0_2ck370 FIND v(dout0_2) AT=190.025n

.meas tran vdout0_3ck370 FIND v(dout0_3) AT=190.025n

.meas tran vdout0_4ck370 FIND v(dout0_4) AT=190.025n

.meas tran vdout0_5ck370 FIND v(dout0_5) AT=190.025n

.meas tran vdout0_6ck370 FIND v(dout0_6) AT=190.025n

.meas tran vdout0_7ck370 FIND v(dout0_7) AT=190.025n

.meas tran vdout0_8ck370 FIND v(dout0_8) AT=190.025n

.meas tran vdout0_9ck370 FIND v(dout0_9) AT=190.025n

.meas tran vdout0_10ck370 FIND v(dout0_10) AT=190.025n

.meas tran vdout0_11ck370 FIND v(dout0_11) AT=190.025n

.meas tran vdout0_12ck370 FIND v(dout0_12) AT=190.025n

.meas tran vdout0_13ck370 FIND v(dout0_13) AT=190.025n

.meas tran vdout0_14ck370 FIND v(dout0_14) AT=190.025n

.meas tran vdout0_15ck370 FIND v(dout0_15) AT=190.025n

.meas tran vdout0_16ck370 FIND v(dout0_16) AT=190.025n

.meas tran vdout0_17ck370 FIND v(dout0_17) AT=190.025n

.meas tran vdout0_18ck370 FIND v(dout0_18) AT=190.025n

.meas tran vdout0_19ck370 FIND v(dout0_19) AT=190.025n

.meas tran vdout0_20ck370 FIND v(dout0_20) AT=190.025n

.meas tran vdout0_21ck370 FIND v(dout0_21) AT=190.025n

.meas tran vdout0_22ck370 FIND v(dout0_22) AT=190.025n

.meas tran vdout0_23ck370 FIND v(dout0_23) AT=190.025n

.meas tran vdout0_24ck370 FIND v(dout0_24) AT=190.025n

.meas tran vdout0_25ck370 FIND v(dout0_25) AT=190.025n

.meas tran vdout0_26ck370 FIND v(dout0_26) AT=190.025n

.meas tran vdout0_27ck370 FIND v(dout0_27) AT=190.025n

.meas tran vdout0_28ck370 FIND v(dout0_28) AT=190.025n

.meas tran vdout0_29ck370 FIND v(dout0_29) AT=190.025n

.meas tran vdout0_30ck370 FIND v(dout0_30) AT=190.025n

.meas tran vdout0_31ck370 FIND v(dout0_31) AT=190.025n

.meas tran vdout0_32ck370 FIND v(dout0_32) AT=190.025n

.meas tran vdout0_33ck370 FIND v(dout0_33) AT=190.025n

.meas tran vdout0_34ck370 FIND v(dout0_34) AT=190.025n

.meas tran vdout0_35ck370 FIND v(dout0_35) AT=190.025n

.meas tran vdout0_36ck370 FIND v(dout0_36) AT=190.025n

.meas tran vdout0_37ck370 FIND v(dout0_37) AT=190.025n

.meas tran vdout0_38ck370 FIND v(dout0_38) AT=190.025n

.meas tran vdout0_39ck370 FIND v(dout0_39) AT=190.025n

.meas tran vdout0_40ck370 FIND v(dout0_40) AT=190.025n

.meas tran vdout0_41ck370 FIND v(dout0_41) AT=190.025n

.meas tran vdout0_42ck370 FIND v(dout0_42) AT=190.025n

.meas tran vdout0_43ck370 FIND v(dout0_43) AT=190.025n

.meas tran vdout0_44ck370 FIND v(dout0_44) AT=190.025n

.meas tran vdout0_45ck370 FIND v(dout0_45) AT=190.025n

.meas tran vdout0_46ck370 FIND v(dout0_46) AT=190.025n

.meas tran vdout0_47ck370 FIND v(dout0_47) AT=190.025n

.meas tran vdout0_48ck370 FIND v(dout0_48) AT=190.025n

.meas tran vdout0_49ck370 FIND v(dout0_49) AT=190.025n

.meas tran vdout0_50ck370 FIND v(dout0_50) AT=190.025n

.meas tran vdout0_51ck370 FIND v(dout0_51) AT=190.025n

.meas tran vdout0_52ck370 FIND v(dout0_52) AT=190.025n

.meas tran vdout0_53ck370 FIND v(dout0_53) AT=190.025n

.meas tran vdout0_54ck370 FIND v(dout0_54) AT=190.025n

.meas tran vdout0_55ck370 FIND v(dout0_55) AT=190.025n

.meas tran vdout0_56ck370 FIND v(dout0_56) AT=190.025n

.meas tran vdout0_57ck370 FIND v(dout0_57) AT=190.025n

.meas tran vdout0_58ck370 FIND v(dout0_58) AT=190.025n

.meas tran vdout0_59ck370 FIND v(dout0_59) AT=190.025n

.meas tran vdout0_60ck370 FIND v(dout0_60) AT=190.025n

.meas tran vdout0_61ck370 FIND v(dout0_61) AT=190.025n

.meas tran vdout0_62ck370 FIND v(dout0_62) AT=190.025n

.meas tran vdout0_63ck370 FIND v(dout0_63) AT=190.025n

.meas tran vdout0_64ck370 FIND v(dout0_64) AT=190.025n

.meas tran vdout0_65ck370 FIND v(dout0_65) AT=190.025n

.meas tran vdout0_66ck370 FIND v(dout0_66) AT=190.025n

.meas tran vdout0_67ck370 FIND v(dout0_67) AT=190.025n

.meas tran vdout0_68ck370 FIND v(dout0_68) AT=190.025n

.meas tran vdout0_69ck370 FIND v(dout0_69) AT=190.025n

.meas tran vdout0_70ck370 FIND v(dout0_70) AT=190.025n

.meas tran vdout0_71ck370 FIND v(dout0_71) AT=190.025n

.meas tran vdout0_72ck370 FIND v(dout0_72) AT=190.025n

.meas tran vdout0_73ck370 FIND v(dout0_73) AT=190.025n

.meas tran vdout0_74ck370 FIND v(dout0_74) AT=190.025n

.meas tran vdout0_75ck370 FIND v(dout0_75) AT=190.025n

.meas tran vdout0_76ck370 FIND v(dout0_76) AT=190.025n

.meas tran vdout0_77ck370 FIND v(dout0_77) AT=190.025n

.meas tran vdout0_78ck370 FIND v(dout0_78) AT=190.025n

.meas tran vdout0_79ck370 FIND v(dout0_79) AT=190.025n

.meas tran vdout0_80ck370 FIND v(dout0_80) AT=190.025n

.meas tran vdout0_81ck370 FIND v(dout0_81) AT=190.025n

.meas tran vdout0_82ck370 FIND v(dout0_82) AT=190.025n

.meas tran vdout0_83ck370 FIND v(dout0_83) AT=190.025n

.meas tran vdout0_84ck370 FIND v(dout0_84) AT=190.025n

.meas tran vdout0_85ck370 FIND v(dout0_85) AT=190.025n

.meas tran vdout0_86ck370 FIND v(dout0_86) AT=190.025n

.meas tran vdout0_87ck370 FIND v(dout0_87) AT=190.025n

.meas tran vdout0_88ck370 FIND v(dout0_88) AT=190.025n

.meas tran vdout0_89ck370 FIND v(dout0_89) AT=190.025n

.meas tran vdout0_90ck370 FIND v(dout0_90) AT=190.025n

.meas tran vdout0_91ck370 FIND v(dout0_91) AT=190.025n

.meas tran vdout0_92ck370 FIND v(dout0_92) AT=190.025n

.meas tran vdout0_93ck370 FIND v(dout0_93) AT=190.025n

.meas tran vdout0_94ck370 FIND v(dout0_94) AT=190.025n

.meas tran vdout0_95ck370 FIND v(dout0_95) AT=190.025n

.meas tran vdout0_96ck370 FIND v(dout0_96) AT=190.025n

.meas tran vdout0_97ck370 FIND v(dout0_97) AT=190.025n

.meas tran vdout0_98ck370 FIND v(dout0_98) AT=190.025n

.meas tran vdout0_99ck370 FIND v(dout0_99) AT=190.025n

.meas tran vdout0_100ck370 FIND v(dout0_100) AT=190.025n

.meas tran vdout0_101ck370 FIND v(dout0_101) AT=190.025n

.meas tran vdout0_102ck370 FIND v(dout0_102) AT=190.025n

.meas tran vdout0_103ck370 FIND v(dout0_103) AT=190.025n

.meas tran vdout0_104ck370 FIND v(dout0_104) AT=190.025n

.meas tran vdout0_105ck370 FIND v(dout0_105) AT=190.025n

.meas tran vdout0_106ck370 FIND v(dout0_106) AT=190.025n

.meas tran vdout0_107ck370 FIND v(dout0_107) AT=190.025n

.meas tran vdout0_108ck370 FIND v(dout0_108) AT=190.025n

.meas tran vdout0_109ck370 FIND v(dout0_109) AT=190.025n

.meas tran vdout0_110ck370 FIND v(dout0_110) AT=190.025n

.meas tran vdout0_111ck370 FIND v(dout0_111) AT=190.025n

.meas tran vdout0_112ck370 FIND v(dout0_112) AT=190.025n

.meas tran vdout0_113ck370 FIND v(dout0_113) AT=190.025n

.meas tran vdout0_114ck370 FIND v(dout0_114) AT=190.025n

.meas tran vdout0_115ck370 FIND v(dout0_115) AT=190.025n

.meas tran vdout0_116ck370 FIND v(dout0_116) AT=190.025n

.meas tran vdout0_117ck370 FIND v(dout0_117) AT=190.025n

.meas tran vdout0_118ck370 FIND v(dout0_118) AT=190.025n

.meas tran vdout0_119ck370 FIND v(dout0_119) AT=190.025n

.meas tran vdout0_120ck370 FIND v(dout0_120) AT=190.025n

.meas tran vdout0_121ck370 FIND v(dout0_121) AT=190.025n

.meas tran vdout0_122ck370 FIND v(dout0_122) AT=190.025n

.meas tran vdout0_123ck370 FIND v(dout0_123) AT=190.025n

.meas tran vdout0_124ck370 FIND v(dout0_124) AT=190.025n

.meas tran vdout0_125ck370 FIND v(dout0_125) AT=190.025n

.meas tran vdout0_126ck370 FIND v(dout0_126) AT=190.025n

.meas tran vdout0_127ck370 FIND v(dout0_127) AT=190.025n

.meas tran vdout0_128ck370 FIND v(dout0_128) AT=190.025n

.meas tran vdout0_129ck370 FIND v(dout0_129) AT=190.025n

.meas tran vdout0_130ck370 FIND v(dout0_130) AT=190.025n

.meas tran vdout0_131ck370 FIND v(dout0_131) AT=190.025n

.meas tran vdout0_132ck370 FIND v(dout0_132) AT=190.025n

.meas tran vdout0_133ck370 FIND v(dout0_133) AT=190.025n

.meas tran vdout0_134ck370 FIND v(dout0_134) AT=190.025n

.meas tran vdout0_135ck370 FIND v(dout0_135) AT=190.025n

.meas tran vdout0_136ck370 FIND v(dout0_136) AT=190.025n

.meas tran vdout0_137ck370 FIND v(dout0_137) AT=190.025n

.meas tran vdout0_138ck370 FIND v(dout0_138) AT=190.025n

.meas tran vdout0_139ck370 FIND v(dout0_139) AT=190.025n

.meas tran vdout0_140ck370 FIND v(dout0_140) AT=190.025n

.meas tran vdout0_141ck370 FIND v(dout0_141) AT=190.025n

.meas tran vdout0_142ck370 FIND v(dout0_142) AT=190.025n

.meas tran vdout0_143ck370 FIND v(dout0_143) AT=190.025n

.meas tran vdout0_144ck370 FIND v(dout0_144) AT=190.025n

.meas tran vdout0_145ck370 FIND v(dout0_145) AT=190.025n

.meas tran vdout0_146ck370 FIND v(dout0_146) AT=190.025n

.meas tran vdout0_147ck370 FIND v(dout0_147) AT=190.025n

.meas tran vdout0_148ck370 FIND v(dout0_148) AT=190.025n

.meas tran vdout0_149ck370 FIND v(dout0_149) AT=190.025n

.meas tran vdout0_150ck370 FIND v(dout0_150) AT=190.025n

.meas tran vdout0_151ck370 FIND v(dout0_151) AT=190.025n

.meas tran vdout0_152ck370 FIND v(dout0_152) AT=190.025n

.meas tran vdout0_153ck370 FIND v(dout0_153) AT=190.025n

.meas tran vdout0_154ck370 FIND v(dout0_154) AT=190.025n

.meas tran vdout0_155ck370 FIND v(dout0_155) AT=190.025n

.meas tran vdout0_156ck370 FIND v(dout0_156) AT=190.025n

.meas tran vdout0_157ck370 FIND v(dout0_157) AT=190.025n

.meas tran vdout0_158ck370 FIND v(dout0_158) AT=190.025n

.meas tran vdout0_159ck370 FIND v(dout0_159) AT=190.025n

.meas tran vdout0_160ck370 FIND v(dout0_160) AT=190.025n

.meas tran vdout0_161ck370 FIND v(dout0_161) AT=190.025n

.meas tran vdout0_162ck370 FIND v(dout0_162) AT=190.025n

.meas tran vdout0_163ck370 FIND v(dout0_163) AT=190.025n

.meas tran vdout0_164ck370 FIND v(dout0_164) AT=190.025n

.meas tran vdout0_165ck370 FIND v(dout0_165) AT=190.025n

.meas tran vdout0_166ck370 FIND v(dout0_166) AT=190.025n

.meas tran vdout0_167ck370 FIND v(dout0_167) AT=190.025n

.meas tran vdout0_168ck370 FIND v(dout0_168) AT=190.025n

.meas tran vdout0_169ck370 FIND v(dout0_169) AT=190.025n

.meas tran vdout0_170ck370 FIND v(dout0_170) AT=190.025n

.meas tran vdout0_171ck370 FIND v(dout0_171) AT=190.025n

.meas tran vdout0_172ck370 FIND v(dout0_172) AT=190.025n

.meas tran vdout0_173ck370 FIND v(dout0_173) AT=190.025n

.meas tran vdout0_174ck370 FIND v(dout0_174) AT=190.025n

.meas tran vdout0_175ck370 FIND v(dout0_175) AT=190.025n

.meas tran vdout0_176ck370 FIND v(dout0_176) AT=190.025n

.meas tran vdout0_177ck370 FIND v(dout0_177) AT=190.025n

.meas tran vdout0_178ck370 FIND v(dout0_178) AT=190.025n

.meas tran vdout0_179ck370 FIND v(dout0_179) AT=190.025n

.meas tran vdout0_180ck370 FIND v(dout0_180) AT=190.025n

.meas tran vdout0_181ck370 FIND v(dout0_181) AT=190.025n

.meas tran vdout0_182ck370 FIND v(dout0_182) AT=190.025n

.meas tran vdout0_183ck370 FIND v(dout0_183) AT=190.025n

.meas tran vdout0_184ck370 FIND v(dout0_184) AT=190.025n

.meas tran vdout0_185ck370 FIND v(dout0_185) AT=190.025n

.meas tran vdout0_186ck370 FIND v(dout0_186) AT=190.025n

.meas tran vdout0_187ck370 FIND v(dout0_187) AT=190.025n

.meas tran vdout0_188ck370 FIND v(dout0_188) AT=190.025n

.meas tran vdout0_189ck370 FIND v(dout0_189) AT=190.025n

.meas tran vdout0_190ck370 FIND v(dout0_190) AT=190.025n

.meas tran vdout0_191ck370 FIND v(dout0_191) AT=190.025n

.meas tran vdout0_192ck370 FIND v(dout0_192) AT=190.025n

.meas tran vdout0_193ck370 FIND v(dout0_193) AT=190.025n

.meas tran vdout0_194ck370 FIND v(dout0_194) AT=190.025n

.meas tran vdout0_195ck370 FIND v(dout0_195) AT=190.025n

.meas tran vdout0_196ck370 FIND v(dout0_196) AT=190.025n

.meas tran vdout0_197ck370 FIND v(dout0_197) AT=190.025n

.meas tran vdout0_198ck370 FIND v(dout0_198) AT=190.025n

.meas tran vdout0_199ck370 FIND v(dout0_199) AT=190.025n

.meas tran vdout0_200ck370 FIND v(dout0_200) AT=190.025n

.meas tran vdout0_201ck370 FIND v(dout0_201) AT=190.025n

.meas tran vdout0_202ck370 FIND v(dout0_202) AT=190.025n

.meas tran vdout0_203ck370 FIND v(dout0_203) AT=190.025n

.meas tran vdout0_204ck370 FIND v(dout0_204) AT=190.025n

.meas tran vdout0_205ck370 FIND v(dout0_205) AT=190.025n

.meas tran vdout0_206ck370 FIND v(dout0_206) AT=190.025n

.meas tran vdout0_207ck370 FIND v(dout0_207) AT=190.025n

.meas tran vdout0_208ck370 FIND v(dout0_208) AT=190.025n

.meas tran vdout0_209ck370 FIND v(dout0_209) AT=190.025n

.meas tran vdout0_210ck370 FIND v(dout0_210) AT=190.025n

.meas tran vdout0_211ck370 FIND v(dout0_211) AT=190.025n

.meas tran vdout0_212ck370 FIND v(dout0_212) AT=190.025n

.meas tran vdout0_213ck370 FIND v(dout0_213) AT=190.025n

.meas tran vdout0_214ck370 FIND v(dout0_214) AT=190.025n

.meas tran vdout0_215ck370 FIND v(dout0_215) AT=190.025n

.meas tran vdout0_216ck370 FIND v(dout0_216) AT=190.025n

.meas tran vdout0_217ck370 FIND v(dout0_217) AT=190.025n

.meas tran vdout0_218ck370 FIND v(dout0_218) AT=190.025n

.meas tran vdout0_219ck370 FIND v(dout0_219) AT=190.025n

.meas tran vdout0_220ck370 FIND v(dout0_220) AT=190.025n

.meas tran vdout0_221ck370 FIND v(dout0_221) AT=190.025n

.meas tran vdout0_222ck370 FIND v(dout0_222) AT=190.025n

.meas tran vdout0_223ck370 FIND v(dout0_223) AT=190.025n

.meas tran vdout0_224ck370 FIND v(dout0_224) AT=190.025n

.meas tran vdout0_225ck370 FIND v(dout0_225) AT=190.025n

.meas tran vdout0_226ck370 FIND v(dout0_226) AT=190.025n

.meas tran vdout0_227ck370 FIND v(dout0_227) AT=190.025n

.meas tran vdout0_228ck370 FIND v(dout0_228) AT=190.025n

.meas tran vdout0_229ck370 FIND v(dout0_229) AT=190.025n

.meas tran vdout0_230ck370 FIND v(dout0_230) AT=190.025n

.meas tran vdout0_231ck370 FIND v(dout0_231) AT=190.025n

.meas tran vdout0_232ck370 FIND v(dout0_232) AT=190.025n

.meas tran vdout0_233ck370 FIND v(dout0_233) AT=190.025n

.meas tran vdout0_234ck370 FIND v(dout0_234) AT=190.025n

.meas tran vdout0_235ck370 FIND v(dout0_235) AT=190.025n

.meas tran vdout0_236ck370 FIND v(dout0_236) AT=190.025n

.meas tran vdout0_237ck370 FIND v(dout0_237) AT=190.025n

.meas tran vdout0_238ck370 FIND v(dout0_238) AT=190.025n

.meas tran vdout0_239ck370 FIND v(dout0_239) AT=190.025n

.meas tran vdout0_240ck370 FIND v(dout0_240) AT=190.025n

.meas tran vdout0_241ck370 FIND v(dout0_241) AT=190.025n

.meas tran vdout0_242ck370 FIND v(dout0_242) AT=190.025n

.meas tran vdout0_243ck370 FIND v(dout0_243) AT=190.025n

.meas tran vdout0_244ck370 FIND v(dout0_244) AT=190.025n

.meas tran vdout0_245ck370 FIND v(dout0_245) AT=190.025n

.meas tran vdout0_246ck370 FIND v(dout0_246) AT=190.025n

.meas tran vdout0_247ck370 FIND v(dout0_247) AT=190.025n

.meas tran vdout0_248ck370 FIND v(dout0_248) AT=190.025n

.meas tran vdout0_249ck370 FIND v(dout0_249) AT=190.025n

.meas tran vdout0_250ck370 FIND v(dout0_250) AT=190.025n

.meas tran vdout0_251ck370 FIND v(dout0_251) AT=190.025n

.meas tran vdout0_252ck370 FIND v(dout0_252) AT=190.025n

.meas tran vdout0_253ck370 FIND v(dout0_253) AT=190.025n

.meas tran vdout0_254ck370 FIND v(dout0_254) AT=190.025n

.meas tran vdout0_255ck370 FIND v(dout0_255) AT=190.025n

.meas tran vdout0_0ck390 FIND v(dout0_0) AT=200.025n

.meas tran vdout0_1ck390 FIND v(dout0_1) AT=200.025n

.meas tran vdout0_2ck390 FIND v(dout0_2) AT=200.025n

.meas tran vdout0_3ck390 FIND v(dout0_3) AT=200.025n

.meas tran vdout0_4ck390 FIND v(dout0_4) AT=200.025n

.meas tran vdout0_5ck390 FIND v(dout0_5) AT=200.025n

.meas tran vdout0_6ck390 FIND v(dout0_6) AT=200.025n

.meas tran vdout0_7ck390 FIND v(dout0_7) AT=200.025n

.meas tran vdout0_8ck390 FIND v(dout0_8) AT=200.025n

.meas tran vdout0_9ck390 FIND v(dout0_9) AT=200.025n

.meas tran vdout0_10ck390 FIND v(dout0_10) AT=200.025n

.meas tran vdout0_11ck390 FIND v(dout0_11) AT=200.025n

.meas tran vdout0_12ck390 FIND v(dout0_12) AT=200.025n

.meas tran vdout0_13ck390 FIND v(dout0_13) AT=200.025n

.meas tran vdout0_14ck390 FIND v(dout0_14) AT=200.025n

.meas tran vdout0_15ck390 FIND v(dout0_15) AT=200.025n

.meas tran vdout0_16ck390 FIND v(dout0_16) AT=200.025n

.meas tran vdout0_17ck390 FIND v(dout0_17) AT=200.025n

.meas tran vdout0_18ck390 FIND v(dout0_18) AT=200.025n

.meas tran vdout0_19ck390 FIND v(dout0_19) AT=200.025n

.meas tran vdout0_20ck390 FIND v(dout0_20) AT=200.025n

.meas tran vdout0_21ck390 FIND v(dout0_21) AT=200.025n

.meas tran vdout0_22ck390 FIND v(dout0_22) AT=200.025n

.meas tran vdout0_23ck390 FIND v(dout0_23) AT=200.025n

.meas tran vdout0_24ck390 FIND v(dout0_24) AT=200.025n

.meas tran vdout0_25ck390 FIND v(dout0_25) AT=200.025n

.meas tran vdout0_26ck390 FIND v(dout0_26) AT=200.025n

.meas tran vdout0_27ck390 FIND v(dout0_27) AT=200.025n

.meas tran vdout0_28ck390 FIND v(dout0_28) AT=200.025n

.meas tran vdout0_29ck390 FIND v(dout0_29) AT=200.025n

.meas tran vdout0_30ck390 FIND v(dout0_30) AT=200.025n

.meas tran vdout0_31ck390 FIND v(dout0_31) AT=200.025n

.meas tran vdout0_32ck390 FIND v(dout0_32) AT=200.025n

.meas tran vdout0_33ck390 FIND v(dout0_33) AT=200.025n

.meas tran vdout0_34ck390 FIND v(dout0_34) AT=200.025n

.meas tran vdout0_35ck390 FIND v(dout0_35) AT=200.025n

.meas tran vdout0_36ck390 FIND v(dout0_36) AT=200.025n

.meas tran vdout0_37ck390 FIND v(dout0_37) AT=200.025n

.meas tran vdout0_38ck390 FIND v(dout0_38) AT=200.025n

.meas tran vdout0_39ck390 FIND v(dout0_39) AT=200.025n

.meas tran vdout0_40ck390 FIND v(dout0_40) AT=200.025n

.meas tran vdout0_41ck390 FIND v(dout0_41) AT=200.025n

.meas tran vdout0_42ck390 FIND v(dout0_42) AT=200.025n

.meas tran vdout0_43ck390 FIND v(dout0_43) AT=200.025n

.meas tran vdout0_44ck390 FIND v(dout0_44) AT=200.025n

.meas tran vdout0_45ck390 FIND v(dout0_45) AT=200.025n

.meas tran vdout0_46ck390 FIND v(dout0_46) AT=200.025n

.meas tran vdout0_47ck390 FIND v(dout0_47) AT=200.025n

.meas tran vdout0_48ck390 FIND v(dout0_48) AT=200.025n

.meas tran vdout0_49ck390 FIND v(dout0_49) AT=200.025n

.meas tran vdout0_50ck390 FIND v(dout0_50) AT=200.025n

.meas tran vdout0_51ck390 FIND v(dout0_51) AT=200.025n

.meas tran vdout0_52ck390 FIND v(dout0_52) AT=200.025n

.meas tran vdout0_53ck390 FIND v(dout0_53) AT=200.025n

.meas tran vdout0_54ck390 FIND v(dout0_54) AT=200.025n

.meas tran vdout0_55ck390 FIND v(dout0_55) AT=200.025n

.meas tran vdout0_56ck390 FIND v(dout0_56) AT=200.025n

.meas tran vdout0_57ck390 FIND v(dout0_57) AT=200.025n

.meas tran vdout0_58ck390 FIND v(dout0_58) AT=200.025n

.meas tran vdout0_59ck390 FIND v(dout0_59) AT=200.025n

.meas tran vdout0_60ck390 FIND v(dout0_60) AT=200.025n

.meas tran vdout0_61ck390 FIND v(dout0_61) AT=200.025n

.meas tran vdout0_62ck390 FIND v(dout0_62) AT=200.025n

.meas tran vdout0_63ck390 FIND v(dout0_63) AT=200.025n

.meas tran vdout0_64ck390 FIND v(dout0_64) AT=200.025n

.meas tran vdout0_65ck390 FIND v(dout0_65) AT=200.025n

.meas tran vdout0_66ck390 FIND v(dout0_66) AT=200.025n

.meas tran vdout0_67ck390 FIND v(dout0_67) AT=200.025n

.meas tran vdout0_68ck390 FIND v(dout0_68) AT=200.025n

.meas tran vdout0_69ck390 FIND v(dout0_69) AT=200.025n

.meas tran vdout0_70ck390 FIND v(dout0_70) AT=200.025n

.meas tran vdout0_71ck390 FIND v(dout0_71) AT=200.025n

.meas tran vdout0_72ck390 FIND v(dout0_72) AT=200.025n

.meas tran vdout0_73ck390 FIND v(dout0_73) AT=200.025n

.meas tran vdout0_74ck390 FIND v(dout0_74) AT=200.025n

.meas tran vdout0_75ck390 FIND v(dout0_75) AT=200.025n

.meas tran vdout0_76ck390 FIND v(dout0_76) AT=200.025n

.meas tran vdout0_77ck390 FIND v(dout0_77) AT=200.025n

.meas tran vdout0_78ck390 FIND v(dout0_78) AT=200.025n

.meas tran vdout0_79ck390 FIND v(dout0_79) AT=200.025n

.meas tran vdout0_80ck390 FIND v(dout0_80) AT=200.025n

.meas tran vdout0_81ck390 FIND v(dout0_81) AT=200.025n

.meas tran vdout0_82ck390 FIND v(dout0_82) AT=200.025n

.meas tran vdout0_83ck390 FIND v(dout0_83) AT=200.025n

.meas tran vdout0_84ck390 FIND v(dout0_84) AT=200.025n

.meas tran vdout0_85ck390 FIND v(dout0_85) AT=200.025n

.meas tran vdout0_86ck390 FIND v(dout0_86) AT=200.025n

.meas tran vdout0_87ck390 FIND v(dout0_87) AT=200.025n

.meas tran vdout0_88ck390 FIND v(dout0_88) AT=200.025n

.meas tran vdout0_89ck390 FIND v(dout0_89) AT=200.025n

.meas tran vdout0_90ck390 FIND v(dout0_90) AT=200.025n

.meas tran vdout0_91ck390 FIND v(dout0_91) AT=200.025n

.meas tran vdout0_92ck390 FIND v(dout0_92) AT=200.025n

.meas tran vdout0_93ck390 FIND v(dout0_93) AT=200.025n

.meas tran vdout0_94ck390 FIND v(dout0_94) AT=200.025n

.meas tran vdout0_95ck390 FIND v(dout0_95) AT=200.025n

.meas tran vdout0_96ck390 FIND v(dout0_96) AT=200.025n

.meas tran vdout0_97ck390 FIND v(dout0_97) AT=200.025n

.meas tran vdout0_98ck390 FIND v(dout0_98) AT=200.025n

.meas tran vdout0_99ck390 FIND v(dout0_99) AT=200.025n

.meas tran vdout0_100ck390 FIND v(dout0_100) AT=200.025n

.meas tran vdout0_101ck390 FIND v(dout0_101) AT=200.025n

.meas tran vdout0_102ck390 FIND v(dout0_102) AT=200.025n

.meas tran vdout0_103ck390 FIND v(dout0_103) AT=200.025n

.meas tran vdout0_104ck390 FIND v(dout0_104) AT=200.025n

.meas tran vdout0_105ck390 FIND v(dout0_105) AT=200.025n

.meas tran vdout0_106ck390 FIND v(dout0_106) AT=200.025n

.meas tran vdout0_107ck390 FIND v(dout0_107) AT=200.025n

.meas tran vdout0_108ck390 FIND v(dout0_108) AT=200.025n

.meas tran vdout0_109ck390 FIND v(dout0_109) AT=200.025n

.meas tran vdout0_110ck390 FIND v(dout0_110) AT=200.025n

.meas tran vdout0_111ck390 FIND v(dout0_111) AT=200.025n

.meas tran vdout0_112ck390 FIND v(dout0_112) AT=200.025n

.meas tran vdout0_113ck390 FIND v(dout0_113) AT=200.025n

.meas tran vdout0_114ck390 FIND v(dout0_114) AT=200.025n

.meas tran vdout0_115ck390 FIND v(dout0_115) AT=200.025n

.meas tran vdout0_116ck390 FIND v(dout0_116) AT=200.025n

.meas tran vdout0_117ck390 FIND v(dout0_117) AT=200.025n

.meas tran vdout0_118ck390 FIND v(dout0_118) AT=200.025n

.meas tran vdout0_119ck390 FIND v(dout0_119) AT=200.025n

.meas tran vdout0_120ck390 FIND v(dout0_120) AT=200.025n

.meas tran vdout0_121ck390 FIND v(dout0_121) AT=200.025n

.meas tran vdout0_122ck390 FIND v(dout0_122) AT=200.025n

.meas tran vdout0_123ck390 FIND v(dout0_123) AT=200.025n

.meas tran vdout0_124ck390 FIND v(dout0_124) AT=200.025n

.meas tran vdout0_125ck390 FIND v(dout0_125) AT=200.025n

.meas tran vdout0_126ck390 FIND v(dout0_126) AT=200.025n

.meas tran vdout0_127ck390 FIND v(dout0_127) AT=200.025n

.meas tran vdout0_128ck390 FIND v(dout0_128) AT=200.025n

.meas tran vdout0_129ck390 FIND v(dout0_129) AT=200.025n

.meas tran vdout0_130ck390 FIND v(dout0_130) AT=200.025n

.meas tran vdout0_131ck390 FIND v(dout0_131) AT=200.025n

.meas tran vdout0_132ck390 FIND v(dout0_132) AT=200.025n

.meas tran vdout0_133ck390 FIND v(dout0_133) AT=200.025n

.meas tran vdout0_134ck390 FIND v(dout0_134) AT=200.025n

.meas tran vdout0_135ck390 FIND v(dout0_135) AT=200.025n

.meas tran vdout0_136ck390 FIND v(dout0_136) AT=200.025n

.meas tran vdout0_137ck390 FIND v(dout0_137) AT=200.025n

.meas tran vdout0_138ck390 FIND v(dout0_138) AT=200.025n

.meas tran vdout0_139ck390 FIND v(dout0_139) AT=200.025n

.meas tran vdout0_140ck390 FIND v(dout0_140) AT=200.025n

.meas tran vdout0_141ck390 FIND v(dout0_141) AT=200.025n

.meas tran vdout0_142ck390 FIND v(dout0_142) AT=200.025n

.meas tran vdout0_143ck390 FIND v(dout0_143) AT=200.025n

.meas tran vdout0_144ck390 FIND v(dout0_144) AT=200.025n

.meas tran vdout0_145ck390 FIND v(dout0_145) AT=200.025n

.meas tran vdout0_146ck390 FIND v(dout0_146) AT=200.025n

.meas tran vdout0_147ck390 FIND v(dout0_147) AT=200.025n

.meas tran vdout0_148ck390 FIND v(dout0_148) AT=200.025n

.meas tran vdout0_149ck390 FIND v(dout0_149) AT=200.025n

.meas tran vdout0_150ck390 FIND v(dout0_150) AT=200.025n

.meas tran vdout0_151ck390 FIND v(dout0_151) AT=200.025n

.meas tran vdout0_152ck390 FIND v(dout0_152) AT=200.025n

.meas tran vdout0_153ck390 FIND v(dout0_153) AT=200.025n

.meas tran vdout0_154ck390 FIND v(dout0_154) AT=200.025n

.meas tran vdout0_155ck390 FIND v(dout0_155) AT=200.025n

.meas tran vdout0_156ck390 FIND v(dout0_156) AT=200.025n

.meas tran vdout0_157ck390 FIND v(dout0_157) AT=200.025n

.meas tran vdout0_158ck390 FIND v(dout0_158) AT=200.025n

.meas tran vdout0_159ck390 FIND v(dout0_159) AT=200.025n

.meas tran vdout0_160ck390 FIND v(dout0_160) AT=200.025n

.meas tran vdout0_161ck390 FIND v(dout0_161) AT=200.025n

.meas tran vdout0_162ck390 FIND v(dout0_162) AT=200.025n

.meas tran vdout0_163ck390 FIND v(dout0_163) AT=200.025n

.meas tran vdout0_164ck390 FIND v(dout0_164) AT=200.025n

.meas tran vdout0_165ck390 FIND v(dout0_165) AT=200.025n

.meas tran vdout0_166ck390 FIND v(dout0_166) AT=200.025n

.meas tran vdout0_167ck390 FIND v(dout0_167) AT=200.025n

.meas tran vdout0_168ck390 FIND v(dout0_168) AT=200.025n

.meas tran vdout0_169ck390 FIND v(dout0_169) AT=200.025n

.meas tran vdout0_170ck390 FIND v(dout0_170) AT=200.025n

.meas tran vdout0_171ck390 FIND v(dout0_171) AT=200.025n

.meas tran vdout0_172ck390 FIND v(dout0_172) AT=200.025n

.meas tran vdout0_173ck390 FIND v(dout0_173) AT=200.025n

.meas tran vdout0_174ck390 FIND v(dout0_174) AT=200.025n

.meas tran vdout0_175ck390 FIND v(dout0_175) AT=200.025n

.meas tran vdout0_176ck390 FIND v(dout0_176) AT=200.025n

.meas tran vdout0_177ck390 FIND v(dout0_177) AT=200.025n

.meas tran vdout0_178ck390 FIND v(dout0_178) AT=200.025n

.meas tran vdout0_179ck390 FIND v(dout0_179) AT=200.025n

.meas tran vdout0_180ck390 FIND v(dout0_180) AT=200.025n

.meas tran vdout0_181ck390 FIND v(dout0_181) AT=200.025n

.meas tran vdout0_182ck390 FIND v(dout0_182) AT=200.025n

.meas tran vdout0_183ck390 FIND v(dout0_183) AT=200.025n

.meas tran vdout0_184ck390 FIND v(dout0_184) AT=200.025n

.meas tran vdout0_185ck390 FIND v(dout0_185) AT=200.025n

.meas tran vdout0_186ck390 FIND v(dout0_186) AT=200.025n

.meas tran vdout0_187ck390 FIND v(dout0_187) AT=200.025n

.meas tran vdout0_188ck390 FIND v(dout0_188) AT=200.025n

.meas tran vdout0_189ck390 FIND v(dout0_189) AT=200.025n

.meas tran vdout0_190ck390 FIND v(dout0_190) AT=200.025n

.meas tran vdout0_191ck390 FIND v(dout0_191) AT=200.025n

.meas tran vdout0_192ck390 FIND v(dout0_192) AT=200.025n

.meas tran vdout0_193ck390 FIND v(dout0_193) AT=200.025n

.meas tran vdout0_194ck390 FIND v(dout0_194) AT=200.025n

.meas tran vdout0_195ck390 FIND v(dout0_195) AT=200.025n

.meas tran vdout0_196ck390 FIND v(dout0_196) AT=200.025n

.meas tran vdout0_197ck390 FIND v(dout0_197) AT=200.025n

.meas tran vdout0_198ck390 FIND v(dout0_198) AT=200.025n

.meas tran vdout0_199ck390 FIND v(dout0_199) AT=200.025n

.meas tran vdout0_200ck390 FIND v(dout0_200) AT=200.025n

.meas tran vdout0_201ck390 FIND v(dout0_201) AT=200.025n

.meas tran vdout0_202ck390 FIND v(dout0_202) AT=200.025n

.meas tran vdout0_203ck390 FIND v(dout0_203) AT=200.025n

.meas tran vdout0_204ck390 FIND v(dout0_204) AT=200.025n

.meas tran vdout0_205ck390 FIND v(dout0_205) AT=200.025n

.meas tran vdout0_206ck390 FIND v(dout0_206) AT=200.025n

.meas tran vdout0_207ck390 FIND v(dout0_207) AT=200.025n

.meas tran vdout0_208ck390 FIND v(dout0_208) AT=200.025n

.meas tran vdout0_209ck390 FIND v(dout0_209) AT=200.025n

.meas tran vdout0_210ck390 FIND v(dout0_210) AT=200.025n

.meas tran vdout0_211ck390 FIND v(dout0_211) AT=200.025n

.meas tran vdout0_212ck390 FIND v(dout0_212) AT=200.025n

.meas tran vdout0_213ck390 FIND v(dout0_213) AT=200.025n

.meas tran vdout0_214ck390 FIND v(dout0_214) AT=200.025n

.meas tran vdout0_215ck390 FIND v(dout0_215) AT=200.025n

.meas tran vdout0_216ck390 FIND v(dout0_216) AT=200.025n

.meas tran vdout0_217ck390 FIND v(dout0_217) AT=200.025n

.meas tran vdout0_218ck390 FIND v(dout0_218) AT=200.025n

.meas tran vdout0_219ck390 FIND v(dout0_219) AT=200.025n

.meas tran vdout0_220ck390 FIND v(dout0_220) AT=200.025n

.meas tran vdout0_221ck390 FIND v(dout0_221) AT=200.025n

.meas tran vdout0_222ck390 FIND v(dout0_222) AT=200.025n

.meas tran vdout0_223ck390 FIND v(dout0_223) AT=200.025n

.meas tran vdout0_224ck390 FIND v(dout0_224) AT=200.025n

.meas tran vdout0_225ck390 FIND v(dout0_225) AT=200.025n

.meas tran vdout0_226ck390 FIND v(dout0_226) AT=200.025n

.meas tran vdout0_227ck390 FIND v(dout0_227) AT=200.025n

.meas tran vdout0_228ck390 FIND v(dout0_228) AT=200.025n

.meas tran vdout0_229ck390 FIND v(dout0_229) AT=200.025n

.meas tran vdout0_230ck390 FIND v(dout0_230) AT=200.025n

.meas tran vdout0_231ck390 FIND v(dout0_231) AT=200.025n

.meas tran vdout0_232ck390 FIND v(dout0_232) AT=200.025n

.meas tran vdout0_233ck390 FIND v(dout0_233) AT=200.025n

.meas tran vdout0_234ck390 FIND v(dout0_234) AT=200.025n

.meas tran vdout0_235ck390 FIND v(dout0_235) AT=200.025n

.meas tran vdout0_236ck390 FIND v(dout0_236) AT=200.025n

.meas tran vdout0_237ck390 FIND v(dout0_237) AT=200.025n

.meas tran vdout0_238ck390 FIND v(dout0_238) AT=200.025n

.meas tran vdout0_239ck390 FIND v(dout0_239) AT=200.025n

.meas tran vdout0_240ck390 FIND v(dout0_240) AT=200.025n

.meas tran vdout0_241ck390 FIND v(dout0_241) AT=200.025n

.meas tran vdout0_242ck390 FIND v(dout0_242) AT=200.025n

.meas tran vdout0_243ck390 FIND v(dout0_243) AT=200.025n

.meas tran vdout0_244ck390 FIND v(dout0_244) AT=200.025n

.meas tran vdout0_245ck390 FIND v(dout0_245) AT=200.025n

.meas tran vdout0_246ck390 FIND v(dout0_246) AT=200.025n

.meas tran vdout0_247ck390 FIND v(dout0_247) AT=200.025n

.meas tran vdout0_248ck390 FIND v(dout0_248) AT=200.025n

.meas tran vdout0_249ck390 FIND v(dout0_249) AT=200.025n

.meas tran vdout0_250ck390 FIND v(dout0_250) AT=200.025n

.meas tran vdout0_251ck390 FIND v(dout0_251) AT=200.025n

.meas tran vdout0_252ck390 FIND v(dout0_252) AT=200.025n

.meas tran vdout0_253ck390 FIND v(dout0_253) AT=200.025n

.meas tran vdout0_254ck390 FIND v(dout0_254) AT=200.025n

.meas tran vdout0_255ck390 FIND v(dout0_255) AT=200.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_128ck410 FIND v(dout0_128) AT=210.025n

.meas tran vdout0_129ck410 FIND v(dout0_129) AT=210.025n

.meas tran vdout0_130ck410 FIND v(dout0_130) AT=210.025n

.meas tran vdout0_131ck410 FIND v(dout0_131) AT=210.025n

.meas tran vdout0_132ck410 FIND v(dout0_132) AT=210.025n

.meas tran vdout0_133ck410 FIND v(dout0_133) AT=210.025n

.meas tran vdout0_134ck410 FIND v(dout0_134) AT=210.025n

.meas tran vdout0_135ck410 FIND v(dout0_135) AT=210.025n

.meas tran vdout0_136ck410 FIND v(dout0_136) AT=210.025n

.meas tran vdout0_137ck410 FIND v(dout0_137) AT=210.025n

.meas tran vdout0_138ck410 FIND v(dout0_138) AT=210.025n

.meas tran vdout0_139ck410 FIND v(dout0_139) AT=210.025n

.meas tran vdout0_140ck410 FIND v(dout0_140) AT=210.025n

.meas tran vdout0_141ck410 FIND v(dout0_141) AT=210.025n

.meas tran vdout0_142ck410 FIND v(dout0_142) AT=210.025n

.meas tran vdout0_143ck410 FIND v(dout0_143) AT=210.025n

.meas tran vdout0_144ck410 FIND v(dout0_144) AT=210.025n

.meas tran vdout0_145ck410 FIND v(dout0_145) AT=210.025n

.meas tran vdout0_146ck410 FIND v(dout0_146) AT=210.025n

.meas tran vdout0_147ck410 FIND v(dout0_147) AT=210.025n

.meas tran vdout0_148ck410 FIND v(dout0_148) AT=210.025n

.meas tran vdout0_149ck410 FIND v(dout0_149) AT=210.025n

.meas tran vdout0_150ck410 FIND v(dout0_150) AT=210.025n

.meas tran vdout0_151ck410 FIND v(dout0_151) AT=210.025n

.meas tran vdout0_152ck410 FIND v(dout0_152) AT=210.025n

.meas tran vdout0_153ck410 FIND v(dout0_153) AT=210.025n

.meas tran vdout0_154ck410 FIND v(dout0_154) AT=210.025n

.meas tran vdout0_155ck410 FIND v(dout0_155) AT=210.025n

.meas tran vdout0_156ck410 FIND v(dout0_156) AT=210.025n

.meas tran vdout0_157ck410 FIND v(dout0_157) AT=210.025n

.meas tran vdout0_158ck410 FIND v(dout0_158) AT=210.025n

.meas tran vdout0_159ck410 FIND v(dout0_159) AT=210.025n

.meas tran vdout0_160ck410 FIND v(dout0_160) AT=210.025n

.meas tran vdout0_161ck410 FIND v(dout0_161) AT=210.025n

.meas tran vdout0_162ck410 FIND v(dout0_162) AT=210.025n

.meas tran vdout0_163ck410 FIND v(dout0_163) AT=210.025n

.meas tran vdout0_164ck410 FIND v(dout0_164) AT=210.025n

.meas tran vdout0_165ck410 FIND v(dout0_165) AT=210.025n

.meas tran vdout0_166ck410 FIND v(dout0_166) AT=210.025n

.meas tran vdout0_167ck410 FIND v(dout0_167) AT=210.025n

.meas tran vdout0_168ck410 FIND v(dout0_168) AT=210.025n

.meas tran vdout0_169ck410 FIND v(dout0_169) AT=210.025n

.meas tran vdout0_170ck410 FIND v(dout0_170) AT=210.025n

.meas tran vdout0_171ck410 FIND v(dout0_171) AT=210.025n

.meas tran vdout0_172ck410 FIND v(dout0_172) AT=210.025n

.meas tran vdout0_173ck410 FIND v(dout0_173) AT=210.025n

.meas tran vdout0_174ck410 FIND v(dout0_174) AT=210.025n

.meas tran vdout0_175ck410 FIND v(dout0_175) AT=210.025n

.meas tran vdout0_176ck410 FIND v(dout0_176) AT=210.025n

.meas tran vdout0_177ck410 FIND v(dout0_177) AT=210.025n

.meas tran vdout0_178ck410 FIND v(dout0_178) AT=210.025n

.meas tran vdout0_179ck410 FIND v(dout0_179) AT=210.025n

.meas tran vdout0_180ck410 FIND v(dout0_180) AT=210.025n

.meas tran vdout0_181ck410 FIND v(dout0_181) AT=210.025n

.meas tran vdout0_182ck410 FIND v(dout0_182) AT=210.025n

.meas tran vdout0_183ck410 FIND v(dout0_183) AT=210.025n

.meas tran vdout0_184ck410 FIND v(dout0_184) AT=210.025n

.meas tran vdout0_185ck410 FIND v(dout0_185) AT=210.025n

.meas tran vdout0_186ck410 FIND v(dout0_186) AT=210.025n

.meas tran vdout0_187ck410 FIND v(dout0_187) AT=210.025n

.meas tran vdout0_188ck410 FIND v(dout0_188) AT=210.025n

.meas tran vdout0_189ck410 FIND v(dout0_189) AT=210.025n

.meas tran vdout0_190ck410 FIND v(dout0_190) AT=210.025n

.meas tran vdout0_191ck410 FIND v(dout0_191) AT=210.025n

.meas tran vdout0_192ck410 FIND v(dout0_192) AT=210.025n

.meas tran vdout0_193ck410 FIND v(dout0_193) AT=210.025n

.meas tran vdout0_194ck410 FIND v(dout0_194) AT=210.025n

.meas tran vdout0_195ck410 FIND v(dout0_195) AT=210.025n

.meas tran vdout0_196ck410 FIND v(dout0_196) AT=210.025n

.meas tran vdout0_197ck410 FIND v(dout0_197) AT=210.025n

.meas tran vdout0_198ck410 FIND v(dout0_198) AT=210.025n

.meas tran vdout0_199ck410 FIND v(dout0_199) AT=210.025n

.meas tran vdout0_200ck410 FIND v(dout0_200) AT=210.025n

.meas tran vdout0_201ck410 FIND v(dout0_201) AT=210.025n

.meas tran vdout0_202ck410 FIND v(dout0_202) AT=210.025n

.meas tran vdout0_203ck410 FIND v(dout0_203) AT=210.025n

.meas tran vdout0_204ck410 FIND v(dout0_204) AT=210.025n

.meas tran vdout0_205ck410 FIND v(dout0_205) AT=210.025n

.meas tran vdout0_206ck410 FIND v(dout0_206) AT=210.025n

.meas tran vdout0_207ck410 FIND v(dout0_207) AT=210.025n

.meas tran vdout0_208ck410 FIND v(dout0_208) AT=210.025n

.meas tran vdout0_209ck410 FIND v(dout0_209) AT=210.025n

.meas tran vdout0_210ck410 FIND v(dout0_210) AT=210.025n

.meas tran vdout0_211ck410 FIND v(dout0_211) AT=210.025n

.meas tran vdout0_212ck410 FIND v(dout0_212) AT=210.025n

.meas tran vdout0_213ck410 FIND v(dout0_213) AT=210.025n

.meas tran vdout0_214ck410 FIND v(dout0_214) AT=210.025n

.meas tran vdout0_215ck410 FIND v(dout0_215) AT=210.025n

.meas tran vdout0_216ck410 FIND v(dout0_216) AT=210.025n

.meas tran vdout0_217ck410 FIND v(dout0_217) AT=210.025n

.meas tran vdout0_218ck410 FIND v(dout0_218) AT=210.025n

.meas tran vdout0_219ck410 FIND v(dout0_219) AT=210.025n

.meas tran vdout0_220ck410 FIND v(dout0_220) AT=210.025n

.meas tran vdout0_221ck410 FIND v(dout0_221) AT=210.025n

.meas tran vdout0_222ck410 FIND v(dout0_222) AT=210.025n

.meas tran vdout0_223ck410 FIND v(dout0_223) AT=210.025n

.meas tran vdout0_224ck410 FIND v(dout0_224) AT=210.025n

.meas tran vdout0_225ck410 FIND v(dout0_225) AT=210.025n

.meas tran vdout0_226ck410 FIND v(dout0_226) AT=210.025n

.meas tran vdout0_227ck410 FIND v(dout0_227) AT=210.025n

.meas tran vdout0_228ck410 FIND v(dout0_228) AT=210.025n

.meas tran vdout0_229ck410 FIND v(dout0_229) AT=210.025n

.meas tran vdout0_230ck410 FIND v(dout0_230) AT=210.025n

.meas tran vdout0_231ck410 FIND v(dout0_231) AT=210.025n

.meas tran vdout0_232ck410 FIND v(dout0_232) AT=210.025n

.meas tran vdout0_233ck410 FIND v(dout0_233) AT=210.025n

.meas tran vdout0_234ck410 FIND v(dout0_234) AT=210.025n

.meas tran vdout0_235ck410 FIND v(dout0_235) AT=210.025n

.meas tran vdout0_236ck410 FIND v(dout0_236) AT=210.025n

.meas tran vdout0_237ck410 FIND v(dout0_237) AT=210.025n

.meas tran vdout0_238ck410 FIND v(dout0_238) AT=210.025n

.meas tran vdout0_239ck410 FIND v(dout0_239) AT=210.025n

.meas tran vdout0_240ck410 FIND v(dout0_240) AT=210.025n

.meas tran vdout0_241ck410 FIND v(dout0_241) AT=210.025n

.meas tran vdout0_242ck410 FIND v(dout0_242) AT=210.025n

.meas tran vdout0_243ck410 FIND v(dout0_243) AT=210.025n

.meas tran vdout0_244ck410 FIND v(dout0_244) AT=210.025n

.meas tran vdout0_245ck410 FIND v(dout0_245) AT=210.025n

.meas tran vdout0_246ck410 FIND v(dout0_246) AT=210.025n

.meas tran vdout0_247ck410 FIND v(dout0_247) AT=210.025n

.meas tran vdout0_248ck410 FIND v(dout0_248) AT=210.025n

.meas tran vdout0_249ck410 FIND v(dout0_249) AT=210.025n

.meas tran vdout0_250ck410 FIND v(dout0_250) AT=210.025n

.meas tran vdout0_251ck410 FIND v(dout0_251) AT=210.025n

.meas tran vdout0_252ck410 FIND v(dout0_252) AT=210.025n

.meas tran vdout0_253ck410 FIND v(dout0_253) AT=210.025n

.meas tran vdout0_254ck410 FIND v(dout0_254) AT=210.025n

.meas tran vdout0_255ck410 FIND v(dout0_255) AT=210.025n

.meas tran vdout0_0ck420 FIND v(dout0_0) AT=215.025n

.meas tran vdout0_1ck420 FIND v(dout0_1) AT=215.025n

.meas tran vdout0_2ck420 FIND v(dout0_2) AT=215.025n

.meas tran vdout0_3ck420 FIND v(dout0_3) AT=215.025n

.meas tran vdout0_4ck420 FIND v(dout0_4) AT=215.025n

.meas tran vdout0_5ck420 FIND v(dout0_5) AT=215.025n

.meas tran vdout0_6ck420 FIND v(dout0_6) AT=215.025n

.meas tran vdout0_7ck420 FIND v(dout0_7) AT=215.025n

.meas tran vdout0_8ck420 FIND v(dout0_8) AT=215.025n

.meas tran vdout0_9ck420 FIND v(dout0_9) AT=215.025n

.meas tran vdout0_10ck420 FIND v(dout0_10) AT=215.025n

.meas tran vdout0_11ck420 FIND v(dout0_11) AT=215.025n

.meas tran vdout0_12ck420 FIND v(dout0_12) AT=215.025n

.meas tran vdout0_13ck420 FIND v(dout0_13) AT=215.025n

.meas tran vdout0_14ck420 FIND v(dout0_14) AT=215.025n

.meas tran vdout0_15ck420 FIND v(dout0_15) AT=215.025n

.meas tran vdout0_16ck420 FIND v(dout0_16) AT=215.025n

.meas tran vdout0_17ck420 FIND v(dout0_17) AT=215.025n

.meas tran vdout0_18ck420 FIND v(dout0_18) AT=215.025n

.meas tran vdout0_19ck420 FIND v(dout0_19) AT=215.025n

.meas tran vdout0_20ck420 FIND v(dout0_20) AT=215.025n

.meas tran vdout0_21ck420 FIND v(dout0_21) AT=215.025n

.meas tran vdout0_22ck420 FIND v(dout0_22) AT=215.025n

.meas tran vdout0_23ck420 FIND v(dout0_23) AT=215.025n

.meas tran vdout0_24ck420 FIND v(dout0_24) AT=215.025n

.meas tran vdout0_25ck420 FIND v(dout0_25) AT=215.025n

.meas tran vdout0_26ck420 FIND v(dout0_26) AT=215.025n

.meas tran vdout0_27ck420 FIND v(dout0_27) AT=215.025n

.meas tran vdout0_28ck420 FIND v(dout0_28) AT=215.025n

.meas tran vdout0_29ck420 FIND v(dout0_29) AT=215.025n

.meas tran vdout0_30ck420 FIND v(dout0_30) AT=215.025n

.meas tran vdout0_31ck420 FIND v(dout0_31) AT=215.025n

.meas tran vdout0_32ck420 FIND v(dout0_32) AT=215.025n

.meas tran vdout0_33ck420 FIND v(dout0_33) AT=215.025n

.meas tran vdout0_34ck420 FIND v(dout0_34) AT=215.025n

.meas tran vdout0_35ck420 FIND v(dout0_35) AT=215.025n

.meas tran vdout0_36ck420 FIND v(dout0_36) AT=215.025n

.meas tran vdout0_37ck420 FIND v(dout0_37) AT=215.025n

.meas tran vdout0_38ck420 FIND v(dout0_38) AT=215.025n

.meas tran vdout0_39ck420 FIND v(dout0_39) AT=215.025n

.meas tran vdout0_40ck420 FIND v(dout0_40) AT=215.025n

.meas tran vdout0_41ck420 FIND v(dout0_41) AT=215.025n

.meas tran vdout0_42ck420 FIND v(dout0_42) AT=215.025n

.meas tran vdout0_43ck420 FIND v(dout0_43) AT=215.025n

.meas tran vdout0_44ck420 FIND v(dout0_44) AT=215.025n

.meas tran vdout0_45ck420 FIND v(dout0_45) AT=215.025n

.meas tran vdout0_46ck420 FIND v(dout0_46) AT=215.025n

.meas tran vdout0_47ck420 FIND v(dout0_47) AT=215.025n

.meas tran vdout0_48ck420 FIND v(dout0_48) AT=215.025n

.meas tran vdout0_49ck420 FIND v(dout0_49) AT=215.025n

.meas tran vdout0_50ck420 FIND v(dout0_50) AT=215.025n

.meas tran vdout0_51ck420 FIND v(dout0_51) AT=215.025n

.meas tran vdout0_52ck420 FIND v(dout0_52) AT=215.025n

.meas tran vdout0_53ck420 FIND v(dout0_53) AT=215.025n

.meas tran vdout0_54ck420 FIND v(dout0_54) AT=215.025n

.meas tran vdout0_55ck420 FIND v(dout0_55) AT=215.025n

.meas tran vdout0_56ck420 FIND v(dout0_56) AT=215.025n

.meas tran vdout0_57ck420 FIND v(dout0_57) AT=215.025n

.meas tran vdout0_58ck420 FIND v(dout0_58) AT=215.025n

.meas tran vdout0_59ck420 FIND v(dout0_59) AT=215.025n

.meas tran vdout0_60ck420 FIND v(dout0_60) AT=215.025n

.meas tran vdout0_61ck420 FIND v(dout0_61) AT=215.025n

.meas tran vdout0_62ck420 FIND v(dout0_62) AT=215.025n

.meas tran vdout0_63ck420 FIND v(dout0_63) AT=215.025n

.meas tran vdout0_64ck420 FIND v(dout0_64) AT=215.025n

.meas tran vdout0_65ck420 FIND v(dout0_65) AT=215.025n

.meas tran vdout0_66ck420 FIND v(dout0_66) AT=215.025n

.meas tran vdout0_67ck420 FIND v(dout0_67) AT=215.025n

.meas tran vdout0_68ck420 FIND v(dout0_68) AT=215.025n

.meas tran vdout0_69ck420 FIND v(dout0_69) AT=215.025n

.meas tran vdout0_70ck420 FIND v(dout0_70) AT=215.025n

.meas tran vdout0_71ck420 FIND v(dout0_71) AT=215.025n

.meas tran vdout0_72ck420 FIND v(dout0_72) AT=215.025n

.meas tran vdout0_73ck420 FIND v(dout0_73) AT=215.025n

.meas tran vdout0_74ck420 FIND v(dout0_74) AT=215.025n

.meas tran vdout0_75ck420 FIND v(dout0_75) AT=215.025n

.meas tran vdout0_76ck420 FIND v(dout0_76) AT=215.025n

.meas tran vdout0_77ck420 FIND v(dout0_77) AT=215.025n

.meas tran vdout0_78ck420 FIND v(dout0_78) AT=215.025n

.meas tran vdout0_79ck420 FIND v(dout0_79) AT=215.025n

.meas tran vdout0_80ck420 FIND v(dout0_80) AT=215.025n

.meas tran vdout0_81ck420 FIND v(dout0_81) AT=215.025n

.meas tran vdout0_82ck420 FIND v(dout0_82) AT=215.025n

.meas tran vdout0_83ck420 FIND v(dout0_83) AT=215.025n

.meas tran vdout0_84ck420 FIND v(dout0_84) AT=215.025n

.meas tran vdout0_85ck420 FIND v(dout0_85) AT=215.025n

.meas tran vdout0_86ck420 FIND v(dout0_86) AT=215.025n

.meas tran vdout0_87ck420 FIND v(dout0_87) AT=215.025n

.meas tran vdout0_88ck420 FIND v(dout0_88) AT=215.025n

.meas tran vdout0_89ck420 FIND v(dout0_89) AT=215.025n

.meas tran vdout0_90ck420 FIND v(dout0_90) AT=215.025n

.meas tran vdout0_91ck420 FIND v(dout0_91) AT=215.025n

.meas tran vdout0_92ck420 FIND v(dout0_92) AT=215.025n

.meas tran vdout0_93ck420 FIND v(dout0_93) AT=215.025n

.meas tran vdout0_94ck420 FIND v(dout0_94) AT=215.025n

.meas tran vdout0_95ck420 FIND v(dout0_95) AT=215.025n

.meas tran vdout0_96ck420 FIND v(dout0_96) AT=215.025n

.meas tran vdout0_97ck420 FIND v(dout0_97) AT=215.025n

.meas tran vdout0_98ck420 FIND v(dout0_98) AT=215.025n

.meas tran vdout0_99ck420 FIND v(dout0_99) AT=215.025n

.meas tran vdout0_100ck420 FIND v(dout0_100) AT=215.025n

.meas tran vdout0_101ck420 FIND v(dout0_101) AT=215.025n

.meas tran vdout0_102ck420 FIND v(dout0_102) AT=215.025n

.meas tran vdout0_103ck420 FIND v(dout0_103) AT=215.025n

.meas tran vdout0_104ck420 FIND v(dout0_104) AT=215.025n

.meas tran vdout0_105ck420 FIND v(dout0_105) AT=215.025n

.meas tran vdout0_106ck420 FIND v(dout0_106) AT=215.025n

.meas tran vdout0_107ck420 FIND v(dout0_107) AT=215.025n

.meas tran vdout0_108ck420 FIND v(dout0_108) AT=215.025n

.meas tran vdout0_109ck420 FIND v(dout0_109) AT=215.025n

.meas tran vdout0_110ck420 FIND v(dout0_110) AT=215.025n

.meas tran vdout0_111ck420 FIND v(dout0_111) AT=215.025n

.meas tran vdout0_112ck420 FIND v(dout0_112) AT=215.025n

.meas tran vdout0_113ck420 FIND v(dout0_113) AT=215.025n

.meas tran vdout0_114ck420 FIND v(dout0_114) AT=215.025n

.meas tran vdout0_115ck420 FIND v(dout0_115) AT=215.025n

.meas tran vdout0_116ck420 FIND v(dout0_116) AT=215.025n

.meas tran vdout0_117ck420 FIND v(dout0_117) AT=215.025n

.meas tran vdout0_118ck420 FIND v(dout0_118) AT=215.025n

.meas tran vdout0_119ck420 FIND v(dout0_119) AT=215.025n

.meas tran vdout0_120ck420 FIND v(dout0_120) AT=215.025n

.meas tran vdout0_121ck420 FIND v(dout0_121) AT=215.025n

.meas tran vdout0_122ck420 FIND v(dout0_122) AT=215.025n

.meas tran vdout0_123ck420 FIND v(dout0_123) AT=215.025n

.meas tran vdout0_124ck420 FIND v(dout0_124) AT=215.025n

.meas tran vdout0_125ck420 FIND v(dout0_125) AT=215.025n

.meas tran vdout0_126ck420 FIND v(dout0_126) AT=215.025n

.meas tran vdout0_127ck420 FIND v(dout0_127) AT=215.025n

.meas tran vdout0_128ck420 FIND v(dout0_128) AT=215.025n

.meas tran vdout0_129ck420 FIND v(dout0_129) AT=215.025n

.meas tran vdout0_130ck420 FIND v(dout0_130) AT=215.025n

.meas tran vdout0_131ck420 FIND v(dout0_131) AT=215.025n

.meas tran vdout0_132ck420 FIND v(dout0_132) AT=215.025n

.meas tran vdout0_133ck420 FIND v(dout0_133) AT=215.025n

.meas tran vdout0_134ck420 FIND v(dout0_134) AT=215.025n

.meas tran vdout0_135ck420 FIND v(dout0_135) AT=215.025n

.meas tran vdout0_136ck420 FIND v(dout0_136) AT=215.025n

.meas tran vdout0_137ck420 FIND v(dout0_137) AT=215.025n

.meas tran vdout0_138ck420 FIND v(dout0_138) AT=215.025n

.meas tran vdout0_139ck420 FIND v(dout0_139) AT=215.025n

.meas tran vdout0_140ck420 FIND v(dout0_140) AT=215.025n

.meas tran vdout0_141ck420 FIND v(dout0_141) AT=215.025n

.meas tran vdout0_142ck420 FIND v(dout0_142) AT=215.025n

.meas tran vdout0_143ck420 FIND v(dout0_143) AT=215.025n

.meas tran vdout0_144ck420 FIND v(dout0_144) AT=215.025n

.meas tran vdout0_145ck420 FIND v(dout0_145) AT=215.025n

.meas tran vdout0_146ck420 FIND v(dout0_146) AT=215.025n

.meas tran vdout0_147ck420 FIND v(dout0_147) AT=215.025n

.meas tran vdout0_148ck420 FIND v(dout0_148) AT=215.025n

.meas tran vdout0_149ck420 FIND v(dout0_149) AT=215.025n

.meas tran vdout0_150ck420 FIND v(dout0_150) AT=215.025n

.meas tran vdout0_151ck420 FIND v(dout0_151) AT=215.025n

.meas tran vdout0_152ck420 FIND v(dout0_152) AT=215.025n

.meas tran vdout0_153ck420 FIND v(dout0_153) AT=215.025n

.meas tran vdout0_154ck420 FIND v(dout0_154) AT=215.025n

.meas tran vdout0_155ck420 FIND v(dout0_155) AT=215.025n

.meas tran vdout0_156ck420 FIND v(dout0_156) AT=215.025n

.meas tran vdout0_157ck420 FIND v(dout0_157) AT=215.025n

.meas tran vdout0_158ck420 FIND v(dout0_158) AT=215.025n

.meas tran vdout0_159ck420 FIND v(dout0_159) AT=215.025n

.meas tran vdout0_160ck420 FIND v(dout0_160) AT=215.025n

.meas tran vdout0_161ck420 FIND v(dout0_161) AT=215.025n

.meas tran vdout0_162ck420 FIND v(dout0_162) AT=215.025n

.meas tran vdout0_163ck420 FIND v(dout0_163) AT=215.025n

.meas tran vdout0_164ck420 FIND v(dout0_164) AT=215.025n

.meas tran vdout0_165ck420 FIND v(dout0_165) AT=215.025n

.meas tran vdout0_166ck420 FIND v(dout0_166) AT=215.025n

.meas tran vdout0_167ck420 FIND v(dout0_167) AT=215.025n

.meas tran vdout0_168ck420 FIND v(dout0_168) AT=215.025n

.meas tran vdout0_169ck420 FIND v(dout0_169) AT=215.025n

.meas tran vdout0_170ck420 FIND v(dout0_170) AT=215.025n

.meas tran vdout0_171ck420 FIND v(dout0_171) AT=215.025n

.meas tran vdout0_172ck420 FIND v(dout0_172) AT=215.025n

.meas tran vdout0_173ck420 FIND v(dout0_173) AT=215.025n

.meas tran vdout0_174ck420 FIND v(dout0_174) AT=215.025n

.meas tran vdout0_175ck420 FIND v(dout0_175) AT=215.025n

.meas tran vdout0_176ck420 FIND v(dout0_176) AT=215.025n

.meas tran vdout0_177ck420 FIND v(dout0_177) AT=215.025n

.meas tran vdout0_178ck420 FIND v(dout0_178) AT=215.025n

.meas tran vdout0_179ck420 FIND v(dout0_179) AT=215.025n

.meas tran vdout0_180ck420 FIND v(dout0_180) AT=215.025n

.meas tran vdout0_181ck420 FIND v(dout0_181) AT=215.025n

.meas tran vdout0_182ck420 FIND v(dout0_182) AT=215.025n

.meas tran vdout0_183ck420 FIND v(dout0_183) AT=215.025n

.meas tran vdout0_184ck420 FIND v(dout0_184) AT=215.025n

.meas tran vdout0_185ck420 FIND v(dout0_185) AT=215.025n

.meas tran vdout0_186ck420 FIND v(dout0_186) AT=215.025n

.meas tran vdout0_187ck420 FIND v(dout0_187) AT=215.025n

.meas tran vdout0_188ck420 FIND v(dout0_188) AT=215.025n

.meas tran vdout0_189ck420 FIND v(dout0_189) AT=215.025n

.meas tran vdout0_190ck420 FIND v(dout0_190) AT=215.025n

.meas tran vdout0_191ck420 FIND v(dout0_191) AT=215.025n

.meas tran vdout0_192ck420 FIND v(dout0_192) AT=215.025n

.meas tran vdout0_193ck420 FIND v(dout0_193) AT=215.025n

.meas tran vdout0_194ck420 FIND v(dout0_194) AT=215.025n

.meas tran vdout0_195ck420 FIND v(dout0_195) AT=215.025n

.meas tran vdout0_196ck420 FIND v(dout0_196) AT=215.025n

.meas tran vdout0_197ck420 FIND v(dout0_197) AT=215.025n

.meas tran vdout0_198ck420 FIND v(dout0_198) AT=215.025n

.meas tran vdout0_199ck420 FIND v(dout0_199) AT=215.025n

.meas tran vdout0_200ck420 FIND v(dout0_200) AT=215.025n

.meas tran vdout0_201ck420 FIND v(dout0_201) AT=215.025n

.meas tran vdout0_202ck420 FIND v(dout0_202) AT=215.025n

.meas tran vdout0_203ck420 FIND v(dout0_203) AT=215.025n

.meas tran vdout0_204ck420 FIND v(dout0_204) AT=215.025n

.meas tran vdout0_205ck420 FIND v(dout0_205) AT=215.025n

.meas tran vdout0_206ck420 FIND v(dout0_206) AT=215.025n

.meas tran vdout0_207ck420 FIND v(dout0_207) AT=215.025n

.meas tran vdout0_208ck420 FIND v(dout0_208) AT=215.025n

.meas tran vdout0_209ck420 FIND v(dout0_209) AT=215.025n

.meas tran vdout0_210ck420 FIND v(dout0_210) AT=215.025n

.meas tran vdout0_211ck420 FIND v(dout0_211) AT=215.025n

.meas tran vdout0_212ck420 FIND v(dout0_212) AT=215.025n

.meas tran vdout0_213ck420 FIND v(dout0_213) AT=215.025n

.meas tran vdout0_214ck420 FIND v(dout0_214) AT=215.025n

.meas tran vdout0_215ck420 FIND v(dout0_215) AT=215.025n

.meas tran vdout0_216ck420 FIND v(dout0_216) AT=215.025n

.meas tran vdout0_217ck420 FIND v(dout0_217) AT=215.025n

.meas tran vdout0_218ck420 FIND v(dout0_218) AT=215.025n

.meas tran vdout0_219ck420 FIND v(dout0_219) AT=215.025n

.meas tran vdout0_220ck420 FIND v(dout0_220) AT=215.025n

.meas tran vdout0_221ck420 FIND v(dout0_221) AT=215.025n

.meas tran vdout0_222ck420 FIND v(dout0_222) AT=215.025n

.meas tran vdout0_223ck420 FIND v(dout0_223) AT=215.025n

.meas tran vdout0_224ck420 FIND v(dout0_224) AT=215.025n

.meas tran vdout0_225ck420 FIND v(dout0_225) AT=215.025n

.meas tran vdout0_226ck420 FIND v(dout0_226) AT=215.025n

.meas tran vdout0_227ck420 FIND v(dout0_227) AT=215.025n

.meas tran vdout0_228ck420 FIND v(dout0_228) AT=215.025n

.meas tran vdout0_229ck420 FIND v(dout0_229) AT=215.025n

.meas tran vdout0_230ck420 FIND v(dout0_230) AT=215.025n

.meas tran vdout0_231ck420 FIND v(dout0_231) AT=215.025n

.meas tran vdout0_232ck420 FIND v(dout0_232) AT=215.025n

.meas tran vdout0_233ck420 FIND v(dout0_233) AT=215.025n

.meas tran vdout0_234ck420 FIND v(dout0_234) AT=215.025n

.meas tran vdout0_235ck420 FIND v(dout0_235) AT=215.025n

.meas tran vdout0_236ck420 FIND v(dout0_236) AT=215.025n

.meas tran vdout0_237ck420 FIND v(dout0_237) AT=215.025n

.meas tran vdout0_238ck420 FIND v(dout0_238) AT=215.025n

.meas tran vdout0_239ck420 FIND v(dout0_239) AT=215.025n

.meas tran vdout0_240ck420 FIND v(dout0_240) AT=215.025n

.meas tran vdout0_241ck420 FIND v(dout0_241) AT=215.025n

.meas tran vdout0_242ck420 FIND v(dout0_242) AT=215.025n

.meas tran vdout0_243ck420 FIND v(dout0_243) AT=215.025n

.meas tran vdout0_244ck420 FIND v(dout0_244) AT=215.025n

.meas tran vdout0_245ck420 FIND v(dout0_245) AT=215.025n

.meas tran vdout0_246ck420 FIND v(dout0_246) AT=215.025n

.meas tran vdout0_247ck420 FIND v(dout0_247) AT=215.025n

.meas tran vdout0_248ck420 FIND v(dout0_248) AT=215.025n

.meas tran vdout0_249ck420 FIND v(dout0_249) AT=215.025n

.meas tran vdout0_250ck420 FIND v(dout0_250) AT=215.025n

.meas tran vdout0_251ck420 FIND v(dout0_251) AT=215.025n

.meas tran vdout0_252ck420 FIND v(dout0_252) AT=215.025n

.meas tran vdout0_253ck420 FIND v(dout0_253) AT=215.025n

.meas tran vdout0_254ck420 FIND v(dout0_254) AT=215.025n

.meas tran vdout0_255ck420 FIND v(dout0_255) AT=215.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_128ck480 FIND v(dout0_128) AT=245.025n

.meas tran vdout0_129ck480 FIND v(dout0_129) AT=245.025n

.meas tran vdout0_130ck480 FIND v(dout0_130) AT=245.025n

.meas tran vdout0_131ck480 FIND v(dout0_131) AT=245.025n

.meas tran vdout0_132ck480 FIND v(dout0_132) AT=245.025n

.meas tran vdout0_133ck480 FIND v(dout0_133) AT=245.025n

.meas tran vdout0_134ck480 FIND v(dout0_134) AT=245.025n

.meas tran vdout0_135ck480 FIND v(dout0_135) AT=245.025n

.meas tran vdout0_136ck480 FIND v(dout0_136) AT=245.025n

.meas tran vdout0_137ck480 FIND v(dout0_137) AT=245.025n

.meas tran vdout0_138ck480 FIND v(dout0_138) AT=245.025n

.meas tran vdout0_139ck480 FIND v(dout0_139) AT=245.025n

.meas tran vdout0_140ck480 FIND v(dout0_140) AT=245.025n

.meas tran vdout0_141ck480 FIND v(dout0_141) AT=245.025n

.meas tran vdout0_142ck480 FIND v(dout0_142) AT=245.025n

.meas tran vdout0_143ck480 FIND v(dout0_143) AT=245.025n

.meas tran vdout0_144ck480 FIND v(dout0_144) AT=245.025n

.meas tran vdout0_145ck480 FIND v(dout0_145) AT=245.025n

.meas tran vdout0_146ck480 FIND v(dout0_146) AT=245.025n

.meas tran vdout0_147ck480 FIND v(dout0_147) AT=245.025n

.meas tran vdout0_148ck480 FIND v(dout0_148) AT=245.025n

.meas tran vdout0_149ck480 FIND v(dout0_149) AT=245.025n

.meas tran vdout0_150ck480 FIND v(dout0_150) AT=245.025n

.meas tran vdout0_151ck480 FIND v(dout0_151) AT=245.025n

.meas tran vdout0_152ck480 FIND v(dout0_152) AT=245.025n

.meas tran vdout0_153ck480 FIND v(dout0_153) AT=245.025n

.meas tran vdout0_154ck480 FIND v(dout0_154) AT=245.025n

.meas tran vdout0_155ck480 FIND v(dout0_155) AT=245.025n

.meas tran vdout0_156ck480 FIND v(dout0_156) AT=245.025n

.meas tran vdout0_157ck480 FIND v(dout0_157) AT=245.025n

.meas tran vdout0_158ck480 FIND v(dout0_158) AT=245.025n

.meas tran vdout0_159ck480 FIND v(dout0_159) AT=245.025n

.meas tran vdout0_160ck480 FIND v(dout0_160) AT=245.025n

.meas tran vdout0_161ck480 FIND v(dout0_161) AT=245.025n

.meas tran vdout0_162ck480 FIND v(dout0_162) AT=245.025n

.meas tran vdout0_163ck480 FIND v(dout0_163) AT=245.025n

.meas tran vdout0_164ck480 FIND v(dout0_164) AT=245.025n

.meas tran vdout0_165ck480 FIND v(dout0_165) AT=245.025n

.meas tran vdout0_166ck480 FIND v(dout0_166) AT=245.025n

.meas tran vdout0_167ck480 FIND v(dout0_167) AT=245.025n

.meas tran vdout0_168ck480 FIND v(dout0_168) AT=245.025n

.meas tran vdout0_169ck480 FIND v(dout0_169) AT=245.025n

.meas tran vdout0_170ck480 FIND v(dout0_170) AT=245.025n

.meas tran vdout0_171ck480 FIND v(dout0_171) AT=245.025n

.meas tran vdout0_172ck480 FIND v(dout0_172) AT=245.025n

.meas tran vdout0_173ck480 FIND v(dout0_173) AT=245.025n

.meas tran vdout0_174ck480 FIND v(dout0_174) AT=245.025n

.meas tran vdout0_175ck480 FIND v(dout0_175) AT=245.025n

.meas tran vdout0_176ck480 FIND v(dout0_176) AT=245.025n

.meas tran vdout0_177ck480 FIND v(dout0_177) AT=245.025n

.meas tran vdout0_178ck480 FIND v(dout0_178) AT=245.025n

.meas tran vdout0_179ck480 FIND v(dout0_179) AT=245.025n

.meas tran vdout0_180ck480 FIND v(dout0_180) AT=245.025n

.meas tran vdout0_181ck480 FIND v(dout0_181) AT=245.025n

.meas tran vdout0_182ck480 FIND v(dout0_182) AT=245.025n

.meas tran vdout0_183ck480 FIND v(dout0_183) AT=245.025n

.meas tran vdout0_184ck480 FIND v(dout0_184) AT=245.025n

.meas tran vdout0_185ck480 FIND v(dout0_185) AT=245.025n

.meas tran vdout0_186ck480 FIND v(dout0_186) AT=245.025n

.meas tran vdout0_187ck480 FIND v(dout0_187) AT=245.025n

.meas tran vdout0_188ck480 FIND v(dout0_188) AT=245.025n

.meas tran vdout0_189ck480 FIND v(dout0_189) AT=245.025n

.meas tran vdout0_190ck480 FIND v(dout0_190) AT=245.025n

.meas tran vdout0_191ck480 FIND v(dout0_191) AT=245.025n

.meas tran vdout0_192ck480 FIND v(dout0_192) AT=245.025n

.meas tran vdout0_193ck480 FIND v(dout0_193) AT=245.025n

.meas tran vdout0_194ck480 FIND v(dout0_194) AT=245.025n

.meas tran vdout0_195ck480 FIND v(dout0_195) AT=245.025n

.meas tran vdout0_196ck480 FIND v(dout0_196) AT=245.025n

.meas tran vdout0_197ck480 FIND v(dout0_197) AT=245.025n

.meas tran vdout0_198ck480 FIND v(dout0_198) AT=245.025n

.meas tran vdout0_199ck480 FIND v(dout0_199) AT=245.025n

.meas tran vdout0_200ck480 FIND v(dout0_200) AT=245.025n

.meas tran vdout0_201ck480 FIND v(dout0_201) AT=245.025n

.meas tran vdout0_202ck480 FIND v(dout0_202) AT=245.025n

.meas tran vdout0_203ck480 FIND v(dout0_203) AT=245.025n

.meas tran vdout0_204ck480 FIND v(dout0_204) AT=245.025n

.meas tran vdout0_205ck480 FIND v(dout0_205) AT=245.025n

.meas tran vdout0_206ck480 FIND v(dout0_206) AT=245.025n

.meas tran vdout0_207ck480 FIND v(dout0_207) AT=245.025n

.meas tran vdout0_208ck480 FIND v(dout0_208) AT=245.025n

.meas tran vdout0_209ck480 FIND v(dout0_209) AT=245.025n

.meas tran vdout0_210ck480 FIND v(dout0_210) AT=245.025n

.meas tran vdout0_211ck480 FIND v(dout0_211) AT=245.025n

.meas tran vdout0_212ck480 FIND v(dout0_212) AT=245.025n

.meas tran vdout0_213ck480 FIND v(dout0_213) AT=245.025n

.meas tran vdout0_214ck480 FIND v(dout0_214) AT=245.025n

.meas tran vdout0_215ck480 FIND v(dout0_215) AT=245.025n

.meas tran vdout0_216ck480 FIND v(dout0_216) AT=245.025n

.meas tran vdout0_217ck480 FIND v(dout0_217) AT=245.025n

.meas tran vdout0_218ck480 FIND v(dout0_218) AT=245.025n

.meas tran vdout0_219ck480 FIND v(dout0_219) AT=245.025n

.meas tran vdout0_220ck480 FIND v(dout0_220) AT=245.025n

.meas tran vdout0_221ck480 FIND v(dout0_221) AT=245.025n

.meas tran vdout0_222ck480 FIND v(dout0_222) AT=245.025n

.meas tran vdout0_223ck480 FIND v(dout0_223) AT=245.025n

.meas tran vdout0_224ck480 FIND v(dout0_224) AT=245.025n

.meas tran vdout0_225ck480 FIND v(dout0_225) AT=245.025n

.meas tran vdout0_226ck480 FIND v(dout0_226) AT=245.025n

.meas tran vdout0_227ck480 FIND v(dout0_227) AT=245.025n

.meas tran vdout0_228ck480 FIND v(dout0_228) AT=245.025n

.meas tran vdout0_229ck480 FIND v(dout0_229) AT=245.025n

.meas tran vdout0_230ck480 FIND v(dout0_230) AT=245.025n

.meas tran vdout0_231ck480 FIND v(dout0_231) AT=245.025n

.meas tran vdout0_232ck480 FIND v(dout0_232) AT=245.025n

.meas tran vdout0_233ck480 FIND v(dout0_233) AT=245.025n

.meas tran vdout0_234ck480 FIND v(dout0_234) AT=245.025n

.meas tran vdout0_235ck480 FIND v(dout0_235) AT=245.025n

.meas tran vdout0_236ck480 FIND v(dout0_236) AT=245.025n

.meas tran vdout0_237ck480 FIND v(dout0_237) AT=245.025n

.meas tran vdout0_238ck480 FIND v(dout0_238) AT=245.025n

.meas tran vdout0_239ck480 FIND v(dout0_239) AT=245.025n

.meas tran vdout0_240ck480 FIND v(dout0_240) AT=245.025n

.meas tran vdout0_241ck480 FIND v(dout0_241) AT=245.025n

.meas tran vdout0_242ck480 FIND v(dout0_242) AT=245.025n

.meas tran vdout0_243ck480 FIND v(dout0_243) AT=245.025n

.meas tran vdout0_244ck480 FIND v(dout0_244) AT=245.025n

.meas tran vdout0_245ck480 FIND v(dout0_245) AT=245.025n

.meas tran vdout0_246ck480 FIND v(dout0_246) AT=245.025n

.meas tran vdout0_247ck480 FIND v(dout0_247) AT=245.025n

.meas tran vdout0_248ck480 FIND v(dout0_248) AT=245.025n

.meas tran vdout0_249ck480 FIND v(dout0_249) AT=245.025n

.meas tran vdout0_250ck480 FIND v(dout0_250) AT=245.025n

.meas tran vdout0_251ck480 FIND v(dout0_251) AT=245.025n

.meas tran vdout0_252ck480 FIND v(dout0_252) AT=245.025n

.meas tran vdout0_253ck480 FIND v(dout0_253) AT=245.025n

.meas tran vdout0_254ck480 FIND v(dout0_254) AT=245.025n

.meas tran vdout0_255ck480 FIND v(dout0_255) AT=245.025n

.meas tran vdout0_0ck500 FIND v(dout0_0) AT=255.025n

.meas tran vdout0_1ck500 FIND v(dout0_1) AT=255.025n

.meas tran vdout0_2ck500 FIND v(dout0_2) AT=255.025n

.meas tran vdout0_3ck500 FIND v(dout0_3) AT=255.025n

.meas tran vdout0_4ck500 FIND v(dout0_4) AT=255.025n

.meas tran vdout0_5ck500 FIND v(dout0_5) AT=255.025n

.meas tran vdout0_6ck500 FIND v(dout0_6) AT=255.025n

.meas tran vdout0_7ck500 FIND v(dout0_7) AT=255.025n

.meas tran vdout0_8ck500 FIND v(dout0_8) AT=255.025n

.meas tran vdout0_9ck500 FIND v(dout0_9) AT=255.025n

.meas tran vdout0_10ck500 FIND v(dout0_10) AT=255.025n

.meas tran vdout0_11ck500 FIND v(dout0_11) AT=255.025n

.meas tran vdout0_12ck500 FIND v(dout0_12) AT=255.025n

.meas tran vdout0_13ck500 FIND v(dout0_13) AT=255.025n

.meas tran vdout0_14ck500 FIND v(dout0_14) AT=255.025n

.meas tran vdout0_15ck500 FIND v(dout0_15) AT=255.025n

.meas tran vdout0_16ck500 FIND v(dout0_16) AT=255.025n

.meas tran vdout0_17ck500 FIND v(dout0_17) AT=255.025n

.meas tran vdout0_18ck500 FIND v(dout0_18) AT=255.025n

.meas tran vdout0_19ck500 FIND v(dout0_19) AT=255.025n

.meas tran vdout0_20ck500 FIND v(dout0_20) AT=255.025n

.meas tran vdout0_21ck500 FIND v(dout0_21) AT=255.025n

.meas tran vdout0_22ck500 FIND v(dout0_22) AT=255.025n

.meas tran vdout0_23ck500 FIND v(dout0_23) AT=255.025n

.meas tran vdout0_24ck500 FIND v(dout0_24) AT=255.025n

.meas tran vdout0_25ck500 FIND v(dout0_25) AT=255.025n

.meas tran vdout0_26ck500 FIND v(dout0_26) AT=255.025n

.meas tran vdout0_27ck500 FIND v(dout0_27) AT=255.025n

.meas tran vdout0_28ck500 FIND v(dout0_28) AT=255.025n

.meas tran vdout0_29ck500 FIND v(dout0_29) AT=255.025n

.meas tran vdout0_30ck500 FIND v(dout0_30) AT=255.025n

.meas tran vdout0_31ck500 FIND v(dout0_31) AT=255.025n

.meas tran vdout0_32ck500 FIND v(dout0_32) AT=255.025n

.meas tran vdout0_33ck500 FIND v(dout0_33) AT=255.025n

.meas tran vdout0_34ck500 FIND v(dout0_34) AT=255.025n

.meas tran vdout0_35ck500 FIND v(dout0_35) AT=255.025n

.meas tran vdout0_36ck500 FIND v(dout0_36) AT=255.025n

.meas tran vdout0_37ck500 FIND v(dout0_37) AT=255.025n

.meas tran vdout0_38ck500 FIND v(dout0_38) AT=255.025n

.meas tran vdout0_39ck500 FIND v(dout0_39) AT=255.025n

.meas tran vdout0_40ck500 FIND v(dout0_40) AT=255.025n

.meas tran vdout0_41ck500 FIND v(dout0_41) AT=255.025n

.meas tran vdout0_42ck500 FIND v(dout0_42) AT=255.025n

.meas tran vdout0_43ck500 FIND v(dout0_43) AT=255.025n

.meas tran vdout0_44ck500 FIND v(dout0_44) AT=255.025n

.meas tran vdout0_45ck500 FIND v(dout0_45) AT=255.025n

.meas tran vdout0_46ck500 FIND v(dout0_46) AT=255.025n

.meas tran vdout0_47ck500 FIND v(dout0_47) AT=255.025n

.meas tran vdout0_48ck500 FIND v(dout0_48) AT=255.025n

.meas tran vdout0_49ck500 FIND v(dout0_49) AT=255.025n

.meas tran vdout0_50ck500 FIND v(dout0_50) AT=255.025n

.meas tran vdout0_51ck500 FIND v(dout0_51) AT=255.025n

.meas tran vdout0_52ck500 FIND v(dout0_52) AT=255.025n

.meas tran vdout0_53ck500 FIND v(dout0_53) AT=255.025n

.meas tran vdout0_54ck500 FIND v(dout0_54) AT=255.025n

.meas tran vdout0_55ck500 FIND v(dout0_55) AT=255.025n

.meas tran vdout0_56ck500 FIND v(dout0_56) AT=255.025n

.meas tran vdout0_57ck500 FIND v(dout0_57) AT=255.025n

.meas tran vdout0_58ck500 FIND v(dout0_58) AT=255.025n

.meas tran vdout0_59ck500 FIND v(dout0_59) AT=255.025n

.meas tran vdout0_60ck500 FIND v(dout0_60) AT=255.025n

.meas tran vdout0_61ck500 FIND v(dout0_61) AT=255.025n

.meas tran vdout0_62ck500 FIND v(dout0_62) AT=255.025n

.meas tran vdout0_63ck500 FIND v(dout0_63) AT=255.025n

.meas tran vdout0_64ck500 FIND v(dout0_64) AT=255.025n

.meas tran vdout0_65ck500 FIND v(dout0_65) AT=255.025n

.meas tran vdout0_66ck500 FIND v(dout0_66) AT=255.025n

.meas tran vdout0_67ck500 FIND v(dout0_67) AT=255.025n

.meas tran vdout0_68ck500 FIND v(dout0_68) AT=255.025n

.meas tran vdout0_69ck500 FIND v(dout0_69) AT=255.025n

.meas tran vdout0_70ck500 FIND v(dout0_70) AT=255.025n

.meas tran vdout0_71ck500 FIND v(dout0_71) AT=255.025n

.meas tran vdout0_72ck500 FIND v(dout0_72) AT=255.025n

.meas tran vdout0_73ck500 FIND v(dout0_73) AT=255.025n

.meas tran vdout0_74ck500 FIND v(dout0_74) AT=255.025n

.meas tran vdout0_75ck500 FIND v(dout0_75) AT=255.025n

.meas tran vdout0_76ck500 FIND v(dout0_76) AT=255.025n

.meas tran vdout0_77ck500 FIND v(dout0_77) AT=255.025n

.meas tran vdout0_78ck500 FIND v(dout0_78) AT=255.025n

.meas tran vdout0_79ck500 FIND v(dout0_79) AT=255.025n

.meas tran vdout0_80ck500 FIND v(dout0_80) AT=255.025n

.meas tran vdout0_81ck500 FIND v(dout0_81) AT=255.025n

.meas tran vdout0_82ck500 FIND v(dout0_82) AT=255.025n

.meas tran vdout0_83ck500 FIND v(dout0_83) AT=255.025n

.meas tran vdout0_84ck500 FIND v(dout0_84) AT=255.025n

.meas tran vdout0_85ck500 FIND v(dout0_85) AT=255.025n

.meas tran vdout0_86ck500 FIND v(dout0_86) AT=255.025n

.meas tran vdout0_87ck500 FIND v(dout0_87) AT=255.025n

.meas tran vdout0_88ck500 FIND v(dout0_88) AT=255.025n

.meas tran vdout0_89ck500 FIND v(dout0_89) AT=255.025n

.meas tran vdout0_90ck500 FIND v(dout0_90) AT=255.025n

.meas tran vdout0_91ck500 FIND v(dout0_91) AT=255.025n

.meas tran vdout0_92ck500 FIND v(dout0_92) AT=255.025n

.meas tran vdout0_93ck500 FIND v(dout0_93) AT=255.025n

.meas tran vdout0_94ck500 FIND v(dout0_94) AT=255.025n

.meas tran vdout0_95ck500 FIND v(dout0_95) AT=255.025n

.meas tran vdout0_96ck500 FIND v(dout0_96) AT=255.025n

.meas tran vdout0_97ck500 FIND v(dout0_97) AT=255.025n

.meas tran vdout0_98ck500 FIND v(dout0_98) AT=255.025n

.meas tran vdout0_99ck500 FIND v(dout0_99) AT=255.025n

.meas tran vdout0_100ck500 FIND v(dout0_100) AT=255.025n

.meas tran vdout0_101ck500 FIND v(dout0_101) AT=255.025n

.meas tran vdout0_102ck500 FIND v(dout0_102) AT=255.025n

.meas tran vdout0_103ck500 FIND v(dout0_103) AT=255.025n

.meas tran vdout0_104ck500 FIND v(dout0_104) AT=255.025n

.meas tran vdout0_105ck500 FIND v(dout0_105) AT=255.025n

.meas tran vdout0_106ck500 FIND v(dout0_106) AT=255.025n

.meas tran vdout0_107ck500 FIND v(dout0_107) AT=255.025n

.meas tran vdout0_108ck500 FIND v(dout0_108) AT=255.025n

.meas tran vdout0_109ck500 FIND v(dout0_109) AT=255.025n

.meas tran vdout0_110ck500 FIND v(dout0_110) AT=255.025n

.meas tran vdout0_111ck500 FIND v(dout0_111) AT=255.025n

.meas tran vdout0_112ck500 FIND v(dout0_112) AT=255.025n

.meas tran vdout0_113ck500 FIND v(dout0_113) AT=255.025n

.meas tran vdout0_114ck500 FIND v(dout0_114) AT=255.025n

.meas tran vdout0_115ck500 FIND v(dout0_115) AT=255.025n

.meas tran vdout0_116ck500 FIND v(dout0_116) AT=255.025n

.meas tran vdout0_117ck500 FIND v(dout0_117) AT=255.025n

.meas tran vdout0_118ck500 FIND v(dout0_118) AT=255.025n

.meas tran vdout0_119ck500 FIND v(dout0_119) AT=255.025n

.meas tran vdout0_120ck500 FIND v(dout0_120) AT=255.025n

.meas tran vdout0_121ck500 FIND v(dout0_121) AT=255.025n

.meas tran vdout0_122ck500 FIND v(dout0_122) AT=255.025n

.meas tran vdout0_123ck500 FIND v(dout0_123) AT=255.025n

.meas tran vdout0_124ck500 FIND v(dout0_124) AT=255.025n

.meas tran vdout0_125ck500 FIND v(dout0_125) AT=255.025n

.meas tran vdout0_126ck500 FIND v(dout0_126) AT=255.025n

.meas tran vdout0_127ck500 FIND v(dout0_127) AT=255.025n

.meas tran vdout0_128ck500 FIND v(dout0_128) AT=255.025n

.meas tran vdout0_129ck500 FIND v(dout0_129) AT=255.025n

.meas tran vdout0_130ck500 FIND v(dout0_130) AT=255.025n

.meas tran vdout0_131ck500 FIND v(dout0_131) AT=255.025n

.meas tran vdout0_132ck500 FIND v(dout0_132) AT=255.025n

.meas tran vdout0_133ck500 FIND v(dout0_133) AT=255.025n

.meas tran vdout0_134ck500 FIND v(dout0_134) AT=255.025n

.meas tran vdout0_135ck500 FIND v(dout0_135) AT=255.025n

.meas tran vdout0_136ck500 FIND v(dout0_136) AT=255.025n

.meas tran vdout0_137ck500 FIND v(dout0_137) AT=255.025n

.meas tran vdout0_138ck500 FIND v(dout0_138) AT=255.025n

.meas tran vdout0_139ck500 FIND v(dout0_139) AT=255.025n

.meas tran vdout0_140ck500 FIND v(dout0_140) AT=255.025n

.meas tran vdout0_141ck500 FIND v(dout0_141) AT=255.025n

.meas tran vdout0_142ck500 FIND v(dout0_142) AT=255.025n

.meas tran vdout0_143ck500 FIND v(dout0_143) AT=255.025n

.meas tran vdout0_144ck500 FIND v(dout0_144) AT=255.025n

.meas tran vdout0_145ck500 FIND v(dout0_145) AT=255.025n

.meas tran vdout0_146ck500 FIND v(dout0_146) AT=255.025n

.meas tran vdout0_147ck500 FIND v(dout0_147) AT=255.025n

.meas tran vdout0_148ck500 FIND v(dout0_148) AT=255.025n

.meas tran vdout0_149ck500 FIND v(dout0_149) AT=255.025n

.meas tran vdout0_150ck500 FIND v(dout0_150) AT=255.025n

.meas tran vdout0_151ck500 FIND v(dout0_151) AT=255.025n

.meas tran vdout0_152ck500 FIND v(dout0_152) AT=255.025n

.meas tran vdout0_153ck500 FIND v(dout0_153) AT=255.025n

.meas tran vdout0_154ck500 FIND v(dout0_154) AT=255.025n

.meas tran vdout0_155ck500 FIND v(dout0_155) AT=255.025n

.meas tran vdout0_156ck500 FIND v(dout0_156) AT=255.025n

.meas tran vdout0_157ck500 FIND v(dout0_157) AT=255.025n

.meas tran vdout0_158ck500 FIND v(dout0_158) AT=255.025n

.meas tran vdout0_159ck500 FIND v(dout0_159) AT=255.025n

.meas tran vdout0_160ck500 FIND v(dout0_160) AT=255.025n

.meas tran vdout0_161ck500 FIND v(dout0_161) AT=255.025n

.meas tran vdout0_162ck500 FIND v(dout0_162) AT=255.025n

.meas tran vdout0_163ck500 FIND v(dout0_163) AT=255.025n

.meas tran vdout0_164ck500 FIND v(dout0_164) AT=255.025n

.meas tran vdout0_165ck500 FIND v(dout0_165) AT=255.025n

.meas tran vdout0_166ck500 FIND v(dout0_166) AT=255.025n

.meas tran vdout0_167ck500 FIND v(dout0_167) AT=255.025n

.meas tran vdout0_168ck500 FIND v(dout0_168) AT=255.025n

.meas tran vdout0_169ck500 FIND v(dout0_169) AT=255.025n

.meas tran vdout0_170ck500 FIND v(dout0_170) AT=255.025n

.meas tran vdout0_171ck500 FIND v(dout0_171) AT=255.025n

.meas tran vdout0_172ck500 FIND v(dout0_172) AT=255.025n

.meas tran vdout0_173ck500 FIND v(dout0_173) AT=255.025n

.meas tran vdout0_174ck500 FIND v(dout0_174) AT=255.025n

.meas tran vdout0_175ck500 FIND v(dout0_175) AT=255.025n

.meas tran vdout0_176ck500 FIND v(dout0_176) AT=255.025n

.meas tran vdout0_177ck500 FIND v(dout0_177) AT=255.025n

.meas tran vdout0_178ck500 FIND v(dout0_178) AT=255.025n

.meas tran vdout0_179ck500 FIND v(dout0_179) AT=255.025n

.meas tran vdout0_180ck500 FIND v(dout0_180) AT=255.025n

.meas tran vdout0_181ck500 FIND v(dout0_181) AT=255.025n

.meas tran vdout0_182ck500 FIND v(dout0_182) AT=255.025n

.meas tran vdout0_183ck500 FIND v(dout0_183) AT=255.025n

.meas tran vdout0_184ck500 FIND v(dout0_184) AT=255.025n

.meas tran vdout0_185ck500 FIND v(dout0_185) AT=255.025n

.meas tran vdout0_186ck500 FIND v(dout0_186) AT=255.025n

.meas tran vdout0_187ck500 FIND v(dout0_187) AT=255.025n

.meas tran vdout0_188ck500 FIND v(dout0_188) AT=255.025n

.meas tran vdout0_189ck500 FIND v(dout0_189) AT=255.025n

.meas tran vdout0_190ck500 FIND v(dout0_190) AT=255.025n

.meas tran vdout0_191ck500 FIND v(dout0_191) AT=255.025n

.meas tran vdout0_192ck500 FIND v(dout0_192) AT=255.025n

.meas tran vdout0_193ck500 FIND v(dout0_193) AT=255.025n

.meas tran vdout0_194ck500 FIND v(dout0_194) AT=255.025n

.meas tran vdout0_195ck500 FIND v(dout0_195) AT=255.025n

.meas tran vdout0_196ck500 FIND v(dout0_196) AT=255.025n

.meas tran vdout0_197ck500 FIND v(dout0_197) AT=255.025n

.meas tran vdout0_198ck500 FIND v(dout0_198) AT=255.025n

.meas tran vdout0_199ck500 FIND v(dout0_199) AT=255.025n

.meas tran vdout0_200ck500 FIND v(dout0_200) AT=255.025n

.meas tran vdout0_201ck500 FIND v(dout0_201) AT=255.025n

.meas tran vdout0_202ck500 FIND v(dout0_202) AT=255.025n

.meas tran vdout0_203ck500 FIND v(dout0_203) AT=255.025n

.meas tran vdout0_204ck500 FIND v(dout0_204) AT=255.025n

.meas tran vdout0_205ck500 FIND v(dout0_205) AT=255.025n

.meas tran vdout0_206ck500 FIND v(dout0_206) AT=255.025n

.meas tran vdout0_207ck500 FIND v(dout0_207) AT=255.025n

.meas tran vdout0_208ck500 FIND v(dout0_208) AT=255.025n

.meas tran vdout0_209ck500 FIND v(dout0_209) AT=255.025n

.meas tran vdout0_210ck500 FIND v(dout0_210) AT=255.025n

.meas tran vdout0_211ck500 FIND v(dout0_211) AT=255.025n

.meas tran vdout0_212ck500 FIND v(dout0_212) AT=255.025n

.meas tran vdout0_213ck500 FIND v(dout0_213) AT=255.025n

.meas tran vdout0_214ck500 FIND v(dout0_214) AT=255.025n

.meas tran vdout0_215ck500 FIND v(dout0_215) AT=255.025n

.meas tran vdout0_216ck500 FIND v(dout0_216) AT=255.025n

.meas tran vdout0_217ck500 FIND v(dout0_217) AT=255.025n

.meas tran vdout0_218ck500 FIND v(dout0_218) AT=255.025n

.meas tran vdout0_219ck500 FIND v(dout0_219) AT=255.025n

.meas tran vdout0_220ck500 FIND v(dout0_220) AT=255.025n

.meas tran vdout0_221ck500 FIND v(dout0_221) AT=255.025n

.meas tran vdout0_222ck500 FIND v(dout0_222) AT=255.025n

.meas tran vdout0_223ck500 FIND v(dout0_223) AT=255.025n

.meas tran vdout0_224ck500 FIND v(dout0_224) AT=255.025n

.meas tran vdout0_225ck500 FIND v(dout0_225) AT=255.025n

.meas tran vdout0_226ck500 FIND v(dout0_226) AT=255.025n

.meas tran vdout0_227ck500 FIND v(dout0_227) AT=255.025n

.meas tran vdout0_228ck500 FIND v(dout0_228) AT=255.025n

.meas tran vdout0_229ck500 FIND v(dout0_229) AT=255.025n

.meas tran vdout0_230ck500 FIND v(dout0_230) AT=255.025n

.meas tran vdout0_231ck500 FIND v(dout0_231) AT=255.025n

.meas tran vdout0_232ck500 FIND v(dout0_232) AT=255.025n

.meas tran vdout0_233ck500 FIND v(dout0_233) AT=255.025n

.meas tran vdout0_234ck500 FIND v(dout0_234) AT=255.025n

.meas tran vdout0_235ck500 FIND v(dout0_235) AT=255.025n

.meas tran vdout0_236ck500 FIND v(dout0_236) AT=255.025n

.meas tran vdout0_237ck500 FIND v(dout0_237) AT=255.025n

.meas tran vdout0_238ck500 FIND v(dout0_238) AT=255.025n

.meas tran vdout0_239ck500 FIND v(dout0_239) AT=255.025n

.meas tran vdout0_240ck500 FIND v(dout0_240) AT=255.025n

.meas tran vdout0_241ck500 FIND v(dout0_241) AT=255.025n

.meas tran vdout0_242ck500 FIND v(dout0_242) AT=255.025n

.meas tran vdout0_243ck500 FIND v(dout0_243) AT=255.025n

.meas tran vdout0_244ck500 FIND v(dout0_244) AT=255.025n

.meas tran vdout0_245ck500 FIND v(dout0_245) AT=255.025n

.meas tran vdout0_246ck500 FIND v(dout0_246) AT=255.025n

.meas tran vdout0_247ck500 FIND v(dout0_247) AT=255.025n

.meas tran vdout0_248ck500 FIND v(dout0_248) AT=255.025n

.meas tran vdout0_249ck500 FIND v(dout0_249) AT=255.025n

.meas tran vdout0_250ck500 FIND v(dout0_250) AT=255.025n

.meas tran vdout0_251ck500 FIND v(dout0_251) AT=255.025n

.meas tran vdout0_252ck500 FIND v(dout0_252) AT=255.025n

.meas tran vdout0_253ck500 FIND v(dout0_253) AT=255.025n

.meas tran vdout0_254ck500 FIND v(dout0_254) AT=255.025n

.meas tran vdout0_255ck500 FIND v(dout0_255) AT=255.025n

.meas tran vdout0_0ck520 FIND v(dout0_0) AT=265.025n

.meas tran vdout0_1ck520 FIND v(dout0_1) AT=265.025n

.meas tran vdout0_2ck520 FIND v(dout0_2) AT=265.025n

.meas tran vdout0_3ck520 FIND v(dout0_3) AT=265.025n

.meas tran vdout0_4ck520 FIND v(dout0_4) AT=265.025n

.meas tran vdout0_5ck520 FIND v(dout0_5) AT=265.025n

.meas tran vdout0_6ck520 FIND v(dout0_6) AT=265.025n

.meas tran vdout0_7ck520 FIND v(dout0_7) AT=265.025n

.meas tran vdout0_8ck520 FIND v(dout0_8) AT=265.025n

.meas tran vdout0_9ck520 FIND v(dout0_9) AT=265.025n

.meas tran vdout0_10ck520 FIND v(dout0_10) AT=265.025n

.meas tran vdout0_11ck520 FIND v(dout0_11) AT=265.025n

.meas tran vdout0_12ck520 FIND v(dout0_12) AT=265.025n

.meas tran vdout0_13ck520 FIND v(dout0_13) AT=265.025n

.meas tran vdout0_14ck520 FIND v(dout0_14) AT=265.025n

.meas tran vdout0_15ck520 FIND v(dout0_15) AT=265.025n

.meas tran vdout0_16ck520 FIND v(dout0_16) AT=265.025n

.meas tran vdout0_17ck520 FIND v(dout0_17) AT=265.025n

.meas tran vdout0_18ck520 FIND v(dout0_18) AT=265.025n

.meas tran vdout0_19ck520 FIND v(dout0_19) AT=265.025n

.meas tran vdout0_20ck520 FIND v(dout0_20) AT=265.025n

.meas tran vdout0_21ck520 FIND v(dout0_21) AT=265.025n

.meas tran vdout0_22ck520 FIND v(dout0_22) AT=265.025n

.meas tran vdout0_23ck520 FIND v(dout0_23) AT=265.025n

.meas tran vdout0_24ck520 FIND v(dout0_24) AT=265.025n

.meas tran vdout0_25ck520 FIND v(dout0_25) AT=265.025n

.meas tran vdout0_26ck520 FIND v(dout0_26) AT=265.025n

.meas tran vdout0_27ck520 FIND v(dout0_27) AT=265.025n

.meas tran vdout0_28ck520 FIND v(dout0_28) AT=265.025n

.meas tran vdout0_29ck520 FIND v(dout0_29) AT=265.025n

.meas tran vdout0_30ck520 FIND v(dout0_30) AT=265.025n

.meas tran vdout0_31ck520 FIND v(dout0_31) AT=265.025n

.meas tran vdout0_32ck520 FIND v(dout0_32) AT=265.025n

.meas tran vdout0_33ck520 FIND v(dout0_33) AT=265.025n

.meas tran vdout0_34ck520 FIND v(dout0_34) AT=265.025n

.meas tran vdout0_35ck520 FIND v(dout0_35) AT=265.025n

.meas tran vdout0_36ck520 FIND v(dout0_36) AT=265.025n

.meas tran vdout0_37ck520 FIND v(dout0_37) AT=265.025n

.meas tran vdout0_38ck520 FIND v(dout0_38) AT=265.025n

.meas tran vdout0_39ck520 FIND v(dout0_39) AT=265.025n

.meas tran vdout0_40ck520 FIND v(dout0_40) AT=265.025n

.meas tran vdout0_41ck520 FIND v(dout0_41) AT=265.025n

.meas tran vdout0_42ck520 FIND v(dout0_42) AT=265.025n

.meas tran vdout0_43ck520 FIND v(dout0_43) AT=265.025n

.meas tran vdout0_44ck520 FIND v(dout0_44) AT=265.025n

.meas tran vdout0_45ck520 FIND v(dout0_45) AT=265.025n

.meas tran vdout0_46ck520 FIND v(dout0_46) AT=265.025n

.meas tran vdout0_47ck520 FIND v(dout0_47) AT=265.025n

.meas tran vdout0_48ck520 FIND v(dout0_48) AT=265.025n

.meas tran vdout0_49ck520 FIND v(dout0_49) AT=265.025n

.meas tran vdout0_50ck520 FIND v(dout0_50) AT=265.025n

.meas tran vdout0_51ck520 FIND v(dout0_51) AT=265.025n

.meas tran vdout0_52ck520 FIND v(dout0_52) AT=265.025n

.meas tran vdout0_53ck520 FIND v(dout0_53) AT=265.025n

.meas tran vdout0_54ck520 FIND v(dout0_54) AT=265.025n

.meas tran vdout0_55ck520 FIND v(dout0_55) AT=265.025n

.meas tran vdout0_56ck520 FIND v(dout0_56) AT=265.025n

.meas tran vdout0_57ck520 FIND v(dout0_57) AT=265.025n

.meas tran vdout0_58ck520 FIND v(dout0_58) AT=265.025n

.meas tran vdout0_59ck520 FIND v(dout0_59) AT=265.025n

.meas tran vdout0_60ck520 FIND v(dout0_60) AT=265.025n

.meas tran vdout0_61ck520 FIND v(dout0_61) AT=265.025n

.meas tran vdout0_62ck520 FIND v(dout0_62) AT=265.025n

.meas tran vdout0_63ck520 FIND v(dout0_63) AT=265.025n

.meas tran vdout0_64ck520 FIND v(dout0_64) AT=265.025n

.meas tran vdout0_65ck520 FIND v(dout0_65) AT=265.025n

.meas tran vdout0_66ck520 FIND v(dout0_66) AT=265.025n

.meas tran vdout0_67ck520 FIND v(dout0_67) AT=265.025n

.meas tran vdout0_68ck520 FIND v(dout0_68) AT=265.025n

.meas tran vdout0_69ck520 FIND v(dout0_69) AT=265.025n

.meas tran vdout0_70ck520 FIND v(dout0_70) AT=265.025n

.meas tran vdout0_71ck520 FIND v(dout0_71) AT=265.025n

.meas tran vdout0_72ck520 FIND v(dout0_72) AT=265.025n

.meas tran vdout0_73ck520 FIND v(dout0_73) AT=265.025n

.meas tran vdout0_74ck520 FIND v(dout0_74) AT=265.025n

.meas tran vdout0_75ck520 FIND v(dout0_75) AT=265.025n

.meas tran vdout0_76ck520 FIND v(dout0_76) AT=265.025n

.meas tran vdout0_77ck520 FIND v(dout0_77) AT=265.025n

.meas tran vdout0_78ck520 FIND v(dout0_78) AT=265.025n

.meas tran vdout0_79ck520 FIND v(dout0_79) AT=265.025n

.meas tran vdout0_80ck520 FIND v(dout0_80) AT=265.025n

.meas tran vdout0_81ck520 FIND v(dout0_81) AT=265.025n

.meas tran vdout0_82ck520 FIND v(dout0_82) AT=265.025n

.meas tran vdout0_83ck520 FIND v(dout0_83) AT=265.025n

.meas tran vdout0_84ck520 FIND v(dout0_84) AT=265.025n

.meas tran vdout0_85ck520 FIND v(dout0_85) AT=265.025n

.meas tran vdout0_86ck520 FIND v(dout0_86) AT=265.025n

.meas tran vdout0_87ck520 FIND v(dout0_87) AT=265.025n

.meas tran vdout0_88ck520 FIND v(dout0_88) AT=265.025n

.meas tran vdout0_89ck520 FIND v(dout0_89) AT=265.025n

.meas tran vdout0_90ck520 FIND v(dout0_90) AT=265.025n

.meas tran vdout0_91ck520 FIND v(dout0_91) AT=265.025n

.meas tran vdout0_92ck520 FIND v(dout0_92) AT=265.025n

.meas tran vdout0_93ck520 FIND v(dout0_93) AT=265.025n

.meas tran vdout0_94ck520 FIND v(dout0_94) AT=265.025n

.meas tran vdout0_95ck520 FIND v(dout0_95) AT=265.025n

.meas tran vdout0_96ck520 FIND v(dout0_96) AT=265.025n

.meas tran vdout0_97ck520 FIND v(dout0_97) AT=265.025n

.meas tran vdout0_98ck520 FIND v(dout0_98) AT=265.025n

.meas tran vdout0_99ck520 FIND v(dout0_99) AT=265.025n

.meas tran vdout0_100ck520 FIND v(dout0_100) AT=265.025n

.meas tran vdout0_101ck520 FIND v(dout0_101) AT=265.025n

.meas tran vdout0_102ck520 FIND v(dout0_102) AT=265.025n

.meas tran vdout0_103ck520 FIND v(dout0_103) AT=265.025n

.meas tran vdout0_104ck520 FIND v(dout0_104) AT=265.025n

.meas tran vdout0_105ck520 FIND v(dout0_105) AT=265.025n

.meas tran vdout0_106ck520 FIND v(dout0_106) AT=265.025n

.meas tran vdout0_107ck520 FIND v(dout0_107) AT=265.025n

.meas tran vdout0_108ck520 FIND v(dout0_108) AT=265.025n

.meas tran vdout0_109ck520 FIND v(dout0_109) AT=265.025n

.meas tran vdout0_110ck520 FIND v(dout0_110) AT=265.025n

.meas tran vdout0_111ck520 FIND v(dout0_111) AT=265.025n

.meas tran vdout0_112ck520 FIND v(dout0_112) AT=265.025n

.meas tran vdout0_113ck520 FIND v(dout0_113) AT=265.025n

.meas tran vdout0_114ck520 FIND v(dout0_114) AT=265.025n

.meas tran vdout0_115ck520 FIND v(dout0_115) AT=265.025n

.meas tran vdout0_116ck520 FIND v(dout0_116) AT=265.025n

.meas tran vdout0_117ck520 FIND v(dout0_117) AT=265.025n

.meas tran vdout0_118ck520 FIND v(dout0_118) AT=265.025n

.meas tran vdout0_119ck520 FIND v(dout0_119) AT=265.025n

.meas tran vdout0_120ck520 FIND v(dout0_120) AT=265.025n

.meas tran vdout0_121ck520 FIND v(dout0_121) AT=265.025n

.meas tran vdout0_122ck520 FIND v(dout0_122) AT=265.025n

.meas tran vdout0_123ck520 FIND v(dout0_123) AT=265.025n

.meas tran vdout0_124ck520 FIND v(dout0_124) AT=265.025n

.meas tran vdout0_125ck520 FIND v(dout0_125) AT=265.025n

.meas tran vdout0_126ck520 FIND v(dout0_126) AT=265.025n

.meas tran vdout0_127ck520 FIND v(dout0_127) AT=265.025n

.meas tran vdout0_128ck520 FIND v(dout0_128) AT=265.025n

.meas tran vdout0_129ck520 FIND v(dout0_129) AT=265.025n

.meas tran vdout0_130ck520 FIND v(dout0_130) AT=265.025n

.meas tran vdout0_131ck520 FIND v(dout0_131) AT=265.025n

.meas tran vdout0_132ck520 FIND v(dout0_132) AT=265.025n

.meas tran vdout0_133ck520 FIND v(dout0_133) AT=265.025n

.meas tran vdout0_134ck520 FIND v(dout0_134) AT=265.025n

.meas tran vdout0_135ck520 FIND v(dout0_135) AT=265.025n

.meas tran vdout0_136ck520 FIND v(dout0_136) AT=265.025n

.meas tran vdout0_137ck520 FIND v(dout0_137) AT=265.025n

.meas tran vdout0_138ck520 FIND v(dout0_138) AT=265.025n

.meas tran vdout0_139ck520 FIND v(dout0_139) AT=265.025n

.meas tran vdout0_140ck520 FIND v(dout0_140) AT=265.025n

.meas tran vdout0_141ck520 FIND v(dout0_141) AT=265.025n

.meas tran vdout0_142ck520 FIND v(dout0_142) AT=265.025n

.meas tran vdout0_143ck520 FIND v(dout0_143) AT=265.025n

.meas tran vdout0_144ck520 FIND v(dout0_144) AT=265.025n

.meas tran vdout0_145ck520 FIND v(dout0_145) AT=265.025n

.meas tran vdout0_146ck520 FIND v(dout0_146) AT=265.025n

.meas tran vdout0_147ck520 FIND v(dout0_147) AT=265.025n

.meas tran vdout0_148ck520 FIND v(dout0_148) AT=265.025n

.meas tran vdout0_149ck520 FIND v(dout0_149) AT=265.025n

.meas tran vdout0_150ck520 FIND v(dout0_150) AT=265.025n

.meas tran vdout0_151ck520 FIND v(dout0_151) AT=265.025n

.meas tran vdout0_152ck520 FIND v(dout0_152) AT=265.025n

.meas tran vdout0_153ck520 FIND v(dout0_153) AT=265.025n

.meas tran vdout0_154ck520 FIND v(dout0_154) AT=265.025n

.meas tran vdout0_155ck520 FIND v(dout0_155) AT=265.025n

.meas tran vdout0_156ck520 FIND v(dout0_156) AT=265.025n

.meas tran vdout0_157ck520 FIND v(dout0_157) AT=265.025n

.meas tran vdout0_158ck520 FIND v(dout0_158) AT=265.025n

.meas tran vdout0_159ck520 FIND v(dout0_159) AT=265.025n

.meas tran vdout0_160ck520 FIND v(dout0_160) AT=265.025n

.meas tran vdout0_161ck520 FIND v(dout0_161) AT=265.025n

.meas tran vdout0_162ck520 FIND v(dout0_162) AT=265.025n

.meas tran vdout0_163ck520 FIND v(dout0_163) AT=265.025n

.meas tran vdout0_164ck520 FIND v(dout0_164) AT=265.025n

.meas tran vdout0_165ck520 FIND v(dout0_165) AT=265.025n

.meas tran vdout0_166ck520 FIND v(dout0_166) AT=265.025n

.meas tran vdout0_167ck520 FIND v(dout0_167) AT=265.025n

.meas tran vdout0_168ck520 FIND v(dout0_168) AT=265.025n

.meas tran vdout0_169ck520 FIND v(dout0_169) AT=265.025n

.meas tran vdout0_170ck520 FIND v(dout0_170) AT=265.025n

.meas tran vdout0_171ck520 FIND v(dout0_171) AT=265.025n

.meas tran vdout0_172ck520 FIND v(dout0_172) AT=265.025n

.meas tran vdout0_173ck520 FIND v(dout0_173) AT=265.025n

.meas tran vdout0_174ck520 FIND v(dout0_174) AT=265.025n

.meas tran vdout0_175ck520 FIND v(dout0_175) AT=265.025n

.meas tran vdout0_176ck520 FIND v(dout0_176) AT=265.025n

.meas tran vdout0_177ck520 FIND v(dout0_177) AT=265.025n

.meas tran vdout0_178ck520 FIND v(dout0_178) AT=265.025n

.meas tran vdout0_179ck520 FIND v(dout0_179) AT=265.025n

.meas tran vdout0_180ck520 FIND v(dout0_180) AT=265.025n

.meas tran vdout0_181ck520 FIND v(dout0_181) AT=265.025n

.meas tran vdout0_182ck520 FIND v(dout0_182) AT=265.025n

.meas tran vdout0_183ck520 FIND v(dout0_183) AT=265.025n

.meas tran vdout0_184ck520 FIND v(dout0_184) AT=265.025n

.meas tran vdout0_185ck520 FIND v(dout0_185) AT=265.025n

.meas tran vdout0_186ck520 FIND v(dout0_186) AT=265.025n

.meas tran vdout0_187ck520 FIND v(dout0_187) AT=265.025n

.meas tran vdout0_188ck520 FIND v(dout0_188) AT=265.025n

.meas tran vdout0_189ck520 FIND v(dout0_189) AT=265.025n

.meas tran vdout0_190ck520 FIND v(dout0_190) AT=265.025n

.meas tran vdout0_191ck520 FIND v(dout0_191) AT=265.025n

.meas tran vdout0_192ck520 FIND v(dout0_192) AT=265.025n

.meas tran vdout0_193ck520 FIND v(dout0_193) AT=265.025n

.meas tran vdout0_194ck520 FIND v(dout0_194) AT=265.025n

.meas tran vdout0_195ck520 FIND v(dout0_195) AT=265.025n

.meas tran vdout0_196ck520 FIND v(dout0_196) AT=265.025n

.meas tran vdout0_197ck520 FIND v(dout0_197) AT=265.025n

.meas tran vdout0_198ck520 FIND v(dout0_198) AT=265.025n

.meas tran vdout0_199ck520 FIND v(dout0_199) AT=265.025n

.meas tran vdout0_200ck520 FIND v(dout0_200) AT=265.025n

.meas tran vdout0_201ck520 FIND v(dout0_201) AT=265.025n

.meas tran vdout0_202ck520 FIND v(dout0_202) AT=265.025n

.meas tran vdout0_203ck520 FIND v(dout0_203) AT=265.025n

.meas tran vdout0_204ck520 FIND v(dout0_204) AT=265.025n

.meas tran vdout0_205ck520 FIND v(dout0_205) AT=265.025n

.meas tran vdout0_206ck520 FIND v(dout0_206) AT=265.025n

.meas tran vdout0_207ck520 FIND v(dout0_207) AT=265.025n

.meas tran vdout0_208ck520 FIND v(dout0_208) AT=265.025n

.meas tran vdout0_209ck520 FIND v(dout0_209) AT=265.025n

.meas tran vdout0_210ck520 FIND v(dout0_210) AT=265.025n

.meas tran vdout0_211ck520 FIND v(dout0_211) AT=265.025n

.meas tran vdout0_212ck520 FIND v(dout0_212) AT=265.025n

.meas tran vdout0_213ck520 FIND v(dout0_213) AT=265.025n

.meas tran vdout0_214ck520 FIND v(dout0_214) AT=265.025n

.meas tran vdout0_215ck520 FIND v(dout0_215) AT=265.025n

.meas tran vdout0_216ck520 FIND v(dout0_216) AT=265.025n

.meas tran vdout0_217ck520 FIND v(dout0_217) AT=265.025n

.meas tran vdout0_218ck520 FIND v(dout0_218) AT=265.025n

.meas tran vdout0_219ck520 FIND v(dout0_219) AT=265.025n

.meas tran vdout0_220ck520 FIND v(dout0_220) AT=265.025n

.meas tran vdout0_221ck520 FIND v(dout0_221) AT=265.025n

.meas tran vdout0_222ck520 FIND v(dout0_222) AT=265.025n

.meas tran vdout0_223ck520 FIND v(dout0_223) AT=265.025n

.meas tran vdout0_224ck520 FIND v(dout0_224) AT=265.025n

.meas tran vdout0_225ck520 FIND v(dout0_225) AT=265.025n

.meas tran vdout0_226ck520 FIND v(dout0_226) AT=265.025n

.meas tran vdout0_227ck520 FIND v(dout0_227) AT=265.025n

.meas tran vdout0_228ck520 FIND v(dout0_228) AT=265.025n

.meas tran vdout0_229ck520 FIND v(dout0_229) AT=265.025n

.meas tran vdout0_230ck520 FIND v(dout0_230) AT=265.025n

.meas tran vdout0_231ck520 FIND v(dout0_231) AT=265.025n

.meas tran vdout0_232ck520 FIND v(dout0_232) AT=265.025n

.meas tran vdout0_233ck520 FIND v(dout0_233) AT=265.025n

.meas tran vdout0_234ck520 FIND v(dout0_234) AT=265.025n

.meas tran vdout0_235ck520 FIND v(dout0_235) AT=265.025n

.meas tran vdout0_236ck520 FIND v(dout0_236) AT=265.025n

.meas tran vdout0_237ck520 FIND v(dout0_237) AT=265.025n

.meas tran vdout0_238ck520 FIND v(dout0_238) AT=265.025n

.meas tran vdout0_239ck520 FIND v(dout0_239) AT=265.025n

.meas tran vdout0_240ck520 FIND v(dout0_240) AT=265.025n

.meas tran vdout0_241ck520 FIND v(dout0_241) AT=265.025n

.meas tran vdout0_242ck520 FIND v(dout0_242) AT=265.025n

.meas tran vdout0_243ck520 FIND v(dout0_243) AT=265.025n

.meas tran vdout0_244ck520 FIND v(dout0_244) AT=265.025n

.meas tran vdout0_245ck520 FIND v(dout0_245) AT=265.025n

.meas tran vdout0_246ck520 FIND v(dout0_246) AT=265.025n

.meas tran vdout0_247ck520 FIND v(dout0_247) AT=265.025n

.meas tran vdout0_248ck520 FIND v(dout0_248) AT=265.025n

.meas tran vdout0_249ck520 FIND v(dout0_249) AT=265.025n

.meas tran vdout0_250ck520 FIND v(dout0_250) AT=265.025n

.meas tran vdout0_251ck520 FIND v(dout0_251) AT=265.025n

.meas tran vdout0_252ck520 FIND v(dout0_252) AT=265.025n

.meas tran vdout0_253ck520 FIND v(dout0_253) AT=265.025n

.meas tran vdout0_254ck520 FIND v(dout0_254) AT=265.025n

.meas tran vdout0_255ck520 FIND v(dout0_255) AT=265.025n

.meas tran vdout0_0ck540 FIND v(dout0_0) AT=275.025n

.meas tran vdout0_1ck540 FIND v(dout0_1) AT=275.025n

.meas tran vdout0_2ck540 FIND v(dout0_2) AT=275.025n

.meas tran vdout0_3ck540 FIND v(dout0_3) AT=275.025n

.meas tran vdout0_4ck540 FIND v(dout0_4) AT=275.025n

.meas tran vdout0_5ck540 FIND v(dout0_5) AT=275.025n

.meas tran vdout0_6ck540 FIND v(dout0_6) AT=275.025n

.meas tran vdout0_7ck540 FIND v(dout0_7) AT=275.025n

.meas tran vdout0_8ck540 FIND v(dout0_8) AT=275.025n

.meas tran vdout0_9ck540 FIND v(dout0_9) AT=275.025n

.meas tran vdout0_10ck540 FIND v(dout0_10) AT=275.025n

.meas tran vdout0_11ck540 FIND v(dout0_11) AT=275.025n

.meas tran vdout0_12ck540 FIND v(dout0_12) AT=275.025n

.meas tran vdout0_13ck540 FIND v(dout0_13) AT=275.025n

.meas tran vdout0_14ck540 FIND v(dout0_14) AT=275.025n

.meas tran vdout0_15ck540 FIND v(dout0_15) AT=275.025n

.meas tran vdout0_16ck540 FIND v(dout0_16) AT=275.025n

.meas tran vdout0_17ck540 FIND v(dout0_17) AT=275.025n

.meas tran vdout0_18ck540 FIND v(dout0_18) AT=275.025n

.meas tran vdout0_19ck540 FIND v(dout0_19) AT=275.025n

.meas tran vdout0_20ck540 FIND v(dout0_20) AT=275.025n

.meas tran vdout0_21ck540 FIND v(dout0_21) AT=275.025n

.meas tran vdout0_22ck540 FIND v(dout0_22) AT=275.025n

.meas tran vdout0_23ck540 FIND v(dout0_23) AT=275.025n

.meas tran vdout0_24ck540 FIND v(dout0_24) AT=275.025n

.meas tran vdout0_25ck540 FIND v(dout0_25) AT=275.025n

.meas tran vdout0_26ck540 FIND v(dout0_26) AT=275.025n

.meas tran vdout0_27ck540 FIND v(dout0_27) AT=275.025n

.meas tran vdout0_28ck540 FIND v(dout0_28) AT=275.025n

.meas tran vdout0_29ck540 FIND v(dout0_29) AT=275.025n

.meas tran vdout0_30ck540 FIND v(dout0_30) AT=275.025n

.meas tran vdout0_31ck540 FIND v(dout0_31) AT=275.025n

.meas tran vdout0_32ck540 FIND v(dout0_32) AT=275.025n

.meas tran vdout0_33ck540 FIND v(dout0_33) AT=275.025n

.meas tran vdout0_34ck540 FIND v(dout0_34) AT=275.025n

.meas tran vdout0_35ck540 FIND v(dout0_35) AT=275.025n

.meas tran vdout0_36ck540 FIND v(dout0_36) AT=275.025n

.meas tran vdout0_37ck540 FIND v(dout0_37) AT=275.025n

.meas tran vdout0_38ck540 FIND v(dout0_38) AT=275.025n

.meas tran vdout0_39ck540 FIND v(dout0_39) AT=275.025n

.meas tran vdout0_40ck540 FIND v(dout0_40) AT=275.025n

.meas tran vdout0_41ck540 FIND v(dout0_41) AT=275.025n

.meas tran vdout0_42ck540 FIND v(dout0_42) AT=275.025n

.meas tran vdout0_43ck540 FIND v(dout0_43) AT=275.025n

.meas tran vdout0_44ck540 FIND v(dout0_44) AT=275.025n

.meas tran vdout0_45ck540 FIND v(dout0_45) AT=275.025n

.meas tran vdout0_46ck540 FIND v(dout0_46) AT=275.025n

.meas tran vdout0_47ck540 FIND v(dout0_47) AT=275.025n

.meas tran vdout0_48ck540 FIND v(dout0_48) AT=275.025n

.meas tran vdout0_49ck540 FIND v(dout0_49) AT=275.025n

.meas tran vdout0_50ck540 FIND v(dout0_50) AT=275.025n

.meas tran vdout0_51ck540 FIND v(dout0_51) AT=275.025n

.meas tran vdout0_52ck540 FIND v(dout0_52) AT=275.025n

.meas tran vdout0_53ck540 FIND v(dout0_53) AT=275.025n

.meas tran vdout0_54ck540 FIND v(dout0_54) AT=275.025n

.meas tran vdout0_55ck540 FIND v(dout0_55) AT=275.025n

.meas tran vdout0_56ck540 FIND v(dout0_56) AT=275.025n

.meas tran vdout0_57ck540 FIND v(dout0_57) AT=275.025n

.meas tran vdout0_58ck540 FIND v(dout0_58) AT=275.025n

.meas tran vdout0_59ck540 FIND v(dout0_59) AT=275.025n

.meas tran vdout0_60ck540 FIND v(dout0_60) AT=275.025n

.meas tran vdout0_61ck540 FIND v(dout0_61) AT=275.025n

.meas tran vdout0_62ck540 FIND v(dout0_62) AT=275.025n

.meas tran vdout0_63ck540 FIND v(dout0_63) AT=275.025n

.meas tran vdout0_64ck540 FIND v(dout0_64) AT=275.025n

.meas tran vdout0_65ck540 FIND v(dout0_65) AT=275.025n

.meas tran vdout0_66ck540 FIND v(dout0_66) AT=275.025n

.meas tran vdout0_67ck540 FIND v(dout0_67) AT=275.025n

.meas tran vdout0_68ck540 FIND v(dout0_68) AT=275.025n

.meas tran vdout0_69ck540 FIND v(dout0_69) AT=275.025n

.meas tran vdout0_70ck540 FIND v(dout0_70) AT=275.025n

.meas tran vdout0_71ck540 FIND v(dout0_71) AT=275.025n

.meas tran vdout0_72ck540 FIND v(dout0_72) AT=275.025n

.meas tran vdout0_73ck540 FIND v(dout0_73) AT=275.025n

.meas tran vdout0_74ck540 FIND v(dout0_74) AT=275.025n

.meas tran vdout0_75ck540 FIND v(dout0_75) AT=275.025n

.meas tran vdout0_76ck540 FIND v(dout0_76) AT=275.025n

.meas tran vdout0_77ck540 FIND v(dout0_77) AT=275.025n

.meas tran vdout0_78ck540 FIND v(dout0_78) AT=275.025n

.meas tran vdout0_79ck540 FIND v(dout0_79) AT=275.025n

.meas tran vdout0_80ck540 FIND v(dout0_80) AT=275.025n

.meas tran vdout0_81ck540 FIND v(dout0_81) AT=275.025n

.meas tran vdout0_82ck540 FIND v(dout0_82) AT=275.025n

.meas tran vdout0_83ck540 FIND v(dout0_83) AT=275.025n

.meas tran vdout0_84ck540 FIND v(dout0_84) AT=275.025n

.meas tran vdout0_85ck540 FIND v(dout0_85) AT=275.025n

.meas tran vdout0_86ck540 FIND v(dout0_86) AT=275.025n

.meas tran vdout0_87ck540 FIND v(dout0_87) AT=275.025n

.meas tran vdout0_88ck540 FIND v(dout0_88) AT=275.025n

.meas tran vdout0_89ck540 FIND v(dout0_89) AT=275.025n

.meas tran vdout0_90ck540 FIND v(dout0_90) AT=275.025n

.meas tran vdout0_91ck540 FIND v(dout0_91) AT=275.025n

.meas tran vdout0_92ck540 FIND v(dout0_92) AT=275.025n

.meas tran vdout0_93ck540 FIND v(dout0_93) AT=275.025n

.meas tran vdout0_94ck540 FIND v(dout0_94) AT=275.025n

.meas tran vdout0_95ck540 FIND v(dout0_95) AT=275.025n

.meas tran vdout0_96ck540 FIND v(dout0_96) AT=275.025n

.meas tran vdout0_97ck540 FIND v(dout0_97) AT=275.025n

.meas tran vdout0_98ck540 FIND v(dout0_98) AT=275.025n

.meas tran vdout0_99ck540 FIND v(dout0_99) AT=275.025n

.meas tran vdout0_100ck540 FIND v(dout0_100) AT=275.025n

.meas tran vdout0_101ck540 FIND v(dout0_101) AT=275.025n

.meas tran vdout0_102ck540 FIND v(dout0_102) AT=275.025n

.meas tran vdout0_103ck540 FIND v(dout0_103) AT=275.025n

.meas tran vdout0_104ck540 FIND v(dout0_104) AT=275.025n

.meas tran vdout0_105ck540 FIND v(dout0_105) AT=275.025n

.meas tran vdout0_106ck540 FIND v(dout0_106) AT=275.025n

.meas tran vdout0_107ck540 FIND v(dout0_107) AT=275.025n

.meas tran vdout0_108ck540 FIND v(dout0_108) AT=275.025n

.meas tran vdout0_109ck540 FIND v(dout0_109) AT=275.025n

.meas tran vdout0_110ck540 FIND v(dout0_110) AT=275.025n

.meas tran vdout0_111ck540 FIND v(dout0_111) AT=275.025n

.meas tran vdout0_112ck540 FIND v(dout0_112) AT=275.025n

.meas tran vdout0_113ck540 FIND v(dout0_113) AT=275.025n

.meas tran vdout0_114ck540 FIND v(dout0_114) AT=275.025n

.meas tran vdout0_115ck540 FIND v(dout0_115) AT=275.025n

.meas tran vdout0_116ck540 FIND v(dout0_116) AT=275.025n

.meas tran vdout0_117ck540 FIND v(dout0_117) AT=275.025n

.meas tran vdout0_118ck540 FIND v(dout0_118) AT=275.025n

.meas tran vdout0_119ck540 FIND v(dout0_119) AT=275.025n

.meas tran vdout0_120ck540 FIND v(dout0_120) AT=275.025n

.meas tran vdout0_121ck540 FIND v(dout0_121) AT=275.025n

.meas tran vdout0_122ck540 FIND v(dout0_122) AT=275.025n

.meas tran vdout0_123ck540 FIND v(dout0_123) AT=275.025n

.meas tran vdout0_124ck540 FIND v(dout0_124) AT=275.025n

.meas tran vdout0_125ck540 FIND v(dout0_125) AT=275.025n

.meas tran vdout0_126ck540 FIND v(dout0_126) AT=275.025n

.meas tran vdout0_127ck540 FIND v(dout0_127) AT=275.025n

.meas tran vdout0_128ck540 FIND v(dout0_128) AT=275.025n

.meas tran vdout0_129ck540 FIND v(dout0_129) AT=275.025n

.meas tran vdout0_130ck540 FIND v(dout0_130) AT=275.025n

.meas tran vdout0_131ck540 FIND v(dout0_131) AT=275.025n

.meas tran vdout0_132ck540 FIND v(dout0_132) AT=275.025n

.meas tran vdout0_133ck540 FIND v(dout0_133) AT=275.025n

.meas tran vdout0_134ck540 FIND v(dout0_134) AT=275.025n

.meas tran vdout0_135ck540 FIND v(dout0_135) AT=275.025n

.meas tran vdout0_136ck540 FIND v(dout0_136) AT=275.025n

.meas tran vdout0_137ck540 FIND v(dout0_137) AT=275.025n

.meas tran vdout0_138ck540 FIND v(dout0_138) AT=275.025n

.meas tran vdout0_139ck540 FIND v(dout0_139) AT=275.025n

.meas tran vdout0_140ck540 FIND v(dout0_140) AT=275.025n

.meas tran vdout0_141ck540 FIND v(dout0_141) AT=275.025n

.meas tran vdout0_142ck540 FIND v(dout0_142) AT=275.025n

.meas tran vdout0_143ck540 FIND v(dout0_143) AT=275.025n

.meas tran vdout0_144ck540 FIND v(dout0_144) AT=275.025n

.meas tran vdout0_145ck540 FIND v(dout0_145) AT=275.025n

.meas tran vdout0_146ck540 FIND v(dout0_146) AT=275.025n

.meas tran vdout0_147ck540 FIND v(dout0_147) AT=275.025n

.meas tran vdout0_148ck540 FIND v(dout0_148) AT=275.025n

.meas tran vdout0_149ck540 FIND v(dout0_149) AT=275.025n

.meas tran vdout0_150ck540 FIND v(dout0_150) AT=275.025n

.meas tran vdout0_151ck540 FIND v(dout0_151) AT=275.025n

.meas tran vdout0_152ck540 FIND v(dout0_152) AT=275.025n

.meas tran vdout0_153ck540 FIND v(dout0_153) AT=275.025n

.meas tran vdout0_154ck540 FIND v(dout0_154) AT=275.025n

.meas tran vdout0_155ck540 FIND v(dout0_155) AT=275.025n

.meas tran vdout0_156ck540 FIND v(dout0_156) AT=275.025n

.meas tran vdout0_157ck540 FIND v(dout0_157) AT=275.025n

.meas tran vdout0_158ck540 FIND v(dout0_158) AT=275.025n

.meas tran vdout0_159ck540 FIND v(dout0_159) AT=275.025n

.meas tran vdout0_160ck540 FIND v(dout0_160) AT=275.025n

.meas tran vdout0_161ck540 FIND v(dout0_161) AT=275.025n

.meas tran vdout0_162ck540 FIND v(dout0_162) AT=275.025n

.meas tran vdout0_163ck540 FIND v(dout0_163) AT=275.025n

.meas tran vdout0_164ck540 FIND v(dout0_164) AT=275.025n

.meas tran vdout0_165ck540 FIND v(dout0_165) AT=275.025n

.meas tran vdout0_166ck540 FIND v(dout0_166) AT=275.025n

.meas tran vdout0_167ck540 FIND v(dout0_167) AT=275.025n

.meas tran vdout0_168ck540 FIND v(dout0_168) AT=275.025n

.meas tran vdout0_169ck540 FIND v(dout0_169) AT=275.025n

.meas tran vdout0_170ck540 FIND v(dout0_170) AT=275.025n

.meas tran vdout0_171ck540 FIND v(dout0_171) AT=275.025n

.meas tran vdout0_172ck540 FIND v(dout0_172) AT=275.025n

.meas tran vdout0_173ck540 FIND v(dout0_173) AT=275.025n

.meas tran vdout0_174ck540 FIND v(dout0_174) AT=275.025n

.meas tran vdout0_175ck540 FIND v(dout0_175) AT=275.025n

.meas tran vdout0_176ck540 FIND v(dout0_176) AT=275.025n

.meas tran vdout0_177ck540 FIND v(dout0_177) AT=275.025n

.meas tran vdout0_178ck540 FIND v(dout0_178) AT=275.025n

.meas tran vdout0_179ck540 FIND v(dout0_179) AT=275.025n

.meas tran vdout0_180ck540 FIND v(dout0_180) AT=275.025n

.meas tran vdout0_181ck540 FIND v(dout0_181) AT=275.025n

.meas tran vdout0_182ck540 FIND v(dout0_182) AT=275.025n

.meas tran vdout0_183ck540 FIND v(dout0_183) AT=275.025n

.meas tran vdout0_184ck540 FIND v(dout0_184) AT=275.025n

.meas tran vdout0_185ck540 FIND v(dout0_185) AT=275.025n

.meas tran vdout0_186ck540 FIND v(dout0_186) AT=275.025n

.meas tran vdout0_187ck540 FIND v(dout0_187) AT=275.025n

.meas tran vdout0_188ck540 FIND v(dout0_188) AT=275.025n

.meas tran vdout0_189ck540 FIND v(dout0_189) AT=275.025n

.meas tran vdout0_190ck540 FIND v(dout0_190) AT=275.025n

.meas tran vdout0_191ck540 FIND v(dout0_191) AT=275.025n

.meas tran vdout0_192ck540 FIND v(dout0_192) AT=275.025n

.meas tran vdout0_193ck540 FIND v(dout0_193) AT=275.025n

.meas tran vdout0_194ck540 FIND v(dout0_194) AT=275.025n

.meas tran vdout0_195ck540 FIND v(dout0_195) AT=275.025n

.meas tran vdout0_196ck540 FIND v(dout0_196) AT=275.025n

.meas tran vdout0_197ck540 FIND v(dout0_197) AT=275.025n

.meas tran vdout0_198ck540 FIND v(dout0_198) AT=275.025n

.meas tran vdout0_199ck540 FIND v(dout0_199) AT=275.025n

.meas tran vdout0_200ck540 FIND v(dout0_200) AT=275.025n

.meas tran vdout0_201ck540 FIND v(dout0_201) AT=275.025n

.meas tran vdout0_202ck540 FIND v(dout0_202) AT=275.025n

.meas tran vdout0_203ck540 FIND v(dout0_203) AT=275.025n

.meas tran vdout0_204ck540 FIND v(dout0_204) AT=275.025n

.meas tran vdout0_205ck540 FIND v(dout0_205) AT=275.025n

.meas tran vdout0_206ck540 FIND v(dout0_206) AT=275.025n

.meas tran vdout0_207ck540 FIND v(dout0_207) AT=275.025n

.meas tran vdout0_208ck540 FIND v(dout0_208) AT=275.025n

.meas tran vdout0_209ck540 FIND v(dout0_209) AT=275.025n

.meas tran vdout0_210ck540 FIND v(dout0_210) AT=275.025n

.meas tran vdout0_211ck540 FIND v(dout0_211) AT=275.025n

.meas tran vdout0_212ck540 FIND v(dout0_212) AT=275.025n

.meas tran vdout0_213ck540 FIND v(dout0_213) AT=275.025n

.meas tran vdout0_214ck540 FIND v(dout0_214) AT=275.025n

.meas tran vdout0_215ck540 FIND v(dout0_215) AT=275.025n

.meas tran vdout0_216ck540 FIND v(dout0_216) AT=275.025n

.meas tran vdout0_217ck540 FIND v(dout0_217) AT=275.025n

.meas tran vdout0_218ck540 FIND v(dout0_218) AT=275.025n

.meas tran vdout0_219ck540 FIND v(dout0_219) AT=275.025n

.meas tran vdout0_220ck540 FIND v(dout0_220) AT=275.025n

.meas tran vdout0_221ck540 FIND v(dout0_221) AT=275.025n

.meas tran vdout0_222ck540 FIND v(dout0_222) AT=275.025n

.meas tran vdout0_223ck540 FIND v(dout0_223) AT=275.025n

.meas tran vdout0_224ck540 FIND v(dout0_224) AT=275.025n

.meas tran vdout0_225ck540 FIND v(dout0_225) AT=275.025n

.meas tran vdout0_226ck540 FIND v(dout0_226) AT=275.025n

.meas tran vdout0_227ck540 FIND v(dout0_227) AT=275.025n

.meas tran vdout0_228ck540 FIND v(dout0_228) AT=275.025n

.meas tran vdout0_229ck540 FIND v(dout0_229) AT=275.025n

.meas tran vdout0_230ck540 FIND v(dout0_230) AT=275.025n

.meas tran vdout0_231ck540 FIND v(dout0_231) AT=275.025n

.meas tran vdout0_232ck540 FIND v(dout0_232) AT=275.025n

.meas tran vdout0_233ck540 FIND v(dout0_233) AT=275.025n

.meas tran vdout0_234ck540 FIND v(dout0_234) AT=275.025n

.meas tran vdout0_235ck540 FIND v(dout0_235) AT=275.025n

.meas tran vdout0_236ck540 FIND v(dout0_236) AT=275.025n

.meas tran vdout0_237ck540 FIND v(dout0_237) AT=275.025n

.meas tran vdout0_238ck540 FIND v(dout0_238) AT=275.025n

.meas tran vdout0_239ck540 FIND v(dout0_239) AT=275.025n

.meas tran vdout0_240ck540 FIND v(dout0_240) AT=275.025n

.meas tran vdout0_241ck540 FIND v(dout0_241) AT=275.025n

.meas tran vdout0_242ck540 FIND v(dout0_242) AT=275.025n

.meas tran vdout0_243ck540 FIND v(dout0_243) AT=275.025n

.meas tran vdout0_244ck540 FIND v(dout0_244) AT=275.025n

.meas tran vdout0_245ck540 FIND v(dout0_245) AT=275.025n

.meas tran vdout0_246ck540 FIND v(dout0_246) AT=275.025n

.meas tran vdout0_247ck540 FIND v(dout0_247) AT=275.025n

.meas tran vdout0_248ck540 FIND v(dout0_248) AT=275.025n

.meas tran vdout0_249ck540 FIND v(dout0_249) AT=275.025n

.meas tran vdout0_250ck540 FIND v(dout0_250) AT=275.025n

.meas tran vdout0_251ck540 FIND v(dout0_251) AT=275.025n

.meas tran vdout0_252ck540 FIND v(dout0_252) AT=275.025n

.meas tran vdout0_253ck540 FIND v(dout0_253) AT=275.025n

.meas tran vdout0_254ck540 FIND v(dout0_254) AT=275.025n

.meas tran vdout0_255ck540 FIND v(dout0_255) AT=275.025n

.meas tran vdout0_0ck570 FIND v(dout0_0) AT=290.025n

.meas tran vdout0_1ck570 FIND v(dout0_1) AT=290.025n

.meas tran vdout0_2ck570 FIND v(dout0_2) AT=290.025n

.meas tran vdout0_3ck570 FIND v(dout0_3) AT=290.025n

.meas tran vdout0_4ck570 FIND v(dout0_4) AT=290.025n

.meas tran vdout0_5ck570 FIND v(dout0_5) AT=290.025n

.meas tran vdout0_6ck570 FIND v(dout0_6) AT=290.025n

.meas tran vdout0_7ck570 FIND v(dout0_7) AT=290.025n

.meas tran vdout0_8ck570 FIND v(dout0_8) AT=290.025n

.meas tran vdout0_9ck570 FIND v(dout0_9) AT=290.025n

.meas tran vdout0_10ck570 FIND v(dout0_10) AT=290.025n

.meas tran vdout0_11ck570 FIND v(dout0_11) AT=290.025n

.meas tran vdout0_12ck570 FIND v(dout0_12) AT=290.025n

.meas tran vdout0_13ck570 FIND v(dout0_13) AT=290.025n

.meas tran vdout0_14ck570 FIND v(dout0_14) AT=290.025n

.meas tran vdout0_15ck570 FIND v(dout0_15) AT=290.025n

.meas tran vdout0_16ck570 FIND v(dout0_16) AT=290.025n

.meas tran vdout0_17ck570 FIND v(dout0_17) AT=290.025n

.meas tran vdout0_18ck570 FIND v(dout0_18) AT=290.025n

.meas tran vdout0_19ck570 FIND v(dout0_19) AT=290.025n

.meas tran vdout0_20ck570 FIND v(dout0_20) AT=290.025n

.meas tran vdout0_21ck570 FIND v(dout0_21) AT=290.025n

.meas tran vdout0_22ck570 FIND v(dout0_22) AT=290.025n

.meas tran vdout0_23ck570 FIND v(dout0_23) AT=290.025n

.meas tran vdout0_24ck570 FIND v(dout0_24) AT=290.025n

.meas tran vdout0_25ck570 FIND v(dout0_25) AT=290.025n

.meas tran vdout0_26ck570 FIND v(dout0_26) AT=290.025n

.meas tran vdout0_27ck570 FIND v(dout0_27) AT=290.025n

.meas tran vdout0_28ck570 FIND v(dout0_28) AT=290.025n

.meas tran vdout0_29ck570 FIND v(dout0_29) AT=290.025n

.meas tran vdout0_30ck570 FIND v(dout0_30) AT=290.025n

.meas tran vdout0_31ck570 FIND v(dout0_31) AT=290.025n

.meas tran vdout0_32ck570 FIND v(dout0_32) AT=290.025n

.meas tran vdout0_33ck570 FIND v(dout0_33) AT=290.025n

.meas tran vdout0_34ck570 FIND v(dout0_34) AT=290.025n

.meas tran vdout0_35ck570 FIND v(dout0_35) AT=290.025n

.meas tran vdout0_36ck570 FIND v(dout0_36) AT=290.025n

.meas tran vdout0_37ck570 FIND v(dout0_37) AT=290.025n

.meas tran vdout0_38ck570 FIND v(dout0_38) AT=290.025n

.meas tran vdout0_39ck570 FIND v(dout0_39) AT=290.025n

.meas tran vdout0_40ck570 FIND v(dout0_40) AT=290.025n

.meas tran vdout0_41ck570 FIND v(dout0_41) AT=290.025n

.meas tran vdout0_42ck570 FIND v(dout0_42) AT=290.025n

.meas tran vdout0_43ck570 FIND v(dout0_43) AT=290.025n

.meas tran vdout0_44ck570 FIND v(dout0_44) AT=290.025n

.meas tran vdout0_45ck570 FIND v(dout0_45) AT=290.025n

.meas tran vdout0_46ck570 FIND v(dout0_46) AT=290.025n

.meas tran vdout0_47ck570 FIND v(dout0_47) AT=290.025n

.meas tran vdout0_48ck570 FIND v(dout0_48) AT=290.025n

.meas tran vdout0_49ck570 FIND v(dout0_49) AT=290.025n

.meas tran vdout0_50ck570 FIND v(dout0_50) AT=290.025n

.meas tran vdout0_51ck570 FIND v(dout0_51) AT=290.025n

.meas tran vdout0_52ck570 FIND v(dout0_52) AT=290.025n

.meas tran vdout0_53ck570 FIND v(dout0_53) AT=290.025n

.meas tran vdout0_54ck570 FIND v(dout0_54) AT=290.025n

.meas tran vdout0_55ck570 FIND v(dout0_55) AT=290.025n

.meas tran vdout0_56ck570 FIND v(dout0_56) AT=290.025n

.meas tran vdout0_57ck570 FIND v(dout0_57) AT=290.025n

.meas tran vdout0_58ck570 FIND v(dout0_58) AT=290.025n

.meas tran vdout0_59ck570 FIND v(dout0_59) AT=290.025n

.meas tran vdout0_60ck570 FIND v(dout0_60) AT=290.025n

.meas tran vdout0_61ck570 FIND v(dout0_61) AT=290.025n

.meas tran vdout0_62ck570 FIND v(dout0_62) AT=290.025n

.meas tran vdout0_63ck570 FIND v(dout0_63) AT=290.025n

.meas tran vdout0_64ck570 FIND v(dout0_64) AT=290.025n

.meas tran vdout0_65ck570 FIND v(dout0_65) AT=290.025n

.meas tran vdout0_66ck570 FIND v(dout0_66) AT=290.025n

.meas tran vdout0_67ck570 FIND v(dout0_67) AT=290.025n

.meas tran vdout0_68ck570 FIND v(dout0_68) AT=290.025n

.meas tran vdout0_69ck570 FIND v(dout0_69) AT=290.025n

.meas tran vdout0_70ck570 FIND v(dout0_70) AT=290.025n

.meas tran vdout0_71ck570 FIND v(dout0_71) AT=290.025n

.meas tran vdout0_72ck570 FIND v(dout0_72) AT=290.025n

.meas tran vdout0_73ck570 FIND v(dout0_73) AT=290.025n

.meas tran vdout0_74ck570 FIND v(dout0_74) AT=290.025n

.meas tran vdout0_75ck570 FIND v(dout0_75) AT=290.025n

.meas tran vdout0_76ck570 FIND v(dout0_76) AT=290.025n

.meas tran vdout0_77ck570 FIND v(dout0_77) AT=290.025n

.meas tran vdout0_78ck570 FIND v(dout0_78) AT=290.025n

.meas tran vdout0_79ck570 FIND v(dout0_79) AT=290.025n

.meas tran vdout0_80ck570 FIND v(dout0_80) AT=290.025n

.meas tran vdout0_81ck570 FIND v(dout0_81) AT=290.025n

.meas tran vdout0_82ck570 FIND v(dout0_82) AT=290.025n

.meas tran vdout0_83ck570 FIND v(dout0_83) AT=290.025n

.meas tran vdout0_84ck570 FIND v(dout0_84) AT=290.025n

.meas tran vdout0_85ck570 FIND v(dout0_85) AT=290.025n

.meas tran vdout0_86ck570 FIND v(dout0_86) AT=290.025n

.meas tran vdout0_87ck570 FIND v(dout0_87) AT=290.025n

.meas tran vdout0_88ck570 FIND v(dout0_88) AT=290.025n

.meas tran vdout0_89ck570 FIND v(dout0_89) AT=290.025n

.meas tran vdout0_90ck570 FIND v(dout0_90) AT=290.025n

.meas tran vdout0_91ck570 FIND v(dout0_91) AT=290.025n

.meas tran vdout0_92ck570 FIND v(dout0_92) AT=290.025n

.meas tran vdout0_93ck570 FIND v(dout0_93) AT=290.025n

.meas tran vdout0_94ck570 FIND v(dout0_94) AT=290.025n

.meas tran vdout0_95ck570 FIND v(dout0_95) AT=290.025n

.meas tran vdout0_96ck570 FIND v(dout0_96) AT=290.025n

.meas tran vdout0_97ck570 FIND v(dout0_97) AT=290.025n

.meas tran vdout0_98ck570 FIND v(dout0_98) AT=290.025n

.meas tran vdout0_99ck570 FIND v(dout0_99) AT=290.025n

.meas tran vdout0_100ck570 FIND v(dout0_100) AT=290.025n

.meas tran vdout0_101ck570 FIND v(dout0_101) AT=290.025n

.meas tran vdout0_102ck570 FIND v(dout0_102) AT=290.025n

.meas tran vdout0_103ck570 FIND v(dout0_103) AT=290.025n

.meas tran vdout0_104ck570 FIND v(dout0_104) AT=290.025n

.meas tran vdout0_105ck570 FIND v(dout0_105) AT=290.025n

.meas tran vdout0_106ck570 FIND v(dout0_106) AT=290.025n

.meas tran vdout0_107ck570 FIND v(dout0_107) AT=290.025n

.meas tran vdout0_108ck570 FIND v(dout0_108) AT=290.025n

.meas tran vdout0_109ck570 FIND v(dout0_109) AT=290.025n

.meas tran vdout0_110ck570 FIND v(dout0_110) AT=290.025n

.meas tran vdout0_111ck570 FIND v(dout0_111) AT=290.025n

.meas tran vdout0_112ck570 FIND v(dout0_112) AT=290.025n

.meas tran vdout0_113ck570 FIND v(dout0_113) AT=290.025n

.meas tran vdout0_114ck570 FIND v(dout0_114) AT=290.025n

.meas tran vdout0_115ck570 FIND v(dout0_115) AT=290.025n

.meas tran vdout0_116ck570 FIND v(dout0_116) AT=290.025n

.meas tran vdout0_117ck570 FIND v(dout0_117) AT=290.025n

.meas tran vdout0_118ck570 FIND v(dout0_118) AT=290.025n

.meas tran vdout0_119ck570 FIND v(dout0_119) AT=290.025n

.meas tran vdout0_120ck570 FIND v(dout0_120) AT=290.025n

.meas tran vdout0_121ck570 FIND v(dout0_121) AT=290.025n

.meas tran vdout0_122ck570 FIND v(dout0_122) AT=290.025n

.meas tran vdout0_123ck570 FIND v(dout0_123) AT=290.025n

.meas tran vdout0_124ck570 FIND v(dout0_124) AT=290.025n

.meas tran vdout0_125ck570 FIND v(dout0_125) AT=290.025n

.meas tran vdout0_126ck570 FIND v(dout0_126) AT=290.025n

.meas tran vdout0_127ck570 FIND v(dout0_127) AT=290.025n

.meas tran vdout0_128ck570 FIND v(dout0_128) AT=290.025n

.meas tran vdout0_129ck570 FIND v(dout0_129) AT=290.025n

.meas tran vdout0_130ck570 FIND v(dout0_130) AT=290.025n

.meas tran vdout0_131ck570 FIND v(dout0_131) AT=290.025n

.meas tran vdout0_132ck570 FIND v(dout0_132) AT=290.025n

.meas tran vdout0_133ck570 FIND v(dout0_133) AT=290.025n

.meas tran vdout0_134ck570 FIND v(dout0_134) AT=290.025n

.meas tran vdout0_135ck570 FIND v(dout0_135) AT=290.025n

.meas tran vdout0_136ck570 FIND v(dout0_136) AT=290.025n

.meas tran vdout0_137ck570 FIND v(dout0_137) AT=290.025n

.meas tran vdout0_138ck570 FIND v(dout0_138) AT=290.025n

.meas tran vdout0_139ck570 FIND v(dout0_139) AT=290.025n

.meas tran vdout0_140ck570 FIND v(dout0_140) AT=290.025n

.meas tran vdout0_141ck570 FIND v(dout0_141) AT=290.025n

.meas tran vdout0_142ck570 FIND v(dout0_142) AT=290.025n

.meas tran vdout0_143ck570 FIND v(dout0_143) AT=290.025n

.meas tran vdout0_144ck570 FIND v(dout0_144) AT=290.025n

.meas tran vdout0_145ck570 FIND v(dout0_145) AT=290.025n

.meas tran vdout0_146ck570 FIND v(dout0_146) AT=290.025n

.meas tran vdout0_147ck570 FIND v(dout0_147) AT=290.025n

.meas tran vdout0_148ck570 FIND v(dout0_148) AT=290.025n

.meas tran vdout0_149ck570 FIND v(dout0_149) AT=290.025n

.meas tran vdout0_150ck570 FIND v(dout0_150) AT=290.025n

.meas tran vdout0_151ck570 FIND v(dout0_151) AT=290.025n

.meas tran vdout0_152ck570 FIND v(dout0_152) AT=290.025n

.meas tran vdout0_153ck570 FIND v(dout0_153) AT=290.025n

.meas tran vdout0_154ck570 FIND v(dout0_154) AT=290.025n

.meas tran vdout0_155ck570 FIND v(dout0_155) AT=290.025n

.meas tran vdout0_156ck570 FIND v(dout0_156) AT=290.025n

.meas tran vdout0_157ck570 FIND v(dout0_157) AT=290.025n

.meas tran vdout0_158ck570 FIND v(dout0_158) AT=290.025n

.meas tran vdout0_159ck570 FIND v(dout0_159) AT=290.025n

.meas tran vdout0_160ck570 FIND v(dout0_160) AT=290.025n

.meas tran vdout0_161ck570 FIND v(dout0_161) AT=290.025n

.meas tran vdout0_162ck570 FIND v(dout0_162) AT=290.025n

.meas tran vdout0_163ck570 FIND v(dout0_163) AT=290.025n

.meas tran vdout0_164ck570 FIND v(dout0_164) AT=290.025n

.meas tran vdout0_165ck570 FIND v(dout0_165) AT=290.025n

.meas tran vdout0_166ck570 FIND v(dout0_166) AT=290.025n

.meas tran vdout0_167ck570 FIND v(dout0_167) AT=290.025n

.meas tran vdout0_168ck570 FIND v(dout0_168) AT=290.025n

.meas tran vdout0_169ck570 FIND v(dout0_169) AT=290.025n

.meas tran vdout0_170ck570 FIND v(dout0_170) AT=290.025n

.meas tran vdout0_171ck570 FIND v(dout0_171) AT=290.025n

.meas tran vdout0_172ck570 FIND v(dout0_172) AT=290.025n

.meas tran vdout0_173ck570 FIND v(dout0_173) AT=290.025n

.meas tran vdout0_174ck570 FIND v(dout0_174) AT=290.025n

.meas tran vdout0_175ck570 FIND v(dout0_175) AT=290.025n

.meas tran vdout0_176ck570 FIND v(dout0_176) AT=290.025n

.meas tran vdout0_177ck570 FIND v(dout0_177) AT=290.025n

.meas tran vdout0_178ck570 FIND v(dout0_178) AT=290.025n

.meas tran vdout0_179ck570 FIND v(dout0_179) AT=290.025n

.meas tran vdout0_180ck570 FIND v(dout0_180) AT=290.025n

.meas tran vdout0_181ck570 FIND v(dout0_181) AT=290.025n

.meas tran vdout0_182ck570 FIND v(dout0_182) AT=290.025n

.meas tran vdout0_183ck570 FIND v(dout0_183) AT=290.025n

.meas tran vdout0_184ck570 FIND v(dout0_184) AT=290.025n

.meas tran vdout0_185ck570 FIND v(dout0_185) AT=290.025n

.meas tran vdout0_186ck570 FIND v(dout0_186) AT=290.025n

.meas tran vdout0_187ck570 FIND v(dout0_187) AT=290.025n

.meas tran vdout0_188ck570 FIND v(dout0_188) AT=290.025n

.meas tran vdout0_189ck570 FIND v(dout0_189) AT=290.025n

.meas tran vdout0_190ck570 FIND v(dout0_190) AT=290.025n

.meas tran vdout0_191ck570 FIND v(dout0_191) AT=290.025n

.meas tran vdout0_192ck570 FIND v(dout0_192) AT=290.025n

.meas tran vdout0_193ck570 FIND v(dout0_193) AT=290.025n

.meas tran vdout0_194ck570 FIND v(dout0_194) AT=290.025n

.meas tran vdout0_195ck570 FIND v(dout0_195) AT=290.025n

.meas tran vdout0_196ck570 FIND v(dout0_196) AT=290.025n

.meas tran vdout0_197ck570 FIND v(dout0_197) AT=290.025n

.meas tran vdout0_198ck570 FIND v(dout0_198) AT=290.025n

.meas tran vdout0_199ck570 FIND v(dout0_199) AT=290.025n

.meas tran vdout0_200ck570 FIND v(dout0_200) AT=290.025n

.meas tran vdout0_201ck570 FIND v(dout0_201) AT=290.025n

.meas tran vdout0_202ck570 FIND v(dout0_202) AT=290.025n

.meas tran vdout0_203ck570 FIND v(dout0_203) AT=290.025n

.meas tran vdout0_204ck570 FIND v(dout0_204) AT=290.025n

.meas tran vdout0_205ck570 FIND v(dout0_205) AT=290.025n

.meas tran vdout0_206ck570 FIND v(dout0_206) AT=290.025n

.meas tran vdout0_207ck570 FIND v(dout0_207) AT=290.025n

.meas tran vdout0_208ck570 FIND v(dout0_208) AT=290.025n

.meas tran vdout0_209ck570 FIND v(dout0_209) AT=290.025n

.meas tran vdout0_210ck570 FIND v(dout0_210) AT=290.025n

.meas tran vdout0_211ck570 FIND v(dout0_211) AT=290.025n

.meas tran vdout0_212ck570 FIND v(dout0_212) AT=290.025n

.meas tran vdout0_213ck570 FIND v(dout0_213) AT=290.025n

.meas tran vdout0_214ck570 FIND v(dout0_214) AT=290.025n

.meas tran vdout0_215ck570 FIND v(dout0_215) AT=290.025n

.meas tran vdout0_216ck570 FIND v(dout0_216) AT=290.025n

.meas tran vdout0_217ck570 FIND v(dout0_217) AT=290.025n

.meas tran vdout0_218ck570 FIND v(dout0_218) AT=290.025n

.meas tran vdout0_219ck570 FIND v(dout0_219) AT=290.025n

.meas tran vdout0_220ck570 FIND v(dout0_220) AT=290.025n

.meas tran vdout0_221ck570 FIND v(dout0_221) AT=290.025n

.meas tran vdout0_222ck570 FIND v(dout0_222) AT=290.025n

.meas tran vdout0_223ck570 FIND v(dout0_223) AT=290.025n

.meas tran vdout0_224ck570 FIND v(dout0_224) AT=290.025n

.meas tran vdout0_225ck570 FIND v(dout0_225) AT=290.025n

.meas tran vdout0_226ck570 FIND v(dout0_226) AT=290.025n

.meas tran vdout0_227ck570 FIND v(dout0_227) AT=290.025n

.meas tran vdout0_228ck570 FIND v(dout0_228) AT=290.025n

.meas tran vdout0_229ck570 FIND v(dout0_229) AT=290.025n

.meas tran vdout0_230ck570 FIND v(dout0_230) AT=290.025n

.meas tran vdout0_231ck570 FIND v(dout0_231) AT=290.025n

.meas tran vdout0_232ck570 FIND v(dout0_232) AT=290.025n

.meas tran vdout0_233ck570 FIND v(dout0_233) AT=290.025n

.meas tran vdout0_234ck570 FIND v(dout0_234) AT=290.025n

.meas tran vdout0_235ck570 FIND v(dout0_235) AT=290.025n

.meas tran vdout0_236ck570 FIND v(dout0_236) AT=290.025n

.meas tran vdout0_237ck570 FIND v(dout0_237) AT=290.025n

.meas tran vdout0_238ck570 FIND v(dout0_238) AT=290.025n

.meas tran vdout0_239ck570 FIND v(dout0_239) AT=290.025n

.meas tran vdout0_240ck570 FIND v(dout0_240) AT=290.025n

.meas tran vdout0_241ck570 FIND v(dout0_241) AT=290.025n

.meas tran vdout0_242ck570 FIND v(dout0_242) AT=290.025n

.meas tran vdout0_243ck570 FIND v(dout0_243) AT=290.025n

.meas tran vdout0_244ck570 FIND v(dout0_244) AT=290.025n

.meas tran vdout0_245ck570 FIND v(dout0_245) AT=290.025n

.meas tran vdout0_246ck570 FIND v(dout0_246) AT=290.025n

.meas tran vdout0_247ck570 FIND v(dout0_247) AT=290.025n

.meas tran vdout0_248ck570 FIND v(dout0_248) AT=290.025n

.meas tran vdout0_249ck570 FIND v(dout0_249) AT=290.025n

.meas tran vdout0_250ck570 FIND v(dout0_250) AT=290.025n

.meas tran vdout0_251ck570 FIND v(dout0_251) AT=290.025n

.meas tran vdout0_252ck570 FIND v(dout0_252) AT=290.025n

.meas tran vdout0_253ck570 FIND v(dout0_253) AT=290.025n

.meas tran vdout0_254ck570 FIND v(dout0_254) AT=290.025n

.meas tran vdout0_255ck570 FIND v(dout0_255) AT=290.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_128ck580 FIND v(dout0_128) AT=295.025n

.meas tran vdout0_129ck580 FIND v(dout0_129) AT=295.025n

.meas tran vdout0_130ck580 FIND v(dout0_130) AT=295.025n

.meas tran vdout0_131ck580 FIND v(dout0_131) AT=295.025n

.meas tran vdout0_132ck580 FIND v(dout0_132) AT=295.025n

.meas tran vdout0_133ck580 FIND v(dout0_133) AT=295.025n

.meas tran vdout0_134ck580 FIND v(dout0_134) AT=295.025n

.meas tran vdout0_135ck580 FIND v(dout0_135) AT=295.025n

.meas tran vdout0_136ck580 FIND v(dout0_136) AT=295.025n

.meas tran vdout0_137ck580 FIND v(dout0_137) AT=295.025n

.meas tran vdout0_138ck580 FIND v(dout0_138) AT=295.025n

.meas tran vdout0_139ck580 FIND v(dout0_139) AT=295.025n

.meas tran vdout0_140ck580 FIND v(dout0_140) AT=295.025n

.meas tran vdout0_141ck580 FIND v(dout0_141) AT=295.025n

.meas tran vdout0_142ck580 FIND v(dout0_142) AT=295.025n

.meas tran vdout0_143ck580 FIND v(dout0_143) AT=295.025n

.meas tran vdout0_144ck580 FIND v(dout0_144) AT=295.025n

.meas tran vdout0_145ck580 FIND v(dout0_145) AT=295.025n

.meas tran vdout0_146ck580 FIND v(dout0_146) AT=295.025n

.meas tran vdout0_147ck580 FIND v(dout0_147) AT=295.025n

.meas tran vdout0_148ck580 FIND v(dout0_148) AT=295.025n

.meas tran vdout0_149ck580 FIND v(dout0_149) AT=295.025n

.meas tran vdout0_150ck580 FIND v(dout0_150) AT=295.025n

.meas tran vdout0_151ck580 FIND v(dout0_151) AT=295.025n

.meas tran vdout0_152ck580 FIND v(dout0_152) AT=295.025n

.meas tran vdout0_153ck580 FIND v(dout0_153) AT=295.025n

.meas tran vdout0_154ck580 FIND v(dout0_154) AT=295.025n

.meas tran vdout0_155ck580 FIND v(dout0_155) AT=295.025n

.meas tran vdout0_156ck580 FIND v(dout0_156) AT=295.025n

.meas tran vdout0_157ck580 FIND v(dout0_157) AT=295.025n

.meas tran vdout0_158ck580 FIND v(dout0_158) AT=295.025n

.meas tran vdout0_159ck580 FIND v(dout0_159) AT=295.025n

.meas tran vdout0_160ck580 FIND v(dout0_160) AT=295.025n

.meas tran vdout0_161ck580 FIND v(dout0_161) AT=295.025n

.meas tran vdout0_162ck580 FIND v(dout0_162) AT=295.025n

.meas tran vdout0_163ck580 FIND v(dout0_163) AT=295.025n

.meas tran vdout0_164ck580 FIND v(dout0_164) AT=295.025n

.meas tran vdout0_165ck580 FIND v(dout0_165) AT=295.025n

.meas tran vdout0_166ck580 FIND v(dout0_166) AT=295.025n

.meas tran vdout0_167ck580 FIND v(dout0_167) AT=295.025n

.meas tran vdout0_168ck580 FIND v(dout0_168) AT=295.025n

.meas tran vdout0_169ck580 FIND v(dout0_169) AT=295.025n

.meas tran vdout0_170ck580 FIND v(dout0_170) AT=295.025n

.meas tran vdout0_171ck580 FIND v(dout0_171) AT=295.025n

.meas tran vdout0_172ck580 FIND v(dout0_172) AT=295.025n

.meas tran vdout0_173ck580 FIND v(dout0_173) AT=295.025n

.meas tran vdout0_174ck580 FIND v(dout0_174) AT=295.025n

.meas tran vdout0_175ck580 FIND v(dout0_175) AT=295.025n

.meas tran vdout0_176ck580 FIND v(dout0_176) AT=295.025n

.meas tran vdout0_177ck580 FIND v(dout0_177) AT=295.025n

.meas tran vdout0_178ck580 FIND v(dout0_178) AT=295.025n

.meas tran vdout0_179ck580 FIND v(dout0_179) AT=295.025n

.meas tran vdout0_180ck580 FIND v(dout0_180) AT=295.025n

.meas tran vdout0_181ck580 FIND v(dout0_181) AT=295.025n

.meas tran vdout0_182ck580 FIND v(dout0_182) AT=295.025n

.meas tran vdout0_183ck580 FIND v(dout0_183) AT=295.025n

.meas tran vdout0_184ck580 FIND v(dout0_184) AT=295.025n

.meas tran vdout0_185ck580 FIND v(dout0_185) AT=295.025n

.meas tran vdout0_186ck580 FIND v(dout0_186) AT=295.025n

.meas tran vdout0_187ck580 FIND v(dout0_187) AT=295.025n

.meas tran vdout0_188ck580 FIND v(dout0_188) AT=295.025n

.meas tran vdout0_189ck580 FIND v(dout0_189) AT=295.025n

.meas tran vdout0_190ck580 FIND v(dout0_190) AT=295.025n

.meas tran vdout0_191ck580 FIND v(dout0_191) AT=295.025n

.meas tran vdout0_192ck580 FIND v(dout0_192) AT=295.025n

.meas tran vdout0_193ck580 FIND v(dout0_193) AT=295.025n

.meas tran vdout0_194ck580 FIND v(dout0_194) AT=295.025n

.meas tran vdout0_195ck580 FIND v(dout0_195) AT=295.025n

.meas tran vdout0_196ck580 FIND v(dout0_196) AT=295.025n

.meas tran vdout0_197ck580 FIND v(dout0_197) AT=295.025n

.meas tran vdout0_198ck580 FIND v(dout0_198) AT=295.025n

.meas tran vdout0_199ck580 FIND v(dout0_199) AT=295.025n

.meas tran vdout0_200ck580 FIND v(dout0_200) AT=295.025n

.meas tran vdout0_201ck580 FIND v(dout0_201) AT=295.025n

.meas tran vdout0_202ck580 FIND v(dout0_202) AT=295.025n

.meas tran vdout0_203ck580 FIND v(dout0_203) AT=295.025n

.meas tran vdout0_204ck580 FIND v(dout0_204) AT=295.025n

.meas tran vdout0_205ck580 FIND v(dout0_205) AT=295.025n

.meas tran vdout0_206ck580 FIND v(dout0_206) AT=295.025n

.meas tran vdout0_207ck580 FIND v(dout0_207) AT=295.025n

.meas tran vdout0_208ck580 FIND v(dout0_208) AT=295.025n

.meas tran vdout0_209ck580 FIND v(dout0_209) AT=295.025n

.meas tran vdout0_210ck580 FIND v(dout0_210) AT=295.025n

.meas tran vdout0_211ck580 FIND v(dout0_211) AT=295.025n

.meas tran vdout0_212ck580 FIND v(dout0_212) AT=295.025n

.meas tran vdout0_213ck580 FIND v(dout0_213) AT=295.025n

.meas tran vdout0_214ck580 FIND v(dout0_214) AT=295.025n

.meas tran vdout0_215ck580 FIND v(dout0_215) AT=295.025n

.meas tran vdout0_216ck580 FIND v(dout0_216) AT=295.025n

.meas tran vdout0_217ck580 FIND v(dout0_217) AT=295.025n

.meas tran vdout0_218ck580 FIND v(dout0_218) AT=295.025n

.meas tran vdout0_219ck580 FIND v(dout0_219) AT=295.025n

.meas tran vdout0_220ck580 FIND v(dout0_220) AT=295.025n

.meas tran vdout0_221ck580 FIND v(dout0_221) AT=295.025n

.meas tran vdout0_222ck580 FIND v(dout0_222) AT=295.025n

.meas tran vdout0_223ck580 FIND v(dout0_223) AT=295.025n

.meas tran vdout0_224ck580 FIND v(dout0_224) AT=295.025n

.meas tran vdout0_225ck580 FIND v(dout0_225) AT=295.025n

.meas tran vdout0_226ck580 FIND v(dout0_226) AT=295.025n

.meas tran vdout0_227ck580 FIND v(dout0_227) AT=295.025n

.meas tran vdout0_228ck580 FIND v(dout0_228) AT=295.025n

.meas tran vdout0_229ck580 FIND v(dout0_229) AT=295.025n

.meas tran vdout0_230ck580 FIND v(dout0_230) AT=295.025n

.meas tran vdout0_231ck580 FIND v(dout0_231) AT=295.025n

.meas tran vdout0_232ck580 FIND v(dout0_232) AT=295.025n

.meas tran vdout0_233ck580 FIND v(dout0_233) AT=295.025n

.meas tran vdout0_234ck580 FIND v(dout0_234) AT=295.025n

.meas tran vdout0_235ck580 FIND v(dout0_235) AT=295.025n

.meas tran vdout0_236ck580 FIND v(dout0_236) AT=295.025n

.meas tran vdout0_237ck580 FIND v(dout0_237) AT=295.025n

.meas tran vdout0_238ck580 FIND v(dout0_238) AT=295.025n

.meas tran vdout0_239ck580 FIND v(dout0_239) AT=295.025n

.meas tran vdout0_240ck580 FIND v(dout0_240) AT=295.025n

.meas tran vdout0_241ck580 FIND v(dout0_241) AT=295.025n

.meas tran vdout0_242ck580 FIND v(dout0_242) AT=295.025n

.meas tran vdout0_243ck580 FIND v(dout0_243) AT=295.025n

.meas tran vdout0_244ck580 FIND v(dout0_244) AT=295.025n

.meas tran vdout0_245ck580 FIND v(dout0_245) AT=295.025n

.meas tran vdout0_246ck580 FIND v(dout0_246) AT=295.025n

.meas tran vdout0_247ck580 FIND v(dout0_247) AT=295.025n

.meas tran vdout0_248ck580 FIND v(dout0_248) AT=295.025n

.meas tran vdout0_249ck580 FIND v(dout0_249) AT=295.025n

.meas tran vdout0_250ck580 FIND v(dout0_250) AT=295.025n

.meas tran vdout0_251ck580 FIND v(dout0_251) AT=295.025n

.meas tran vdout0_252ck580 FIND v(dout0_252) AT=295.025n

.meas tran vdout0_253ck580 FIND v(dout0_253) AT=295.025n

.meas tran vdout0_254ck580 FIND v(dout0_254) AT=295.025n

.meas tran vdout0_255ck580 FIND v(dout0_255) AT=295.025n

.meas tran vdout0_0ck620 FIND v(dout0_0) AT=315.025n

.meas tran vdout0_1ck620 FIND v(dout0_1) AT=315.025n

.meas tran vdout0_2ck620 FIND v(dout0_2) AT=315.025n

.meas tran vdout0_3ck620 FIND v(dout0_3) AT=315.025n

.meas tran vdout0_4ck620 FIND v(dout0_4) AT=315.025n

.meas tran vdout0_5ck620 FIND v(dout0_5) AT=315.025n

.meas tran vdout0_6ck620 FIND v(dout0_6) AT=315.025n

.meas tran vdout0_7ck620 FIND v(dout0_7) AT=315.025n

.meas tran vdout0_8ck620 FIND v(dout0_8) AT=315.025n

.meas tran vdout0_9ck620 FIND v(dout0_9) AT=315.025n

.meas tran vdout0_10ck620 FIND v(dout0_10) AT=315.025n

.meas tran vdout0_11ck620 FIND v(dout0_11) AT=315.025n

.meas tran vdout0_12ck620 FIND v(dout0_12) AT=315.025n

.meas tran vdout0_13ck620 FIND v(dout0_13) AT=315.025n

.meas tran vdout0_14ck620 FIND v(dout0_14) AT=315.025n

.meas tran vdout0_15ck620 FIND v(dout0_15) AT=315.025n

.meas tran vdout0_16ck620 FIND v(dout0_16) AT=315.025n

.meas tran vdout0_17ck620 FIND v(dout0_17) AT=315.025n

.meas tran vdout0_18ck620 FIND v(dout0_18) AT=315.025n

.meas tran vdout0_19ck620 FIND v(dout0_19) AT=315.025n

.meas tran vdout0_20ck620 FIND v(dout0_20) AT=315.025n

.meas tran vdout0_21ck620 FIND v(dout0_21) AT=315.025n

.meas tran vdout0_22ck620 FIND v(dout0_22) AT=315.025n

.meas tran vdout0_23ck620 FIND v(dout0_23) AT=315.025n

.meas tran vdout0_24ck620 FIND v(dout0_24) AT=315.025n

.meas tran vdout0_25ck620 FIND v(dout0_25) AT=315.025n

.meas tran vdout0_26ck620 FIND v(dout0_26) AT=315.025n

.meas tran vdout0_27ck620 FIND v(dout0_27) AT=315.025n

.meas tran vdout0_28ck620 FIND v(dout0_28) AT=315.025n

.meas tran vdout0_29ck620 FIND v(dout0_29) AT=315.025n

.meas tran vdout0_30ck620 FIND v(dout0_30) AT=315.025n

.meas tran vdout0_31ck620 FIND v(dout0_31) AT=315.025n

.meas tran vdout0_32ck620 FIND v(dout0_32) AT=315.025n

.meas tran vdout0_33ck620 FIND v(dout0_33) AT=315.025n

.meas tran vdout0_34ck620 FIND v(dout0_34) AT=315.025n

.meas tran vdout0_35ck620 FIND v(dout0_35) AT=315.025n

.meas tran vdout0_36ck620 FIND v(dout0_36) AT=315.025n

.meas tran vdout0_37ck620 FIND v(dout0_37) AT=315.025n

.meas tran vdout0_38ck620 FIND v(dout0_38) AT=315.025n

.meas tran vdout0_39ck620 FIND v(dout0_39) AT=315.025n

.meas tran vdout0_40ck620 FIND v(dout0_40) AT=315.025n

.meas tran vdout0_41ck620 FIND v(dout0_41) AT=315.025n

.meas tran vdout0_42ck620 FIND v(dout0_42) AT=315.025n

.meas tran vdout0_43ck620 FIND v(dout0_43) AT=315.025n

.meas tran vdout0_44ck620 FIND v(dout0_44) AT=315.025n

.meas tran vdout0_45ck620 FIND v(dout0_45) AT=315.025n

.meas tran vdout0_46ck620 FIND v(dout0_46) AT=315.025n

.meas tran vdout0_47ck620 FIND v(dout0_47) AT=315.025n

.meas tran vdout0_48ck620 FIND v(dout0_48) AT=315.025n

.meas tran vdout0_49ck620 FIND v(dout0_49) AT=315.025n

.meas tran vdout0_50ck620 FIND v(dout0_50) AT=315.025n

.meas tran vdout0_51ck620 FIND v(dout0_51) AT=315.025n

.meas tran vdout0_52ck620 FIND v(dout0_52) AT=315.025n

.meas tran vdout0_53ck620 FIND v(dout0_53) AT=315.025n

.meas tran vdout0_54ck620 FIND v(dout0_54) AT=315.025n

.meas tran vdout0_55ck620 FIND v(dout0_55) AT=315.025n

.meas tran vdout0_56ck620 FIND v(dout0_56) AT=315.025n

.meas tran vdout0_57ck620 FIND v(dout0_57) AT=315.025n

.meas tran vdout0_58ck620 FIND v(dout0_58) AT=315.025n

.meas tran vdout0_59ck620 FIND v(dout0_59) AT=315.025n

.meas tran vdout0_60ck620 FIND v(dout0_60) AT=315.025n

.meas tran vdout0_61ck620 FIND v(dout0_61) AT=315.025n

.meas tran vdout0_62ck620 FIND v(dout0_62) AT=315.025n

.meas tran vdout0_63ck620 FIND v(dout0_63) AT=315.025n

.meas tran vdout0_64ck620 FIND v(dout0_64) AT=315.025n

.meas tran vdout0_65ck620 FIND v(dout0_65) AT=315.025n

.meas tran vdout0_66ck620 FIND v(dout0_66) AT=315.025n

.meas tran vdout0_67ck620 FIND v(dout0_67) AT=315.025n

.meas tran vdout0_68ck620 FIND v(dout0_68) AT=315.025n

.meas tran vdout0_69ck620 FIND v(dout0_69) AT=315.025n

.meas tran vdout0_70ck620 FIND v(dout0_70) AT=315.025n

.meas tran vdout0_71ck620 FIND v(dout0_71) AT=315.025n

.meas tran vdout0_72ck620 FIND v(dout0_72) AT=315.025n

.meas tran vdout0_73ck620 FIND v(dout0_73) AT=315.025n

.meas tran vdout0_74ck620 FIND v(dout0_74) AT=315.025n

.meas tran vdout0_75ck620 FIND v(dout0_75) AT=315.025n

.meas tran vdout0_76ck620 FIND v(dout0_76) AT=315.025n

.meas tran vdout0_77ck620 FIND v(dout0_77) AT=315.025n

.meas tran vdout0_78ck620 FIND v(dout0_78) AT=315.025n

.meas tran vdout0_79ck620 FIND v(dout0_79) AT=315.025n

.meas tran vdout0_80ck620 FIND v(dout0_80) AT=315.025n

.meas tran vdout0_81ck620 FIND v(dout0_81) AT=315.025n

.meas tran vdout0_82ck620 FIND v(dout0_82) AT=315.025n

.meas tran vdout0_83ck620 FIND v(dout0_83) AT=315.025n

.meas tran vdout0_84ck620 FIND v(dout0_84) AT=315.025n

.meas tran vdout0_85ck620 FIND v(dout0_85) AT=315.025n

.meas tran vdout0_86ck620 FIND v(dout0_86) AT=315.025n

.meas tran vdout0_87ck620 FIND v(dout0_87) AT=315.025n

.meas tran vdout0_88ck620 FIND v(dout0_88) AT=315.025n

.meas tran vdout0_89ck620 FIND v(dout0_89) AT=315.025n

.meas tran vdout0_90ck620 FIND v(dout0_90) AT=315.025n

.meas tran vdout0_91ck620 FIND v(dout0_91) AT=315.025n

.meas tran vdout0_92ck620 FIND v(dout0_92) AT=315.025n

.meas tran vdout0_93ck620 FIND v(dout0_93) AT=315.025n

.meas tran vdout0_94ck620 FIND v(dout0_94) AT=315.025n

.meas tran vdout0_95ck620 FIND v(dout0_95) AT=315.025n

.meas tran vdout0_96ck620 FIND v(dout0_96) AT=315.025n

.meas tran vdout0_97ck620 FIND v(dout0_97) AT=315.025n

.meas tran vdout0_98ck620 FIND v(dout0_98) AT=315.025n

.meas tran vdout0_99ck620 FIND v(dout0_99) AT=315.025n

.meas tran vdout0_100ck620 FIND v(dout0_100) AT=315.025n

.meas tran vdout0_101ck620 FIND v(dout0_101) AT=315.025n

.meas tran vdout0_102ck620 FIND v(dout0_102) AT=315.025n

.meas tran vdout0_103ck620 FIND v(dout0_103) AT=315.025n

.meas tran vdout0_104ck620 FIND v(dout0_104) AT=315.025n

.meas tran vdout0_105ck620 FIND v(dout0_105) AT=315.025n

.meas tran vdout0_106ck620 FIND v(dout0_106) AT=315.025n

.meas tran vdout0_107ck620 FIND v(dout0_107) AT=315.025n

.meas tran vdout0_108ck620 FIND v(dout0_108) AT=315.025n

.meas tran vdout0_109ck620 FIND v(dout0_109) AT=315.025n

.meas tran vdout0_110ck620 FIND v(dout0_110) AT=315.025n

.meas tran vdout0_111ck620 FIND v(dout0_111) AT=315.025n

.meas tran vdout0_112ck620 FIND v(dout0_112) AT=315.025n

.meas tran vdout0_113ck620 FIND v(dout0_113) AT=315.025n

.meas tran vdout0_114ck620 FIND v(dout0_114) AT=315.025n

.meas tran vdout0_115ck620 FIND v(dout0_115) AT=315.025n

.meas tran vdout0_116ck620 FIND v(dout0_116) AT=315.025n

.meas tran vdout0_117ck620 FIND v(dout0_117) AT=315.025n

.meas tran vdout0_118ck620 FIND v(dout0_118) AT=315.025n

.meas tran vdout0_119ck620 FIND v(dout0_119) AT=315.025n

.meas tran vdout0_120ck620 FIND v(dout0_120) AT=315.025n

.meas tran vdout0_121ck620 FIND v(dout0_121) AT=315.025n

.meas tran vdout0_122ck620 FIND v(dout0_122) AT=315.025n

.meas tran vdout0_123ck620 FIND v(dout0_123) AT=315.025n

.meas tran vdout0_124ck620 FIND v(dout0_124) AT=315.025n

.meas tran vdout0_125ck620 FIND v(dout0_125) AT=315.025n

.meas tran vdout0_126ck620 FIND v(dout0_126) AT=315.025n

.meas tran vdout0_127ck620 FIND v(dout0_127) AT=315.025n

.meas tran vdout0_128ck620 FIND v(dout0_128) AT=315.025n

.meas tran vdout0_129ck620 FIND v(dout0_129) AT=315.025n

.meas tran vdout0_130ck620 FIND v(dout0_130) AT=315.025n

.meas tran vdout0_131ck620 FIND v(dout0_131) AT=315.025n

.meas tran vdout0_132ck620 FIND v(dout0_132) AT=315.025n

.meas tran vdout0_133ck620 FIND v(dout0_133) AT=315.025n

.meas tran vdout0_134ck620 FIND v(dout0_134) AT=315.025n

.meas tran vdout0_135ck620 FIND v(dout0_135) AT=315.025n

.meas tran vdout0_136ck620 FIND v(dout0_136) AT=315.025n

.meas tran vdout0_137ck620 FIND v(dout0_137) AT=315.025n

.meas tran vdout0_138ck620 FIND v(dout0_138) AT=315.025n

.meas tran vdout0_139ck620 FIND v(dout0_139) AT=315.025n

.meas tran vdout0_140ck620 FIND v(dout0_140) AT=315.025n

.meas tran vdout0_141ck620 FIND v(dout0_141) AT=315.025n

.meas tran vdout0_142ck620 FIND v(dout0_142) AT=315.025n

.meas tran vdout0_143ck620 FIND v(dout0_143) AT=315.025n

.meas tran vdout0_144ck620 FIND v(dout0_144) AT=315.025n

.meas tran vdout0_145ck620 FIND v(dout0_145) AT=315.025n

.meas tran vdout0_146ck620 FIND v(dout0_146) AT=315.025n

.meas tran vdout0_147ck620 FIND v(dout0_147) AT=315.025n

.meas tran vdout0_148ck620 FIND v(dout0_148) AT=315.025n

.meas tran vdout0_149ck620 FIND v(dout0_149) AT=315.025n

.meas tran vdout0_150ck620 FIND v(dout0_150) AT=315.025n

.meas tran vdout0_151ck620 FIND v(dout0_151) AT=315.025n

.meas tran vdout0_152ck620 FIND v(dout0_152) AT=315.025n

.meas tran vdout0_153ck620 FIND v(dout0_153) AT=315.025n

.meas tran vdout0_154ck620 FIND v(dout0_154) AT=315.025n

.meas tran vdout0_155ck620 FIND v(dout0_155) AT=315.025n

.meas tran vdout0_156ck620 FIND v(dout0_156) AT=315.025n

.meas tran vdout0_157ck620 FIND v(dout0_157) AT=315.025n

.meas tran vdout0_158ck620 FIND v(dout0_158) AT=315.025n

.meas tran vdout0_159ck620 FIND v(dout0_159) AT=315.025n

.meas tran vdout0_160ck620 FIND v(dout0_160) AT=315.025n

.meas tran vdout0_161ck620 FIND v(dout0_161) AT=315.025n

.meas tran vdout0_162ck620 FIND v(dout0_162) AT=315.025n

.meas tran vdout0_163ck620 FIND v(dout0_163) AT=315.025n

.meas tran vdout0_164ck620 FIND v(dout0_164) AT=315.025n

.meas tran vdout0_165ck620 FIND v(dout0_165) AT=315.025n

.meas tran vdout0_166ck620 FIND v(dout0_166) AT=315.025n

.meas tran vdout0_167ck620 FIND v(dout0_167) AT=315.025n

.meas tran vdout0_168ck620 FIND v(dout0_168) AT=315.025n

.meas tran vdout0_169ck620 FIND v(dout0_169) AT=315.025n

.meas tran vdout0_170ck620 FIND v(dout0_170) AT=315.025n

.meas tran vdout0_171ck620 FIND v(dout0_171) AT=315.025n

.meas tran vdout0_172ck620 FIND v(dout0_172) AT=315.025n

.meas tran vdout0_173ck620 FIND v(dout0_173) AT=315.025n

.meas tran vdout0_174ck620 FIND v(dout0_174) AT=315.025n

.meas tran vdout0_175ck620 FIND v(dout0_175) AT=315.025n

.meas tran vdout0_176ck620 FIND v(dout0_176) AT=315.025n

.meas tran vdout0_177ck620 FIND v(dout0_177) AT=315.025n

.meas tran vdout0_178ck620 FIND v(dout0_178) AT=315.025n

.meas tran vdout0_179ck620 FIND v(dout0_179) AT=315.025n

.meas tran vdout0_180ck620 FIND v(dout0_180) AT=315.025n

.meas tran vdout0_181ck620 FIND v(dout0_181) AT=315.025n

.meas tran vdout0_182ck620 FIND v(dout0_182) AT=315.025n

.meas tran vdout0_183ck620 FIND v(dout0_183) AT=315.025n

.meas tran vdout0_184ck620 FIND v(dout0_184) AT=315.025n

.meas tran vdout0_185ck620 FIND v(dout0_185) AT=315.025n

.meas tran vdout0_186ck620 FIND v(dout0_186) AT=315.025n

.meas tran vdout0_187ck620 FIND v(dout0_187) AT=315.025n

.meas tran vdout0_188ck620 FIND v(dout0_188) AT=315.025n

.meas tran vdout0_189ck620 FIND v(dout0_189) AT=315.025n

.meas tran vdout0_190ck620 FIND v(dout0_190) AT=315.025n

.meas tran vdout0_191ck620 FIND v(dout0_191) AT=315.025n

.meas tran vdout0_192ck620 FIND v(dout0_192) AT=315.025n

.meas tran vdout0_193ck620 FIND v(dout0_193) AT=315.025n

.meas tran vdout0_194ck620 FIND v(dout0_194) AT=315.025n

.meas tran vdout0_195ck620 FIND v(dout0_195) AT=315.025n

.meas tran vdout0_196ck620 FIND v(dout0_196) AT=315.025n

.meas tran vdout0_197ck620 FIND v(dout0_197) AT=315.025n

.meas tran vdout0_198ck620 FIND v(dout0_198) AT=315.025n

.meas tran vdout0_199ck620 FIND v(dout0_199) AT=315.025n

.meas tran vdout0_200ck620 FIND v(dout0_200) AT=315.025n

.meas tran vdout0_201ck620 FIND v(dout0_201) AT=315.025n

.meas tran vdout0_202ck620 FIND v(dout0_202) AT=315.025n

.meas tran vdout0_203ck620 FIND v(dout0_203) AT=315.025n

.meas tran vdout0_204ck620 FIND v(dout0_204) AT=315.025n

.meas tran vdout0_205ck620 FIND v(dout0_205) AT=315.025n

.meas tran vdout0_206ck620 FIND v(dout0_206) AT=315.025n

.meas tran vdout0_207ck620 FIND v(dout0_207) AT=315.025n

.meas tran vdout0_208ck620 FIND v(dout0_208) AT=315.025n

.meas tran vdout0_209ck620 FIND v(dout0_209) AT=315.025n

.meas tran vdout0_210ck620 FIND v(dout0_210) AT=315.025n

.meas tran vdout0_211ck620 FIND v(dout0_211) AT=315.025n

.meas tran vdout0_212ck620 FIND v(dout0_212) AT=315.025n

.meas tran vdout0_213ck620 FIND v(dout0_213) AT=315.025n

.meas tran vdout0_214ck620 FIND v(dout0_214) AT=315.025n

.meas tran vdout0_215ck620 FIND v(dout0_215) AT=315.025n

.meas tran vdout0_216ck620 FIND v(dout0_216) AT=315.025n

.meas tran vdout0_217ck620 FIND v(dout0_217) AT=315.025n

.meas tran vdout0_218ck620 FIND v(dout0_218) AT=315.025n

.meas tran vdout0_219ck620 FIND v(dout0_219) AT=315.025n

.meas tran vdout0_220ck620 FIND v(dout0_220) AT=315.025n

.meas tran vdout0_221ck620 FIND v(dout0_221) AT=315.025n

.meas tran vdout0_222ck620 FIND v(dout0_222) AT=315.025n

.meas tran vdout0_223ck620 FIND v(dout0_223) AT=315.025n

.meas tran vdout0_224ck620 FIND v(dout0_224) AT=315.025n

.meas tran vdout0_225ck620 FIND v(dout0_225) AT=315.025n

.meas tran vdout0_226ck620 FIND v(dout0_226) AT=315.025n

.meas tran vdout0_227ck620 FIND v(dout0_227) AT=315.025n

.meas tran vdout0_228ck620 FIND v(dout0_228) AT=315.025n

.meas tran vdout0_229ck620 FIND v(dout0_229) AT=315.025n

.meas tran vdout0_230ck620 FIND v(dout0_230) AT=315.025n

.meas tran vdout0_231ck620 FIND v(dout0_231) AT=315.025n

.meas tran vdout0_232ck620 FIND v(dout0_232) AT=315.025n

.meas tran vdout0_233ck620 FIND v(dout0_233) AT=315.025n

.meas tran vdout0_234ck620 FIND v(dout0_234) AT=315.025n

.meas tran vdout0_235ck620 FIND v(dout0_235) AT=315.025n

.meas tran vdout0_236ck620 FIND v(dout0_236) AT=315.025n

.meas tran vdout0_237ck620 FIND v(dout0_237) AT=315.025n

.meas tran vdout0_238ck620 FIND v(dout0_238) AT=315.025n

.meas tran vdout0_239ck620 FIND v(dout0_239) AT=315.025n

.meas tran vdout0_240ck620 FIND v(dout0_240) AT=315.025n

.meas tran vdout0_241ck620 FIND v(dout0_241) AT=315.025n

.meas tran vdout0_242ck620 FIND v(dout0_242) AT=315.025n

.meas tran vdout0_243ck620 FIND v(dout0_243) AT=315.025n

.meas tran vdout0_244ck620 FIND v(dout0_244) AT=315.025n

.meas tran vdout0_245ck620 FIND v(dout0_245) AT=315.025n

.meas tran vdout0_246ck620 FIND v(dout0_246) AT=315.025n

.meas tran vdout0_247ck620 FIND v(dout0_247) AT=315.025n

.meas tran vdout0_248ck620 FIND v(dout0_248) AT=315.025n

.meas tran vdout0_249ck620 FIND v(dout0_249) AT=315.025n

.meas tran vdout0_250ck620 FIND v(dout0_250) AT=315.025n

.meas tran vdout0_251ck620 FIND v(dout0_251) AT=315.025n

.meas tran vdout0_252ck620 FIND v(dout0_252) AT=315.025n

.meas tran vdout0_253ck620 FIND v(dout0_253) AT=315.025n

.meas tran vdout0_254ck620 FIND v(dout0_254) AT=315.025n

.meas tran vdout0_255ck620 FIND v(dout0_255) AT=315.025n

.meas tran vdout0_0ck630 FIND v(dout0_0) AT=320.025n

.meas tran vdout0_1ck630 FIND v(dout0_1) AT=320.025n

.meas tran vdout0_2ck630 FIND v(dout0_2) AT=320.025n

.meas tran vdout0_3ck630 FIND v(dout0_3) AT=320.025n

.meas tran vdout0_4ck630 FIND v(dout0_4) AT=320.025n

.meas tran vdout0_5ck630 FIND v(dout0_5) AT=320.025n

.meas tran vdout0_6ck630 FIND v(dout0_6) AT=320.025n

.meas tran vdout0_7ck630 FIND v(dout0_7) AT=320.025n

.meas tran vdout0_8ck630 FIND v(dout0_8) AT=320.025n

.meas tran vdout0_9ck630 FIND v(dout0_9) AT=320.025n

.meas tran vdout0_10ck630 FIND v(dout0_10) AT=320.025n

.meas tran vdout0_11ck630 FIND v(dout0_11) AT=320.025n

.meas tran vdout0_12ck630 FIND v(dout0_12) AT=320.025n

.meas tran vdout0_13ck630 FIND v(dout0_13) AT=320.025n

.meas tran vdout0_14ck630 FIND v(dout0_14) AT=320.025n

.meas tran vdout0_15ck630 FIND v(dout0_15) AT=320.025n

.meas tran vdout0_16ck630 FIND v(dout0_16) AT=320.025n

.meas tran vdout0_17ck630 FIND v(dout0_17) AT=320.025n

.meas tran vdout0_18ck630 FIND v(dout0_18) AT=320.025n

.meas tran vdout0_19ck630 FIND v(dout0_19) AT=320.025n

.meas tran vdout0_20ck630 FIND v(dout0_20) AT=320.025n

.meas tran vdout0_21ck630 FIND v(dout0_21) AT=320.025n

.meas tran vdout0_22ck630 FIND v(dout0_22) AT=320.025n

.meas tran vdout0_23ck630 FIND v(dout0_23) AT=320.025n

.meas tran vdout0_24ck630 FIND v(dout0_24) AT=320.025n

.meas tran vdout0_25ck630 FIND v(dout0_25) AT=320.025n

.meas tran vdout0_26ck630 FIND v(dout0_26) AT=320.025n

.meas tran vdout0_27ck630 FIND v(dout0_27) AT=320.025n

.meas tran vdout0_28ck630 FIND v(dout0_28) AT=320.025n

.meas tran vdout0_29ck630 FIND v(dout0_29) AT=320.025n

.meas tran vdout0_30ck630 FIND v(dout0_30) AT=320.025n

.meas tran vdout0_31ck630 FIND v(dout0_31) AT=320.025n

.meas tran vdout0_32ck630 FIND v(dout0_32) AT=320.025n

.meas tran vdout0_33ck630 FIND v(dout0_33) AT=320.025n

.meas tran vdout0_34ck630 FIND v(dout0_34) AT=320.025n

.meas tran vdout0_35ck630 FIND v(dout0_35) AT=320.025n

.meas tran vdout0_36ck630 FIND v(dout0_36) AT=320.025n

.meas tran vdout0_37ck630 FIND v(dout0_37) AT=320.025n

.meas tran vdout0_38ck630 FIND v(dout0_38) AT=320.025n

.meas tran vdout0_39ck630 FIND v(dout0_39) AT=320.025n

.meas tran vdout0_40ck630 FIND v(dout0_40) AT=320.025n

.meas tran vdout0_41ck630 FIND v(dout0_41) AT=320.025n

.meas tran vdout0_42ck630 FIND v(dout0_42) AT=320.025n

.meas tran vdout0_43ck630 FIND v(dout0_43) AT=320.025n

.meas tran vdout0_44ck630 FIND v(dout0_44) AT=320.025n

.meas tran vdout0_45ck630 FIND v(dout0_45) AT=320.025n

.meas tran vdout0_46ck630 FIND v(dout0_46) AT=320.025n

.meas tran vdout0_47ck630 FIND v(dout0_47) AT=320.025n

.meas tran vdout0_48ck630 FIND v(dout0_48) AT=320.025n

.meas tran vdout0_49ck630 FIND v(dout0_49) AT=320.025n

.meas tran vdout0_50ck630 FIND v(dout0_50) AT=320.025n

.meas tran vdout0_51ck630 FIND v(dout0_51) AT=320.025n

.meas tran vdout0_52ck630 FIND v(dout0_52) AT=320.025n

.meas tran vdout0_53ck630 FIND v(dout0_53) AT=320.025n

.meas tran vdout0_54ck630 FIND v(dout0_54) AT=320.025n

.meas tran vdout0_55ck630 FIND v(dout0_55) AT=320.025n

.meas tran vdout0_56ck630 FIND v(dout0_56) AT=320.025n

.meas tran vdout0_57ck630 FIND v(dout0_57) AT=320.025n

.meas tran vdout0_58ck630 FIND v(dout0_58) AT=320.025n

.meas tran vdout0_59ck630 FIND v(dout0_59) AT=320.025n

.meas tran vdout0_60ck630 FIND v(dout0_60) AT=320.025n

.meas tran vdout0_61ck630 FIND v(dout0_61) AT=320.025n

.meas tran vdout0_62ck630 FIND v(dout0_62) AT=320.025n

.meas tran vdout0_63ck630 FIND v(dout0_63) AT=320.025n

.meas tran vdout0_64ck630 FIND v(dout0_64) AT=320.025n

.meas tran vdout0_65ck630 FIND v(dout0_65) AT=320.025n

.meas tran vdout0_66ck630 FIND v(dout0_66) AT=320.025n

.meas tran vdout0_67ck630 FIND v(dout0_67) AT=320.025n

.meas tran vdout0_68ck630 FIND v(dout0_68) AT=320.025n

.meas tran vdout0_69ck630 FIND v(dout0_69) AT=320.025n

.meas tran vdout0_70ck630 FIND v(dout0_70) AT=320.025n

.meas tran vdout0_71ck630 FIND v(dout0_71) AT=320.025n

.meas tran vdout0_72ck630 FIND v(dout0_72) AT=320.025n

.meas tran vdout0_73ck630 FIND v(dout0_73) AT=320.025n

.meas tran vdout0_74ck630 FIND v(dout0_74) AT=320.025n

.meas tran vdout0_75ck630 FIND v(dout0_75) AT=320.025n

.meas tran vdout0_76ck630 FIND v(dout0_76) AT=320.025n

.meas tran vdout0_77ck630 FIND v(dout0_77) AT=320.025n

.meas tran vdout0_78ck630 FIND v(dout0_78) AT=320.025n

.meas tran vdout0_79ck630 FIND v(dout0_79) AT=320.025n

.meas tran vdout0_80ck630 FIND v(dout0_80) AT=320.025n

.meas tran vdout0_81ck630 FIND v(dout0_81) AT=320.025n

.meas tran vdout0_82ck630 FIND v(dout0_82) AT=320.025n

.meas tran vdout0_83ck630 FIND v(dout0_83) AT=320.025n

.meas tran vdout0_84ck630 FIND v(dout0_84) AT=320.025n

.meas tran vdout0_85ck630 FIND v(dout0_85) AT=320.025n

.meas tran vdout0_86ck630 FIND v(dout0_86) AT=320.025n

.meas tran vdout0_87ck630 FIND v(dout0_87) AT=320.025n

.meas tran vdout0_88ck630 FIND v(dout0_88) AT=320.025n

.meas tran vdout0_89ck630 FIND v(dout0_89) AT=320.025n

.meas tran vdout0_90ck630 FIND v(dout0_90) AT=320.025n

.meas tran vdout0_91ck630 FIND v(dout0_91) AT=320.025n

.meas tran vdout0_92ck630 FIND v(dout0_92) AT=320.025n

.meas tran vdout0_93ck630 FIND v(dout0_93) AT=320.025n

.meas tran vdout0_94ck630 FIND v(dout0_94) AT=320.025n

.meas tran vdout0_95ck630 FIND v(dout0_95) AT=320.025n

.meas tran vdout0_96ck630 FIND v(dout0_96) AT=320.025n

.meas tran vdout0_97ck630 FIND v(dout0_97) AT=320.025n

.meas tran vdout0_98ck630 FIND v(dout0_98) AT=320.025n

.meas tran vdout0_99ck630 FIND v(dout0_99) AT=320.025n

.meas tran vdout0_100ck630 FIND v(dout0_100) AT=320.025n

.meas tran vdout0_101ck630 FIND v(dout0_101) AT=320.025n

.meas tran vdout0_102ck630 FIND v(dout0_102) AT=320.025n

.meas tran vdout0_103ck630 FIND v(dout0_103) AT=320.025n

.meas tran vdout0_104ck630 FIND v(dout0_104) AT=320.025n

.meas tran vdout0_105ck630 FIND v(dout0_105) AT=320.025n

.meas tran vdout0_106ck630 FIND v(dout0_106) AT=320.025n

.meas tran vdout0_107ck630 FIND v(dout0_107) AT=320.025n

.meas tran vdout0_108ck630 FIND v(dout0_108) AT=320.025n

.meas tran vdout0_109ck630 FIND v(dout0_109) AT=320.025n

.meas tran vdout0_110ck630 FIND v(dout0_110) AT=320.025n

.meas tran vdout0_111ck630 FIND v(dout0_111) AT=320.025n

.meas tran vdout0_112ck630 FIND v(dout0_112) AT=320.025n

.meas tran vdout0_113ck630 FIND v(dout0_113) AT=320.025n

.meas tran vdout0_114ck630 FIND v(dout0_114) AT=320.025n

.meas tran vdout0_115ck630 FIND v(dout0_115) AT=320.025n

.meas tran vdout0_116ck630 FIND v(dout0_116) AT=320.025n

.meas tran vdout0_117ck630 FIND v(dout0_117) AT=320.025n

.meas tran vdout0_118ck630 FIND v(dout0_118) AT=320.025n

.meas tran vdout0_119ck630 FIND v(dout0_119) AT=320.025n

.meas tran vdout0_120ck630 FIND v(dout0_120) AT=320.025n

.meas tran vdout0_121ck630 FIND v(dout0_121) AT=320.025n

.meas tran vdout0_122ck630 FIND v(dout0_122) AT=320.025n

.meas tran vdout0_123ck630 FIND v(dout0_123) AT=320.025n

.meas tran vdout0_124ck630 FIND v(dout0_124) AT=320.025n

.meas tran vdout0_125ck630 FIND v(dout0_125) AT=320.025n

.meas tran vdout0_126ck630 FIND v(dout0_126) AT=320.025n

.meas tran vdout0_127ck630 FIND v(dout0_127) AT=320.025n

.meas tran vdout0_128ck630 FIND v(dout0_128) AT=320.025n

.meas tran vdout0_129ck630 FIND v(dout0_129) AT=320.025n

.meas tran vdout0_130ck630 FIND v(dout0_130) AT=320.025n

.meas tran vdout0_131ck630 FIND v(dout0_131) AT=320.025n

.meas tran vdout0_132ck630 FIND v(dout0_132) AT=320.025n

.meas tran vdout0_133ck630 FIND v(dout0_133) AT=320.025n

.meas tran vdout0_134ck630 FIND v(dout0_134) AT=320.025n

.meas tran vdout0_135ck630 FIND v(dout0_135) AT=320.025n

.meas tran vdout0_136ck630 FIND v(dout0_136) AT=320.025n

.meas tran vdout0_137ck630 FIND v(dout0_137) AT=320.025n

.meas tran vdout0_138ck630 FIND v(dout0_138) AT=320.025n

.meas tran vdout0_139ck630 FIND v(dout0_139) AT=320.025n

.meas tran vdout0_140ck630 FIND v(dout0_140) AT=320.025n

.meas tran vdout0_141ck630 FIND v(dout0_141) AT=320.025n

.meas tran vdout0_142ck630 FIND v(dout0_142) AT=320.025n

.meas tran vdout0_143ck630 FIND v(dout0_143) AT=320.025n

.meas tran vdout0_144ck630 FIND v(dout0_144) AT=320.025n

.meas tran vdout0_145ck630 FIND v(dout0_145) AT=320.025n

.meas tran vdout0_146ck630 FIND v(dout0_146) AT=320.025n

.meas tran vdout0_147ck630 FIND v(dout0_147) AT=320.025n

.meas tran vdout0_148ck630 FIND v(dout0_148) AT=320.025n

.meas tran vdout0_149ck630 FIND v(dout0_149) AT=320.025n

.meas tran vdout0_150ck630 FIND v(dout0_150) AT=320.025n

.meas tran vdout0_151ck630 FIND v(dout0_151) AT=320.025n

.meas tran vdout0_152ck630 FIND v(dout0_152) AT=320.025n

.meas tran vdout0_153ck630 FIND v(dout0_153) AT=320.025n

.meas tran vdout0_154ck630 FIND v(dout0_154) AT=320.025n

.meas tran vdout0_155ck630 FIND v(dout0_155) AT=320.025n

.meas tran vdout0_156ck630 FIND v(dout0_156) AT=320.025n

.meas tran vdout0_157ck630 FIND v(dout0_157) AT=320.025n

.meas tran vdout0_158ck630 FIND v(dout0_158) AT=320.025n

.meas tran vdout0_159ck630 FIND v(dout0_159) AT=320.025n

.meas tran vdout0_160ck630 FIND v(dout0_160) AT=320.025n

.meas tran vdout0_161ck630 FIND v(dout0_161) AT=320.025n

.meas tran vdout0_162ck630 FIND v(dout0_162) AT=320.025n

.meas tran vdout0_163ck630 FIND v(dout0_163) AT=320.025n

.meas tran vdout0_164ck630 FIND v(dout0_164) AT=320.025n

.meas tran vdout0_165ck630 FIND v(dout0_165) AT=320.025n

.meas tran vdout0_166ck630 FIND v(dout0_166) AT=320.025n

.meas tran vdout0_167ck630 FIND v(dout0_167) AT=320.025n

.meas tran vdout0_168ck630 FIND v(dout0_168) AT=320.025n

.meas tran vdout0_169ck630 FIND v(dout0_169) AT=320.025n

.meas tran vdout0_170ck630 FIND v(dout0_170) AT=320.025n

.meas tran vdout0_171ck630 FIND v(dout0_171) AT=320.025n

.meas tran vdout0_172ck630 FIND v(dout0_172) AT=320.025n

.meas tran vdout0_173ck630 FIND v(dout0_173) AT=320.025n

.meas tran vdout0_174ck630 FIND v(dout0_174) AT=320.025n

.meas tran vdout0_175ck630 FIND v(dout0_175) AT=320.025n

.meas tran vdout0_176ck630 FIND v(dout0_176) AT=320.025n

.meas tran vdout0_177ck630 FIND v(dout0_177) AT=320.025n

.meas tran vdout0_178ck630 FIND v(dout0_178) AT=320.025n

.meas tran vdout0_179ck630 FIND v(dout0_179) AT=320.025n

.meas tran vdout0_180ck630 FIND v(dout0_180) AT=320.025n

.meas tran vdout0_181ck630 FIND v(dout0_181) AT=320.025n

.meas tran vdout0_182ck630 FIND v(dout0_182) AT=320.025n

.meas tran vdout0_183ck630 FIND v(dout0_183) AT=320.025n

.meas tran vdout0_184ck630 FIND v(dout0_184) AT=320.025n

.meas tran vdout0_185ck630 FIND v(dout0_185) AT=320.025n

.meas tran vdout0_186ck630 FIND v(dout0_186) AT=320.025n

.meas tran vdout0_187ck630 FIND v(dout0_187) AT=320.025n

.meas tran vdout0_188ck630 FIND v(dout0_188) AT=320.025n

.meas tran vdout0_189ck630 FIND v(dout0_189) AT=320.025n

.meas tran vdout0_190ck630 FIND v(dout0_190) AT=320.025n

.meas tran vdout0_191ck630 FIND v(dout0_191) AT=320.025n

.meas tran vdout0_192ck630 FIND v(dout0_192) AT=320.025n

.meas tran vdout0_193ck630 FIND v(dout0_193) AT=320.025n

.meas tran vdout0_194ck630 FIND v(dout0_194) AT=320.025n

.meas tran vdout0_195ck630 FIND v(dout0_195) AT=320.025n

.meas tran vdout0_196ck630 FIND v(dout0_196) AT=320.025n

.meas tran vdout0_197ck630 FIND v(dout0_197) AT=320.025n

.meas tran vdout0_198ck630 FIND v(dout0_198) AT=320.025n

.meas tran vdout0_199ck630 FIND v(dout0_199) AT=320.025n

.meas tran vdout0_200ck630 FIND v(dout0_200) AT=320.025n

.meas tran vdout0_201ck630 FIND v(dout0_201) AT=320.025n

.meas tran vdout0_202ck630 FIND v(dout0_202) AT=320.025n

.meas tran vdout0_203ck630 FIND v(dout0_203) AT=320.025n

.meas tran vdout0_204ck630 FIND v(dout0_204) AT=320.025n

.meas tran vdout0_205ck630 FIND v(dout0_205) AT=320.025n

.meas tran vdout0_206ck630 FIND v(dout0_206) AT=320.025n

.meas tran vdout0_207ck630 FIND v(dout0_207) AT=320.025n

.meas tran vdout0_208ck630 FIND v(dout0_208) AT=320.025n

.meas tran vdout0_209ck630 FIND v(dout0_209) AT=320.025n

.meas tran vdout0_210ck630 FIND v(dout0_210) AT=320.025n

.meas tran vdout0_211ck630 FIND v(dout0_211) AT=320.025n

.meas tran vdout0_212ck630 FIND v(dout0_212) AT=320.025n

.meas tran vdout0_213ck630 FIND v(dout0_213) AT=320.025n

.meas tran vdout0_214ck630 FIND v(dout0_214) AT=320.025n

.meas tran vdout0_215ck630 FIND v(dout0_215) AT=320.025n

.meas tran vdout0_216ck630 FIND v(dout0_216) AT=320.025n

.meas tran vdout0_217ck630 FIND v(dout0_217) AT=320.025n

.meas tran vdout0_218ck630 FIND v(dout0_218) AT=320.025n

.meas tran vdout0_219ck630 FIND v(dout0_219) AT=320.025n

.meas tran vdout0_220ck630 FIND v(dout0_220) AT=320.025n

.meas tran vdout0_221ck630 FIND v(dout0_221) AT=320.025n

.meas tran vdout0_222ck630 FIND v(dout0_222) AT=320.025n

.meas tran vdout0_223ck630 FIND v(dout0_223) AT=320.025n

.meas tran vdout0_224ck630 FIND v(dout0_224) AT=320.025n

.meas tran vdout0_225ck630 FIND v(dout0_225) AT=320.025n

.meas tran vdout0_226ck630 FIND v(dout0_226) AT=320.025n

.meas tran vdout0_227ck630 FIND v(dout0_227) AT=320.025n

.meas tran vdout0_228ck630 FIND v(dout0_228) AT=320.025n

.meas tran vdout0_229ck630 FIND v(dout0_229) AT=320.025n

.meas tran vdout0_230ck630 FIND v(dout0_230) AT=320.025n

.meas tran vdout0_231ck630 FIND v(dout0_231) AT=320.025n

.meas tran vdout0_232ck630 FIND v(dout0_232) AT=320.025n

.meas tran vdout0_233ck630 FIND v(dout0_233) AT=320.025n

.meas tran vdout0_234ck630 FIND v(dout0_234) AT=320.025n

.meas tran vdout0_235ck630 FIND v(dout0_235) AT=320.025n

.meas tran vdout0_236ck630 FIND v(dout0_236) AT=320.025n

.meas tran vdout0_237ck630 FIND v(dout0_237) AT=320.025n

.meas tran vdout0_238ck630 FIND v(dout0_238) AT=320.025n

.meas tran vdout0_239ck630 FIND v(dout0_239) AT=320.025n

.meas tran vdout0_240ck630 FIND v(dout0_240) AT=320.025n

.meas tran vdout0_241ck630 FIND v(dout0_241) AT=320.025n

.meas tran vdout0_242ck630 FIND v(dout0_242) AT=320.025n

.meas tran vdout0_243ck630 FIND v(dout0_243) AT=320.025n

.meas tran vdout0_244ck630 FIND v(dout0_244) AT=320.025n

.meas tran vdout0_245ck630 FIND v(dout0_245) AT=320.025n

.meas tran vdout0_246ck630 FIND v(dout0_246) AT=320.025n

.meas tran vdout0_247ck630 FIND v(dout0_247) AT=320.025n

.meas tran vdout0_248ck630 FIND v(dout0_248) AT=320.025n

.meas tran vdout0_249ck630 FIND v(dout0_249) AT=320.025n

.meas tran vdout0_250ck630 FIND v(dout0_250) AT=320.025n

.meas tran vdout0_251ck630 FIND v(dout0_251) AT=320.025n

.meas tran vdout0_252ck630 FIND v(dout0_252) AT=320.025n

.meas tran vdout0_253ck630 FIND v(dout0_253) AT=320.025n

.meas tran vdout0_254ck630 FIND v(dout0_254) AT=320.025n

.meas tran vdout0_255ck630 FIND v(dout0_255) AT=320.025n

.meas tran vdout0_0ck720 FIND v(dout0_0) AT=365.025n

.meas tran vdout0_1ck720 FIND v(dout0_1) AT=365.025n

.meas tran vdout0_2ck720 FIND v(dout0_2) AT=365.025n

.meas tran vdout0_3ck720 FIND v(dout0_3) AT=365.025n

.meas tran vdout0_4ck720 FIND v(dout0_4) AT=365.025n

.meas tran vdout0_5ck720 FIND v(dout0_5) AT=365.025n

.meas tran vdout0_6ck720 FIND v(dout0_6) AT=365.025n

.meas tran vdout0_7ck720 FIND v(dout0_7) AT=365.025n

.meas tran vdout0_8ck720 FIND v(dout0_8) AT=365.025n

.meas tran vdout0_9ck720 FIND v(dout0_9) AT=365.025n

.meas tran vdout0_10ck720 FIND v(dout0_10) AT=365.025n

.meas tran vdout0_11ck720 FIND v(dout0_11) AT=365.025n

.meas tran vdout0_12ck720 FIND v(dout0_12) AT=365.025n

.meas tran vdout0_13ck720 FIND v(dout0_13) AT=365.025n

.meas tran vdout0_14ck720 FIND v(dout0_14) AT=365.025n

.meas tran vdout0_15ck720 FIND v(dout0_15) AT=365.025n

.meas tran vdout0_16ck720 FIND v(dout0_16) AT=365.025n

.meas tran vdout0_17ck720 FIND v(dout0_17) AT=365.025n

.meas tran vdout0_18ck720 FIND v(dout0_18) AT=365.025n

.meas tran vdout0_19ck720 FIND v(dout0_19) AT=365.025n

.meas tran vdout0_20ck720 FIND v(dout0_20) AT=365.025n

.meas tran vdout0_21ck720 FIND v(dout0_21) AT=365.025n

.meas tran vdout0_22ck720 FIND v(dout0_22) AT=365.025n

.meas tran vdout0_23ck720 FIND v(dout0_23) AT=365.025n

.meas tran vdout0_24ck720 FIND v(dout0_24) AT=365.025n

.meas tran vdout0_25ck720 FIND v(dout0_25) AT=365.025n

.meas tran vdout0_26ck720 FIND v(dout0_26) AT=365.025n

.meas tran vdout0_27ck720 FIND v(dout0_27) AT=365.025n

.meas tran vdout0_28ck720 FIND v(dout0_28) AT=365.025n

.meas tran vdout0_29ck720 FIND v(dout0_29) AT=365.025n

.meas tran vdout0_30ck720 FIND v(dout0_30) AT=365.025n

.meas tran vdout0_31ck720 FIND v(dout0_31) AT=365.025n

.meas tran vdout0_32ck720 FIND v(dout0_32) AT=365.025n

.meas tran vdout0_33ck720 FIND v(dout0_33) AT=365.025n

.meas tran vdout0_34ck720 FIND v(dout0_34) AT=365.025n

.meas tran vdout0_35ck720 FIND v(dout0_35) AT=365.025n

.meas tran vdout0_36ck720 FIND v(dout0_36) AT=365.025n

.meas tran vdout0_37ck720 FIND v(dout0_37) AT=365.025n

.meas tran vdout0_38ck720 FIND v(dout0_38) AT=365.025n

.meas tran vdout0_39ck720 FIND v(dout0_39) AT=365.025n

.meas tran vdout0_40ck720 FIND v(dout0_40) AT=365.025n

.meas tran vdout0_41ck720 FIND v(dout0_41) AT=365.025n

.meas tran vdout0_42ck720 FIND v(dout0_42) AT=365.025n

.meas tran vdout0_43ck720 FIND v(dout0_43) AT=365.025n

.meas tran vdout0_44ck720 FIND v(dout0_44) AT=365.025n

.meas tran vdout0_45ck720 FIND v(dout0_45) AT=365.025n

.meas tran vdout0_46ck720 FIND v(dout0_46) AT=365.025n

.meas tran vdout0_47ck720 FIND v(dout0_47) AT=365.025n

.meas tran vdout0_48ck720 FIND v(dout0_48) AT=365.025n

.meas tran vdout0_49ck720 FIND v(dout0_49) AT=365.025n

.meas tran vdout0_50ck720 FIND v(dout0_50) AT=365.025n

.meas tran vdout0_51ck720 FIND v(dout0_51) AT=365.025n

.meas tran vdout0_52ck720 FIND v(dout0_52) AT=365.025n

.meas tran vdout0_53ck720 FIND v(dout0_53) AT=365.025n

.meas tran vdout0_54ck720 FIND v(dout0_54) AT=365.025n

.meas tran vdout0_55ck720 FIND v(dout0_55) AT=365.025n

.meas tran vdout0_56ck720 FIND v(dout0_56) AT=365.025n

.meas tran vdout0_57ck720 FIND v(dout0_57) AT=365.025n

.meas tran vdout0_58ck720 FIND v(dout0_58) AT=365.025n

.meas tran vdout0_59ck720 FIND v(dout0_59) AT=365.025n

.meas tran vdout0_60ck720 FIND v(dout0_60) AT=365.025n

.meas tran vdout0_61ck720 FIND v(dout0_61) AT=365.025n

.meas tran vdout0_62ck720 FIND v(dout0_62) AT=365.025n

.meas tran vdout0_63ck720 FIND v(dout0_63) AT=365.025n

.meas tran vdout0_64ck720 FIND v(dout0_64) AT=365.025n

.meas tran vdout0_65ck720 FIND v(dout0_65) AT=365.025n

.meas tran vdout0_66ck720 FIND v(dout0_66) AT=365.025n

.meas tran vdout0_67ck720 FIND v(dout0_67) AT=365.025n

.meas tran vdout0_68ck720 FIND v(dout0_68) AT=365.025n

.meas tran vdout0_69ck720 FIND v(dout0_69) AT=365.025n

.meas tran vdout0_70ck720 FIND v(dout0_70) AT=365.025n

.meas tran vdout0_71ck720 FIND v(dout0_71) AT=365.025n

.meas tran vdout0_72ck720 FIND v(dout0_72) AT=365.025n

.meas tran vdout0_73ck720 FIND v(dout0_73) AT=365.025n

.meas tran vdout0_74ck720 FIND v(dout0_74) AT=365.025n

.meas tran vdout0_75ck720 FIND v(dout0_75) AT=365.025n

.meas tran vdout0_76ck720 FIND v(dout0_76) AT=365.025n

.meas tran vdout0_77ck720 FIND v(dout0_77) AT=365.025n

.meas tran vdout0_78ck720 FIND v(dout0_78) AT=365.025n

.meas tran vdout0_79ck720 FIND v(dout0_79) AT=365.025n

.meas tran vdout0_80ck720 FIND v(dout0_80) AT=365.025n

.meas tran vdout0_81ck720 FIND v(dout0_81) AT=365.025n

.meas tran vdout0_82ck720 FIND v(dout0_82) AT=365.025n

.meas tran vdout0_83ck720 FIND v(dout0_83) AT=365.025n

.meas tran vdout0_84ck720 FIND v(dout0_84) AT=365.025n

.meas tran vdout0_85ck720 FIND v(dout0_85) AT=365.025n

.meas tran vdout0_86ck720 FIND v(dout0_86) AT=365.025n

.meas tran vdout0_87ck720 FIND v(dout0_87) AT=365.025n

.meas tran vdout0_88ck720 FIND v(dout0_88) AT=365.025n

.meas tran vdout0_89ck720 FIND v(dout0_89) AT=365.025n

.meas tran vdout0_90ck720 FIND v(dout0_90) AT=365.025n

.meas tran vdout0_91ck720 FIND v(dout0_91) AT=365.025n

.meas tran vdout0_92ck720 FIND v(dout0_92) AT=365.025n

.meas tran vdout0_93ck720 FIND v(dout0_93) AT=365.025n

.meas tran vdout0_94ck720 FIND v(dout0_94) AT=365.025n

.meas tran vdout0_95ck720 FIND v(dout0_95) AT=365.025n

.meas tran vdout0_96ck720 FIND v(dout0_96) AT=365.025n

.meas tran vdout0_97ck720 FIND v(dout0_97) AT=365.025n

.meas tran vdout0_98ck720 FIND v(dout0_98) AT=365.025n

.meas tran vdout0_99ck720 FIND v(dout0_99) AT=365.025n

.meas tran vdout0_100ck720 FIND v(dout0_100) AT=365.025n

.meas tran vdout0_101ck720 FIND v(dout0_101) AT=365.025n

.meas tran vdout0_102ck720 FIND v(dout0_102) AT=365.025n

.meas tran vdout0_103ck720 FIND v(dout0_103) AT=365.025n

.meas tran vdout0_104ck720 FIND v(dout0_104) AT=365.025n

.meas tran vdout0_105ck720 FIND v(dout0_105) AT=365.025n

.meas tran vdout0_106ck720 FIND v(dout0_106) AT=365.025n

.meas tran vdout0_107ck720 FIND v(dout0_107) AT=365.025n

.meas tran vdout0_108ck720 FIND v(dout0_108) AT=365.025n

.meas tran vdout0_109ck720 FIND v(dout0_109) AT=365.025n

.meas tran vdout0_110ck720 FIND v(dout0_110) AT=365.025n

.meas tran vdout0_111ck720 FIND v(dout0_111) AT=365.025n

.meas tran vdout0_112ck720 FIND v(dout0_112) AT=365.025n

.meas tran vdout0_113ck720 FIND v(dout0_113) AT=365.025n

.meas tran vdout0_114ck720 FIND v(dout0_114) AT=365.025n

.meas tran vdout0_115ck720 FIND v(dout0_115) AT=365.025n

.meas tran vdout0_116ck720 FIND v(dout0_116) AT=365.025n

.meas tran vdout0_117ck720 FIND v(dout0_117) AT=365.025n

.meas tran vdout0_118ck720 FIND v(dout0_118) AT=365.025n

.meas tran vdout0_119ck720 FIND v(dout0_119) AT=365.025n

.meas tran vdout0_120ck720 FIND v(dout0_120) AT=365.025n

.meas tran vdout0_121ck720 FIND v(dout0_121) AT=365.025n

.meas tran vdout0_122ck720 FIND v(dout0_122) AT=365.025n

.meas tran vdout0_123ck720 FIND v(dout0_123) AT=365.025n

.meas tran vdout0_124ck720 FIND v(dout0_124) AT=365.025n

.meas tran vdout0_125ck720 FIND v(dout0_125) AT=365.025n

.meas tran vdout0_126ck720 FIND v(dout0_126) AT=365.025n

.meas tran vdout0_127ck720 FIND v(dout0_127) AT=365.025n

.meas tran vdout0_128ck720 FIND v(dout0_128) AT=365.025n

.meas tran vdout0_129ck720 FIND v(dout0_129) AT=365.025n

.meas tran vdout0_130ck720 FIND v(dout0_130) AT=365.025n

.meas tran vdout0_131ck720 FIND v(dout0_131) AT=365.025n

.meas tran vdout0_132ck720 FIND v(dout0_132) AT=365.025n

.meas tran vdout0_133ck720 FIND v(dout0_133) AT=365.025n

.meas tran vdout0_134ck720 FIND v(dout0_134) AT=365.025n

.meas tran vdout0_135ck720 FIND v(dout0_135) AT=365.025n

.meas tran vdout0_136ck720 FIND v(dout0_136) AT=365.025n

.meas tran vdout0_137ck720 FIND v(dout0_137) AT=365.025n

.meas tran vdout0_138ck720 FIND v(dout0_138) AT=365.025n

.meas tran vdout0_139ck720 FIND v(dout0_139) AT=365.025n

.meas tran vdout0_140ck720 FIND v(dout0_140) AT=365.025n

.meas tran vdout0_141ck720 FIND v(dout0_141) AT=365.025n

.meas tran vdout0_142ck720 FIND v(dout0_142) AT=365.025n

.meas tran vdout0_143ck720 FIND v(dout0_143) AT=365.025n

.meas tran vdout0_144ck720 FIND v(dout0_144) AT=365.025n

.meas tran vdout0_145ck720 FIND v(dout0_145) AT=365.025n

.meas tran vdout0_146ck720 FIND v(dout0_146) AT=365.025n

.meas tran vdout0_147ck720 FIND v(dout0_147) AT=365.025n

.meas tran vdout0_148ck720 FIND v(dout0_148) AT=365.025n

.meas tran vdout0_149ck720 FIND v(dout0_149) AT=365.025n

.meas tran vdout0_150ck720 FIND v(dout0_150) AT=365.025n

.meas tran vdout0_151ck720 FIND v(dout0_151) AT=365.025n

.meas tran vdout0_152ck720 FIND v(dout0_152) AT=365.025n

.meas tran vdout0_153ck720 FIND v(dout0_153) AT=365.025n

.meas tran vdout0_154ck720 FIND v(dout0_154) AT=365.025n

.meas tran vdout0_155ck720 FIND v(dout0_155) AT=365.025n

.meas tran vdout0_156ck720 FIND v(dout0_156) AT=365.025n

.meas tran vdout0_157ck720 FIND v(dout0_157) AT=365.025n

.meas tran vdout0_158ck720 FIND v(dout0_158) AT=365.025n

.meas tran vdout0_159ck720 FIND v(dout0_159) AT=365.025n

.meas tran vdout0_160ck720 FIND v(dout0_160) AT=365.025n

.meas tran vdout0_161ck720 FIND v(dout0_161) AT=365.025n

.meas tran vdout0_162ck720 FIND v(dout0_162) AT=365.025n

.meas tran vdout0_163ck720 FIND v(dout0_163) AT=365.025n

.meas tran vdout0_164ck720 FIND v(dout0_164) AT=365.025n

.meas tran vdout0_165ck720 FIND v(dout0_165) AT=365.025n

.meas tran vdout0_166ck720 FIND v(dout0_166) AT=365.025n

.meas tran vdout0_167ck720 FIND v(dout0_167) AT=365.025n

.meas tran vdout0_168ck720 FIND v(dout0_168) AT=365.025n

.meas tran vdout0_169ck720 FIND v(dout0_169) AT=365.025n

.meas tran vdout0_170ck720 FIND v(dout0_170) AT=365.025n

.meas tran vdout0_171ck720 FIND v(dout0_171) AT=365.025n

.meas tran vdout0_172ck720 FIND v(dout0_172) AT=365.025n

.meas tran vdout0_173ck720 FIND v(dout0_173) AT=365.025n

.meas tran vdout0_174ck720 FIND v(dout0_174) AT=365.025n

.meas tran vdout0_175ck720 FIND v(dout0_175) AT=365.025n

.meas tran vdout0_176ck720 FIND v(dout0_176) AT=365.025n

.meas tran vdout0_177ck720 FIND v(dout0_177) AT=365.025n

.meas tran vdout0_178ck720 FIND v(dout0_178) AT=365.025n

.meas tran vdout0_179ck720 FIND v(dout0_179) AT=365.025n

.meas tran vdout0_180ck720 FIND v(dout0_180) AT=365.025n

.meas tran vdout0_181ck720 FIND v(dout0_181) AT=365.025n

.meas tran vdout0_182ck720 FIND v(dout0_182) AT=365.025n

.meas tran vdout0_183ck720 FIND v(dout0_183) AT=365.025n

.meas tran vdout0_184ck720 FIND v(dout0_184) AT=365.025n

.meas tran vdout0_185ck720 FIND v(dout0_185) AT=365.025n

.meas tran vdout0_186ck720 FIND v(dout0_186) AT=365.025n

.meas tran vdout0_187ck720 FIND v(dout0_187) AT=365.025n

.meas tran vdout0_188ck720 FIND v(dout0_188) AT=365.025n

.meas tran vdout0_189ck720 FIND v(dout0_189) AT=365.025n

.meas tran vdout0_190ck720 FIND v(dout0_190) AT=365.025n

.meas tran vdout0_191ck720 FIND v(dout0_191) AT=365.025n

.meas tran vdout0_192ck720 FIND v(dout0_192) AT=365.025n

.meas tran vdout0_193ck720 FIND v(dout0_193) AT=365.025n

.meas tran vdout0_194ck720 FIND v(dout0_194) AT=365.025n

.meas tran vdout0_195ck720 FIND v(dout0_195) AT=365.025n

.meas tran vdout0_196ck720 FIND v(dout0_196) AT=365.025n

.meas tran vdout0_197ck720 FIND v(dout0_197) AT=365.025n

.meas tran vdout0_198ck720 FIND v(dout0_198) AT=365.025n

.meas tran vdout0_199ck720 FIND v(dout0_199) AT=365.025n

.meas tran vdout0_200ck720 FIND v(dout0_200) AT=365.025n

.meas tran vdout0_201ck720 FIND v(dout0_201) AT=365.025n

.meas tran vdout0_202ck720 FIND v(dout0_202) AT=365.025n

.meas tran vdout0_203ck720 FIND v(dout0_203) AT=365.025n

.meas tran vdout0_204ck720 FIND v(dout0_204) AT=365.025n

.meas tran vdout0_205ck720 FIND v(dout0_205) AT=365.025n

.meas tran vdout0_206ck720 FIND v(dout0_206) AT=365.025n

.meas tran vdout0_207ck720 FIND v(dout0_207) AT=365.025n

.meas tran vdout0_208ck720 FIND v(dout0_208) AT=365.025n

.meas tran vdout0_209ck720 FIND v(dout0_209) AT=365.025n

.meas tran vdout0_210ck720 FIND v(dout0_210) AT=365.025n

.meas tran vdout0_211ck720 FIND v(dout0_211) AT=365.025n

.meas tran vdout0_212ck720 FIND v(dout0_212) AT=365.025n

.meas tran vdout0_213ck720 FIND v(dout0_213) AT=365.025n

.meas tran vdout0_214ck720 FIND v(dout0_214) AT=365.025n

.meas tran vdout0_215ck720 FIND v(dout0_215) AT=365.025n

.meas tran vdout0_216ck720 FIND v(dout0_216) AT=365.025n

.meas tran vdout0_217ck720 FIND v(dout0_217) AT=365.025n

.meas tran vdout0_218ck720 FIND v(dout0_218) AT=365.025n

.meas tran vdout0_219ck720 FIND v(dout0_219) AT=365.025n

.meas tran vdout0_220ck720 FIND v(dout0_220) AT=365.025n

.meas tran vdout0_221ck720 FIND v(dout0_221) AT=365.025n

.meas tran vdout0_222ck720 FIND v(dout0_222) AT=365.025n

.meas tran vdout0_223ck720 FIND v(dout0_223) AT=365.025n

.meas tran vdout0_224ck720 FIND v(dout0_224) AT=365.025n

.meas tran vdout0_225ck720 FIND v(dout0_225) AT=365.025n

.meas tran vdout0_226ck720 FIND v(dout0_226) AT=365.025n

.meas tran vdout0_227ck720 FIND v(dout0_227) AT=365.025n

.meas tran vdout0_228ck720 FIND v(dout0_228) AT=365.025n

.meas tran vdout0_229ck720 FIND v(dout0_229) AT=365.025n

.meas tran vdout0_230ck720 FIND v(dout0_230) AT=365.025n

.meas tran vdout0_231ck720 FIND v(dout0_231) AT=365.025n

.meas tran vdout0_232ck720 FIND v(dout0_232) AT=365.025n

.meas tran vdout0_233ck720 FIND v(dout0_233) AT=365.025n

.meas tran vdout0_234ck720 FIND v(dout0_234) AT=365.025n

.meas tran vdout0_235ck720 FIND v(dout0_235) AT=365.025n

.meas tran vdout0_236ck720 FIND v(dout0_236) AT=365.025n

.meas tran vdout0_237ck720 FIND v(dout0_237) AT=365.025n

.meas tran vdout0_238ck720 FIND v(dout0_238) AT=365.025n

.meas tran vdout0_239ck720 FIND v(dout0_239) AT=365.025n

.meas tran vdout0_240ck720 FIND v(dout0_240) AT=365.025n

.meas tran vdout0_241ck720 FIND v(dout0_241) AT=365.025n

.meas tran vdout0_242ck720 FIND v(dout0_242) AT=365.025n

.meas tran vdout0_243ck720 FIND v(dout0_243) AT=365.025n

.meas tran vdout0_244ck720 FIND v(dout0_244) AT=365.025n

.meas tran vdout0_245ck720 FIND v(dout0_245) AT=365.025n

.meas tran vdout0_246ck720 FIND v(dout0_246) AT=365.025n

.meas tran vdout0_247ck720 FIND v(dout0_247) AT=365.025n

.meas tran vdout0_248ck720 FIND v(dout0_248) AT=365.025n

.meas tran vdout0_249ck720 FIND v(dout0_249) AT=365.025n

.meas tran vdout0_250ck720 FIND v(dout0_250) AT=365.025n

.meas tran vdout0_251ck720 FIND v(dout0_251) AT=365.025n

.meas tran vdout0_252ck720 FIND v(dout0_252) AT=365.025n

.meas tran vdout0_253ck720 FIND v(dout0_253) AT=365.025n

.meas tran vdout0_254ck720 FIND v(dout0_254) AT=365.025n

.meas tran vdout0_255ck720 FIND v(dout0_255) AT=365.025n

.meas tran vdout0_0ck810 FIND v(dout0_0) AT=410.025n

.meas tran vdout0_1ck810 FIND v(dout0_1) AT=410.025n

.meas tran vdout0_2ck810 FIND v(dout0_2) AT=410.025n

.meas tran vdout0_3ck810 FIND v(dout0_3) AT=410.025n

.meas tran vdout0_4ck810 FIND v(dout0_4) AT=410.025n

.meas tran vdout0_5ck810 FIND v(dout0_5) AT=410.025n

.meas tran vdout0_6ck810 FIND v(dout0_6) AT=410.025n

.meas tran vdout0_7ck810 FIND v(dout0_7) AT=410.025n

.meas tran vdout0_8ck810 FIND v(dout0_8) AT=410.025n

.meas tran vdout0_9ck810 FIND v(dout0_9) AT=410.025n

.meas tran vdout0_10ck810 FIND v(dout0_10) AT=410.025n

.meas tran vdout0_11ck810 FIND v(dout0_11) AT=410.025n

.meas tran vdout0_12ck810 FIND v(dout0_12) AT=410.025n

.meas tran vdout0_13ck810 FIND v(dout0_13) AT=410.025n

.meas tran vdout0_14ck810 FIND v(dout0_14) AT=410.025n

.meas tran vdout0_15ck810 FIND v(dout0_15) AT=410.025n

.meas tran vdout0_16ck810 FIND v(dout0_16) AT=410.025n

.meas tran vdout0_17ck810 FIND v(dout0_17) AT=410.025n

.meas tran vdout0_18ck810 FIND v(dout0_18) AT=410.025n

.meas tran vdout0_19ck810 FIND v(dout0_19) AT=410.025n

.meas tran vdout0_20ck810 FIND v(dout0_20) AT=410.025n

.meas tran vdout0_21ck810 FIND v(dout0_21) AT=410.025n

.meas tran vdout0_22ck810 FIND v(dout0_22) AT=410.025n

.meas tran vdout0_23ck810 FIND v(dout0_23) AT=410.025n

.meas tran vdout0_24ck810 FIND v(dout0_24) AT=410.025n

.meas tran vdout0_25ck810 FIND v(dout0_25) AT=410.025n

.meas tran vdout0_26ck810 FIND v(dout0_26) AT=410.025n

.meas tran vdout0_27ck810 FIND v(dout0_27) AT=410.025n

.meas tran vdout0_28ck810 FIND v(dout0_28) AT=410.025n

.meas tran vdout0_29ck810 FIND v(dout0_29) AT=410.025n

.meas tran vdout0_30ck810 FIND v(dout0_30) AT=410.025n

.meas tran vdout0_31ck810 FIND v(dout0_31) AT=410.025n

.meas tran vdout0_32ck810 FIND v(dout0_32) AT=410.025n

.meas tran vdout0_33ck810 FIND v(dout0_33) AT=410.025n

.meas tran vdout0_34ck810 FIND v(dout0_34) AT=410.025n

.meas tran vdout0_35ck810 FIND v(dout0_35) AT=410.025n

.meas tran vdout0_36ck810 FIND v(dout0_36) AT=410.025n

.meas tran vdout0_37ck810 FIND v(dout0_37) AT=410.025n

.meas tran vdout0_38ck810 FIND v(dout0_38) AT=410.025n

.meas tran vdout0_39ck810 FIND v(dout0_39) AT=410.025n

.meas tran vdout0_40ck810 FIND v(dout0_40) AT=410.025n

.meas tran vdout0_41ck810 FIND v(dout0_41) AT=410.025n

.meas tran vdout0_42ck810 FIND v(dout0_42) AT=410.025n

.meas tran vdout0_43ck810 FIND v(dout0_43) AT=410.025n

.meas tran vdout0_44ck810 FIND v(dout0_44) AT=410.025n

.meas tran vdout0_45ck810 FIND v(dout0_45) AT=410.025n

.meas tran vdout0_46ck810 FIND v(dout0_46) AT=410.025n

.meas tran vdout0_47ck810 FIND v(dout0_47) AT=410.025n

.meas tran vdout0_48ck810 FIND v(dout0_48) AT=410.025n

.meas tran vdout0_49ck810 FIND v(dout0_49) AT=410.025n

.meas tran vdout0_50ck810 FIND v(dout0_50) AT=410.025n

.meas tran vdout0_51ck810 FIND v(dout0_51) AT=410.025n

.meas tran vdout0_52ck810 FIND v(dout0_52) AT=410.025n

.meas tran vdout0_53ck810 FIND v(dout0_53) AT=410.025n

.meas tran vdout0_54ck810 FIND v(dout0_54) AT=410.025n

.meas tran vdout0_55ck810 FIND v(dout0_55) AT=410.025n

.meas tran vdout0_56ck810 FIND v(dout0_56) AT=410.025n

.meas tran vdout0_57ck810 FIND v(dout0_57) AT=410.025n

.meas tran vdout0_58ck810 FIND v(dout0_58) AT=410.025n

.meas tran vdout0_59ck810 FIND v(dout0_59) AT=410.025n

.meas tran vdout0_60ck810 FIND v(dout0_60) AT=410.025n

.meas tran vdout0_61ck810 FIND v(dout0_61) AT=410.025n

.meas tran vdout0_62ck810 FIND v(dout0_62) AT=410.025n

.meas tran vdout0_63ck810 FIND v(dout0_63) AT=410.025n

.meas tran vdout0_64ck810 FIND v(dout0_64) AT=410.025n

.meas tran vdout0_65ck810 FIND v(dout0_65) AT=410.025n

.meas tran vdout0_66ck810 FIND v(dout0_66) AT=410.025n

.meas tran vdout0_67ck810 FIND v(dout0_67) AT=410.025n

.meas tran vdout0_68ck810 FIND v(dout0_68) AT=410.025n

.meas tran vdout0_69ck810 FIND v(dout0_69) AT=410.025n

.meas tran vdout0_70ck810 FIND v(dout0_70) AT=410.025n

.meas tran vdout0_71ck810 FIND v(dout0_71) AT=410.025n

.meas tran vdout0_72ck810 FIND v(dout0_72) AT=410.025n

.meas tran vdout0_73ck810 FIND v(dout0_73) AT=410.025n

.meas tran vdout0_74ck810 FIND v(dout0_74) AT=410.025n

.meas tran vdout0_75ck810 FIND v(dout0_75) AT=410.025n

.meas tran vdout0_76ck810 FIND v(dout0_76) AT=410.025n

.meas tran vdout0_77ck810 FIND v(dout0_77) AT=410.025n

.meas tran vdout0_78ck810 FIND v(dout0_78) AT=410.025n

.meas tran vdout0_79ck810 FIND v(dout0_79) AT=410.025n

.meas tran vdout0_80ck810 FIND v(dout0_80) AT=410.025n

.meas tran vdout0_81ck810 FIND v(dout0_81) AT=410.025n

.meas tran vdout0_82ck810 FIND v(dout0_82) AT=410.025n

.meas tran vdout0_83ck810 FIND v(dout0_83) AT=410.025n

.meas tran vdout0_84ck810 FIND v(dout0_84) AT=410.025n

.meas tran vdout0_85ck810 FIND v(dout0_85) AT=410.025n

.meas tran vdout0_86ck810 FIND v(dout0_86) AT=410.025n

.meas tran vdout0_87ck810 FIND v(dout0_87) AT=410.025n

.meas tran vdout0_88ck810 FIND v(dout0_88) AT=410.025n

.meas tran vdout0_89ck810 FIND v(dout0_89) AT=410.025n

.meas tran vdout0_90ck810 FIND v(dout0_90) AT=410.025n

.meas tran vdout0_91ck810 FIND v(dout0_91) AT=410.025n

.meas tran vdout0_92ck810 FIND v(dout0_92) AT=410.025n

.meas tran vdout0_93ck810 FIND v(dout0_93) AT=410.025n

.meas tran vdout0_94ck810 FIND v(dout0_94) AT=410.025n

.meas tran vdout0_95ck810 FIND v(dout0_95) AT=410.025n

.meas tran vdout0_96ck810 FIND v(dout0_96) AT=410.025n

.meas tran vdout0_97ck810 FIND v(dout0_97) AT=410.025n

.meas tran vdout0_98ck810 FIND v(dout0_98) AT=410.025n

.meas tran vdout0_99ck810 FIND v(dout0_99) AT=410.025n

.meas tran vdout0_100ck810 FIND v(dout0_100) AT=410.025n

.meas tran vdout0_101ck810 FIND v(dout0_101) AT=410.025n

.meas tran vdout0_102ck810 FIND v(dout0_102) AT=410.025n

.meas tran vdout0_103ck810 FIND v(dout0_103) AT=410.025n

.meas tran vdout0_104ck810 FIND v(dout0_104) AT=410.025n

.meas tran vdout0_105ck810 FIND v(dout0_105) AT=410.025n

.meas tran vdout0_106ck810 FIND v(dout0_106) AT=410.025n

.meas tran vdout0_107ck810 FIND v(dout0_107) AT=410.025n

.meas tran vdout0_108ck810 FIND v(dout0_108) AT=410.025n

.meas tran vdout0_109ck810 FIND v(dout0_109) AT=410.025n

.meas tran vdout0_110ck810 FIND v(dout0_110) AT=410.025n

.meas tran vdout0_111ck810 FIND v(dout0_111) AT=410.025n

.meas tran vdout0_112ck810 FIND v(dout0_112) AT=410.025n

.meas tran vdout0_113ck810 FIND v(dout0_113) AT=410.025n

.meas tran vdout0_114ck810 FIND v(dout0_114) AT=410.025n

.meas tran vdout0_115ck810 FIND v(dout0_115) AT=410.025n

.meas tran vdout0_116ck810 FIND v(dout0_116) AT=410.025n

.meas tran vdout0_117ck810 FIND v(dout0_117) AT=410.025n

.meas tran vdout0_118ck810 FIND v(dout0_118) AT=410.025n

.meas tran vdout0_119ck810 FIND v(dout0_119) AT=410.025n

.meas tran vdout0_120ck810 FIND v(dout0_120) AT=410.025n

.meas tran vdout0_121ck810 FIND v(dout0_121) AT=410.025n

.meas tran vdout0_122ck810 FIND v(dout0_122) AT=410.025n

.meas tran vdout0_123ck810 FIND v(dout0_123) AT=410.025n

.meas tran vdout0_124ck810 FIND v(dout0_124) AT=410.025n

.meas tran vdout0_125ck810 FIND v(dout0_125) AT=410.025n

.meas tran vdout0_126ck810 FIND v(dout0_126) AT=410.025n

.meas tran vdout0_127ck810 FIND v(dout0_127) AT=410.025n

.meas tran vdout0_128ck810 FIND v(dout0_128) AT=410.025n

.meas tran vdout0_129ck810 FIND v(dout0_129) AT=410.025n

.meas tran vdout0_130ck810 FIND v(dout0_130) AT=410.025n

.meas tran vdout0_131ck810 FIND v(dout0_131) AT=410.025n

.meas tran vdout0_132ck810 FIND v(dout0_132) AT=410.025n

.meas tran vdout0_133ck810 FIND v(dout0_133) AT=410.025n

.meas tran vdout0_134ck810 FIND v(dout0_134) AT=410.025n

.meas tran vdout0_135ck810 FIND v(dout0_135) AT=410.025n

.meas tran vdout0_136ck810 FIND v(dout0_136) AT=410.025n

.meas tran vdout0_137ck810 FIND v(dout0_137) AT=410.025n

.meas tran vdout0_138ck810 FIND v(dout0_138) AT=410.025n

.meas tran vdout0_139ck810 FIND v(dout0_139) AT=410.025n

.meas tran vdout0_140ck810 FIND v(dout0_140) AT=410.025n

.meas tran vdout0_141ck810 FIND v(dout0_141) AT=410.025n

.meas tran vdout0_142ck810 FIND v(dout0_142) AT=410.025n

.meas tran vdout0_143ck810 FIND v(dout0_143) AT=410.025n

.meas tran vdout0_144ck810 FIND v(dout0_144) AT=410.025n

.meas tran vdout0_145ck810 FIND v(dout0_145) AT=410.025n

.meas tran vdout0_146ck810 FIND v(dout0_146) AT=410.025n

.meas tran vdout0_147ck810 FIND v(dout0_147) AT=410.025n

.meas tran vdout0_148ck810 FIND v(dout0_148) AT=410.025n

.meas tran vdout0_149ck810 FIND v(dout0_149) AT=410.025n

.meas tran vdout0_150ck810 FIND v(dout0_150) AT=410.025n

.meas tran vdout0_151ck810 FIND v(dout0_151) AT=410.025n

.meas tran vdout0_152ck810 FIND v(dout0_152) AT=410.025n

.meas tran vdout0_153ck810 FIND v(dout0_153) AT=410.025n

.meas tran vdout0_154ck810 FIND v(dout0_154) AT=410.025n

.meas tran vdout0_155ck810 FIND v(dout0_155) AT=410.025n

.meas tran vdout0_156ck810 FIND v(dout0_156) AT=410.025n

.meas tran vdout0_157ck810 FIND v(dout0_157) AT=410.025n

.meas tran vdout0_158ck810 FIND v(dout0_158) AT=410.025n

.meas tran vdout0_159ck810 FIND v(dout0_159) AT=410.025n

.meas tran vdout0_160ck810 FIND v(dout0_160) AT=410.025n

.meas tran vdout0_161ck810 FIND v(dout0_161) AT=410.025n

.meas tran vdout0_162ck810 FIND v(dout0_162) AT=410.025n

.meas tran vdout0_163ck810 FIND v(dout0_163) AT=410.025n

.meas tran vdout0_164ck810 FIND v(dout0_164) AT=410.025n

.meas tran vdout0_165ck810 FIND v(dout0_165) AT=410.025n

.meas tran vdout0_166ck810 FIND v(dout0_166) AT=410.025n

.meas tran vdout0_167ck810 FIND v(dout0_167) AT=410.025n

.meas tran vdout0_168ck810 FIND v(dout0_168) AT=410.025n

.meas tran vdout0_169ck810 FIND v(dout0_169) AT=410.025n

.meas tran vdout0_170ck810 FIND v(dout0_170) AT=410.025n

.meas tran vdout0_171ck810 FIND v(dout0_171) AT=410.025n

.meas tran vdout0_172ck810 FIND v(dout0_172) AT=410.025n

.meas tran vdout0_173ck810 FIND v(dout0_173) AT=410.025n

.meas tran vdout0_174ck810 FIND v(dout0_174) AT=410.025n

.meas tran vdout0_175ck810 FIND v(dout0_175) AT=410.025n

.meas tran vdout0_176ck810 FIND v(dout0_176) AT=410.025n

.meas tran vdout0_177ck810 FIND v(dout0_177) AT=410.025n

.meas tran vdout0_178ck810 FIND v(dout0_178) AT=410.025n

.meas tran vdout0_179ck810 FIND v(dout0_179) AT=410.025n

.meas tran vdout0_180ck810 FIND v(dout0_180) AT=410.025n

.meas tran vdout0_181ck810 FIND v(dout0_181) AT=410.025n

.meas tran vdout0_182ck810 FIND v(dout0_182) AT=410.025n

.meas tran vdout0_183ck810 FIND v(dout0_183) AT=410.025n

.meas tran vdout0_184ck810 FIND v(dout0_184) AT=410.025n

.meas tran vdout0_185ck810 FIND v(dout0_185) AT=410.025n

.meas tran vdout0_186ck810 FIND v(dout0_186) AT=410.025n

.meas tran vdout0_187ck810 FIND v(dout0_187) AT=410.025n

.meas tran vdout0_188ck810 FIND v(dout0_188) AT=410.025n

.meas tran vdout0_189ck810 FIND v(dout0_189) AT=410.025n

.meas tran vdout0_190ck810 FIND v(dout0_190) AT=410.025n

.meas tran vdout0_191ck810 FIND v(dout0_191) AT=410.025n

.meas tran vdout0_192ck810 FIND v(dout0_192) AT=410.025n

.meas tran vdout0_193ck810 FIND v(dout0_193) AT=410.025n

.meas tran vdout0_194ck810 FIND v(dout0_194) AT=410.025n

.meas tran vdout0_195ck810 FIND v(dout0_195) AT=410.025n

.meas tran vdout0_196ck810 FIND v(dout0_196) AT=410.025n

.meas tran vdout0_197ck810 FIND v(dout0_197) AT=410.025n

.meas tran vdout0_198ck810 FIND v(dout0_198) AT=410.025n

.meas tran vdout0_199ck810 FIND v(dout0_199) AT=410.025n

.meas tran vdout0_200ck810 FIND v(dout0_200) AT=410.025n

.meas tran vdout0_201ck810 FIND v(dout0_201) AT=410.025n

.meas tran vdout0_202ck810 FIND v(dout0_202) AT=410.025n

.meas tran vdout0_203ck810 FIND v(dout0_203) AT=410.025n

.meas tran vdout0_204ck810 FIND v(dout0_204) AT=410.025n

.meas tran vdout0_205ck810 FIND v(dout0_205) AT=410.025n

.meas tran vdout0_206ck810 FIND v(dout0_206) AT=410.025n

.meas tran vdout0_207ck810 FIND v(dout0_207) AT=410.025n

.meas tran vdout0_208ck810 FIND v(dout0_208) AT=410.025n

.meas tran vdout0_209ck810 FIND v(dout0_209) AT=410.025n

.meas tran vdout0_210ck810 FIND v(dout0_210) AT=410.025n

.meas tran vdout0_211ck810 FIND v(dout0_211) AT=410.025n

.meas tran vdout0_212ck810 FIND v(dout0_212) AT=410.025n

.meas tran vdout0_213ck810 FIND v(dout0_213) AT=410.025n

.meas tran vdout0_214ck810 FIND v(dout0_214) AT=410.025n

.meas tran vdout0_215ck810 FIND v(dout0_215) AT=410.025n

.meas tran vdout0_216ck810 FIND v(dout0_216) AT=410.025n

.meas tran vdout0_217ck810 FIND v(dout0_217) AT=410.025n

.meas tran vdout0_218ck810 FIND v(dout0_218) AT=410.025n

.meas tran vdout0_219ck810 FIND v(dout0_219) AT=410.025n

.meas tran vdout0_220ck810 FIND v(dout0_220) AT=410.025n

.meas tran vdout0_221ck810 FIND v(dout0_221) AT=410.025n

.meas tran vdout0_222ck810 FIND v(dout0_222) AT=410.025n

.meas tran vdout0_223ck810 FIND v(dout0_223) AT=410.025n

.meas tran vdout0_224ck810 FIND v(dout0_224) AT=410.025n

.meas tran vdout0_225ck810 FIND v(dout0_225) AT=410.025n

.meas tran vdout0_226ck810 FIND v(dout0_226) AT=410.025n

.meas tran vdout0_227ck810 FIND v(dout0_227) AT=410.025n

.meas tran vdout0_228ck810 FIND v(dout0_228) AT=410.025n

.meas tran vdout0_229ck810 FIND v(dout0_229) AT=410.025n

.meas tran vdout0_230ck810 FIND v(dout0_230) AT=410.025n

.meas tran vdout0_231ck810 FIND v(dout0_231) AT=410.025n

.meas tran vdout0_232ck810 FIND v(dout0_232) AT=410.025n

.meas tran vdout0_233ck810 FIND v(dout0_233) AT=410.025n

.meas tran vdout0_234ck810 FIND v(dout0_234) AT=410.025n

.meas tran vdout0_235ck810 FIND v(dout0_235) AT=410.025n

.meas tran vdout0_236ck810 FIND v(dout0_236) AT=410.025n

.meas tran vdout0_237ck810 FIND v(dout0_237) AT=410.025n

.meas tran vdout0_238ck810 FIND v(dout0_238) AT=410.025n

.meas tran vdout0_239ck810 FIND v(dout0_239) AT=410.025n

.meas tran vdout0_240ck810 FIND v(dout0_240) AT=410.025n

.meas tran vdout0_241ck810 FIND v(dout0_241) AT=410.025n

.meas tran vdout0_242ck810 FIND v(dout0_242) AT=410.025n

.meas tran vdout0_243ck810 FIND v(dout0_243) AT=410.025n

.meas tran vdout0_244ck810 FIND v(dout0_244) AT=410.025n

.meas tran vdout0_245ck810 FIND v(dout0_245) AT=410.025n

.meas tran vdout0_246ck810 FIND v(dout0_246) AT=410.025n

.meas tran vdout0_247ck810 FIND v(dout0_247) AT=410.025n

.meas tran vdout0_248ck810 FIND v(dout0_248) AT=410.025n

.meas tran vdout0_249ck810 FIND v(dout0_249) AT=410.025n

.meas tran vdout0_250ck810 FIND v(dout0_250) AT=410.025n

.meas tran vdout0_251ck810 FIND v(dout0_251) AT=410.025n

.meas tran vdout0_252ck810 FIND v(dout0_252) AT=410.025n

.meas tran vdout0_253ck810 FIND v(dout0_253) AT=410.025n

.meas tran vdout0_254ck810 FIND v(dout0_254) AT=410.025n

.meas tran vdout0_255ck810 FIND v(dout0_255) AT=410.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_128ck820 FIND v(dout0_128) AT=415.025n

.meas tran vdout0_129ck820 FIND v(dout0_129) AT=415.025n

.meas tran vdout0_130ck820 FIND v(dout0_130) AT=415.025n

.meas tran vdout0_131ck820 FIND v(dout0_131) AT=415.025n

.meas tran vdout0_132ck820 FIND v(dout0_132) AT=415.025n

.meas tran vdout0_133ck820 FIND v(dout0_133) AT=415.025n

.meas tran vdout0_134ck820 FIND v(dout0_134) AT=415.025n

.meas tran vdout0_135ck820 FIND v(dout0_135) AT=415.025n

.meas tran vdout0_136ck820 FIND v(dout0_136) AT=415.025n

.meas tran vdout0_137ck820 FIND v(dout0_137) AT=415.025n

.meas tran vdout0_138ck820 FIND v(dout0_138) AT=415.025n

.meas tran vdout0_139ck820 FIND v(dout0_139) AT=415.025n

.meas tran vdout0_140ck820 FIND v(dout0_140) AT=415.025n

.meas tran vdout0_141ck820 FIND v(dout0_141) AT=415.025n

.meas tran vdout0_142ck820 FIND v(dout0_142) AT=415.025n

.meas tran vdout0_143ck820 FIND v(dout0_143) AT=415.025n

.meas tran vdout0_144ck820 FIND v(dout0_144) AT=415.025n

.meas tran vdout0_145ck820 FIND v(dout0_145) AT=415.025n

.meas tran vdout0_146ck820 FIND v(dout0_146) AT=415.025n

.meas tran vdout0_147ck820 FIND v(dout0_147) AT=415.025n

.meas tran vdout0_148ck820 FIND v(dout0_148) AT=415.025n

.meas tran vdout0_149ck820 FIND v(dout0_149) AT=415.025n

.meas tran vdout0_150ck820 FIND v(dout0_150) AT=415.025n

.meas tran vdout0_151ck820 FIND v(dout0_151) AT=415.025n

.meas tran vdout0_152ck820 FIND v(dout0_152) AT=415.025n

.meas tran vdout0_153ck820 FIND v(dout0_153) AT=415.025n

.meas tran vdout0_154ck820 FIND v(dout0_154) AT=415.025n

.meas tran vdout0_155ck820 FIND v(dout0_155) AT=415.025n

.meas tran vdout0_156ck820 FIND v(dout0_156) AT=415.025n

.meas tran vdout0_157ck820 FIND v(dout0_157) AT=415.025n

.meas tran vdout0_158ck820 FIND v(dout0_158) AT=415.025n

.meas tran vdout0_159ck820 FIND v(dout0_159) AT=415.025n

.meas tran vdout0_160ck820 FIND v(dout0_160) AT=415.025n

.meas tran vdout0_161ck820 FIND v(dout0_161) AT=415.025n

.meas tran vdout0_162ck820 FIND v(dout0_162) AT=415.025n

.meas tran vdout0_163ck820 FIND v(dout0_163) AT=415.025n

.meas tran vdout0_164ck820 FIND v(dout0_164) AT=415.025n

.meas tran vdout0_165ck820 FIND v(dout0_165) AT=415.025n

.meas tran vdout0_166ck820 FIND v(dout0_166) AT=415.025n

.meas tran vdout0_167ck820 FIND v(dout0_167) AT=415.025n

.meas tran vdout0_168ck820 FIND v(dout0_168) AT=415.025n

.meas tran vdout0_169ck820 FIND v(dout0_169) AT=415.025n

.meas tran vdout0_170ck820 FIND v(dout0_170) AT=415.025n

.meas tran vdout0_171ck820 FIND v(dout0_171) AT=415.025n

.meas tran vdout0_172ck820 FIND v(dout0_172) AT=415.025n

.meas tran vdout0_173ck820 FIND v(dout0_173) AT=415.025n

.meas tran vdout0_174ck820 FIND v(dout0_174) AT=415.025n

.meas tran vdout0_175ck820 FIND v(dout0_175) AT=415.025n

.meas tran vdout0_176ck820 FIND v(dout0_176) AT=415.025n

.meas tran vdout0_177ck820 FIND v(dout0_177) AT=415.025n

.meas tran vdout0_178ck820 FIND v(dout0_178) AT=415.025n

.meas tran vdout0_179ck820 FIND v(dout0_179) AT=415.025n

.meas tran vdout0_180ck820 FIND v(dout0_180) AT=415.025n

.meas tran vdout0_181ck820 FIND v(dout0_181) AT=415.025n

.meas tran vdout0_182ck820 FIND v(dout0_182) AT=415.025n

.meas tran vdout0_183ck820 FIND v(dout0_183) AT=415.025n

.meas tran vdout0_184ck820 FIND v(dout0_184) AT=415.025n

.meas tran vdout0_185ck820 FIND v(dout0_185) AT=415.025n

.meas tran vdout0_186ck820 FIND v(dout0_186) AT=415.025n

.meas tran vdout0_187ck820 FIND v(dout0_187) AT=415.025n

.meas tran vdout0_188ck820 FIND v(dout0_188) AT=415.025n

.meas tran vdout0_189ck820 FIND v(dout0_189) AT=415.025n

.meas tran vdout0_190ck820 FIND v(dout0_190) AT=415.025n

.meas tran vdout0_191ck820 FIND v(dout0_191) AT=415.025n

.meas tran vdout0_192ck820 FIND v(dout0_192) AT=415.025n

.meas tran vdout0_193ck820 FIND v(dout0_193) AT=415.025n

.meas tran vdout0_194ck820 FIND v(dout0_194) AT=415.025n

.meas tran vdout0_195ck820 FIND v(dout0_195) AT=415.025n

.meas tran vdout0_196ck820 FIND v(dout0_196) AT=415.025n

.meas tran vdout0_197ck820 FIND v(dout0_197) AT=415.025n

.meas tran vdout0_198ck820 FIND v(dout0_198) AT=415.025n

.meas tran vdout0_199ck820 FIND v(dout0_199) AT=415.025n

.meas tran vdout0_200ck820 FIND v(dout0_200) AT=415.025n

.meas tran vdout0_201ck820 FIND v(dout0_201) AT=415.025n

.meas tran vdout0_202ck820 FIND v(dout0_202) AT=415.025n

.meas tran vdout0_203ck820 FIND v(dout0_203) AT=415.025n

.meas tran vdout0_204ck820 FIND v(dout0_204) AT=415.025n

.meas tran vdout0_205ck820 FIND v(dout0_205) AT=415.025n

.meas tran vdout0_206ck820 FIND v(dout0_206) AT=415.025n

.meas tran vdout0_207ck820 FIND v(dout0_207) AT=415.025n

.meas tran vdout0_208ck820 FIND v(dout0_208) AT=415.025n

.meas tran vdout0_209ck820 FIND v(dout0_209) AT=415.025n

.meas tran vdout0_210ck820 FIND v(dout0_210) AT=415.025n

.meas tran vdout0_211ck820 FIND v(dout0_211) AT=415.025n

.meas tran vdout0_212ck820 FIND v(dout0_212) AT=415.025n

.meas tran vdout0_213ck820 FIND v(dout0_213) AT=415.025n

.meas tran vdout0_214ck820 FIND v(dout0_214) AT=415.025n

.meas tran vdout0_215ck820 FIND v(dout0_215) AT=415.025n

.meas tran vdout0_216ck820 FIND v(dout0_216) AT=415.025n

.meas tran vdout0_217ck820 FIND v(dout0_217) AT=415.025n

.meas tran vdout0_218ck820 FIND v(dout0_218) AT=415.025n

.meas tran vdout0_219ck820 FIND v(dout0_219) AT=415.025n

.meas tran vdout0_220ck820 FIND v(dout0_220) AT=415.025n

.meas tran vdout0_221ck820 FIND v(dout0_221) AT=415.025n

.meas tran vdout0_222ck820 FIND v(dout0_222) AT=415.025n

.meas tran vdout0_223ck820 FIND v(dout0_223) AT=415.025n

.meas tran vdout0_224ck820 FIND v(dout0_224) AT=415.025n

.meas tran vdout0_225ck820 FIND v(dout0_225) AT=415.025n

.meas tran vdout0_226ck820 FIND v(dout0_226) AT=415.025n

.meas tran vdout0_227ck820 FIND v(dout0_227) AT=415.025n

.meas tran vdout0_228ck820 FIND v(dout0_228) AT=415.025n

.meas tran vdout0_229ck820 FIND v(dout0_229) AT=415.025n

.meas tran vdout0_230ck820 FIND v(dout0_230) AT=415.025n

.meas tran vdout0_231ck820 FIND v(dout0_231) AT=415.025n

.meas tran vdout0_232ck820 FIND v(dout0_232) AT=415.025n

.meas tran vdout0_233ck820 FIND v(dout0_233) AT=415.025n

.meas tran vdout0_234ck820 FIND v(dout0_234) AT=415.025n

.meas tran vdout0_235ck820 FIND v(dout0_235) AT=415.025n

.meas tran vdout0_236ck820 FIND v(dout0_236) AT=415.025n

.meas tran vdout0_237ck820 FIND v(dout0_237) AT=415.025n

.meas tran vdout0_238ck820 FIND v(dout0_238) AT=415.025n

.meas tran vdout0_239ck820 FIND v(dout0_239) AT=415.025n

.meas tran vdout0_240ck820 FIND v(dout0_240) AT=415.025n

.meas tran vdout0_241ck820 FIND v(dout0_241) AT=415.025n

.meas tran vdout0_242ck820 FIND v(dout0_242) AT=415.025n

.meas tran vdout0_243ck820 FIND v(dout0_243) AT=415.025n

.meas tran vdout0_244ck820 FIND v(dout0_244) AT=415.025n

.meas tran vdout0_245ck820 FIND v(dout0_245) AT=415.025n

.meas tran vdout0_246ck820 FIND v(dout0_246) AT=415.025n

.meas tran vdout0_247ck820 FIND v(dout0_247) AT=415.025n

.meas tran vdout0_248ck820 FIND v(dout0_248) AT=415.025n

.meas tran vdout0_249ck820 FIND v(dout0_249) AT=415.025n

.meas tran vdout0_250ck820 FIND v(dout0_250) AT=415.025n

.meas tran vdout0_251ck820 FIND v(dout0_251) AT=415.025n

.meas tran vdout0_252ck820 FIND v(dout0_252) AT=415.025n

.meas tran vdout0_253ck820 FIND v(dout0_253) AT=415.025n

.meas tran vdout0_254ck820 FIND v(dout0_254) AT=415.025n

.meas tran vdout0_255ck820 FIND v(dout0_255) AT=415.025n

.meas tran vdout0_0ck850 FIND v(dout0_0) AT=430.025n

.meas tran vdout0_1ck850 FIND v(dout0_1) AT=430.025n

.meas tran vdout0_2ck850 FIND v(dout0_2) AT=430.025n

.meas tran vdout0_3ck850 FIND v(dout0_3) AT=430.025n

.meas tran vdout0_4ck850 FIND v(dout0_4) AT=430.025n

.meas tran vdout0_5ck850 FIND v(dout0_5) AT=430.025n

.meas tran vdout0_6ck850 FIND v(dout0_6) AT=430.025n

.meas tran vdout0_7ck850 FIND v(dout0_7) AT=430.025n

.meas tran vdout0_8ck850 FIND v(dout0_8) AT=430.025n

.meas tran vdout0_9ck850 FIND v(dout0_9) AT=430.025n

.meas tran vdout0_10ck850 FIND v(dout0_10) AT=430.025n

.meas tran vdout0_11ck850 FIND v(dout0_11) AT=430.025n

.meas tran vdout0_12ck850 FIND v(dout0_12) AT=430.025n

.meas tran vdout0_13ck850 FIND v(dout0_13) AT=430.025n

.meas tran vdout0_14ck850 FIND v(dout0_14) AT=430.025n

.meas tran vdout0_15ck850 FIND v(dout0_15) AT=430.025n

.meas tran vdout0_16ck850 FIND v(dout0_16) AT=430.025n

.meas tran vdout0_17ck850 FIND v(dout0_17) AT=430.025n

.meas tran vdout0_18ck850 FIND v(dout0_18) AT=430.025n

.meas tran vdout0_19ck850 FIND v(dout0_19) AT=430.025n

.meas tran vdout0_20ck850 FIND v(dout0_20) AT=430.025n

.meas tran vdout0_21ck850 FIND v(dout0_21) AT=430.025n

.meas tran vdout0_22ck850 FIND v(dout0_22) AT=430.025n

.meas tran vdout0_23ck850 FIND v(dout0_23) AT=430.025n

.meas tran vdout0_24ck850 FIND v(dout0_24) AT=430.025n

.meas tran vdout0_25ck850 FIND v(dout0_25) AT=430.025n

.meas tran vdout0_26ck850 FIND v(dout0_26) AT=430.025n

.meas tran vdout0_27ck850 FIND v(dout0_27) AT=430.025n

.meas tran vdout0_28ck850 FIND v(dout0_28) AT=430.025n

.meas tran vdout0_29ck850 FIND v(dout0_29) AT=430.025n

.meas tran vdout0_30ck850 FIND v(dout0_30) AT=430.025n

.meas tran vdout0_31ck850 FIND v(dout0_31) AT=430.025n

.meas tran vdout0_32ck850 FIND v(dout0_32) AT=430.025n

.meas tran vdout0_33ck850 FIND v(dout0_33) AT=430.025n

.meas tran vdout0_34ck850 FIND v(dout0_34) AT=430.025n

.meas tran vdout0_35ck850 FIND v(dout0_35) AT=430.025n

.meas tran vdout0_36ck850 FIND v(dout0_36) AT=430.025n

.meas tran vdout0_37ck850 FIND v(dout0_37) AT=430.025n

.meas tran vdout0_38ck850 FIND v(dout0_38) AT=430.025n

.meas tran vdout0_39ck850 FIND v(dout0_39) AT=430.025n

.meas tran vdout0_40ck850 FIND v(dout0_40) AT=430.025n

.meas tran vdout0_41ck850 FIND v(dout0_41) AT=430.025n

.meas tran vdout0_42ck850 FIND v(dout0_42) AT=430.025n

.meas tran vdout0_43ck850 FIND v(dout0_43) AT=430.025n

.meas tran vdout0_44ck850 FIND v(dout0_44) AT=430.025n

.meas tran vdout0_45ck850 FIND v(dout0_45) AT=430.025n

.meas tran vdout0_46ck850 FIND v(dout0_46) AT=430.025n

.meas tran vdout0_47ck850 FIND v(dout0_47) AT=430.025n

.meas tran vdout0_48ck850 FIND v(dout0_48) AT=430.025n

.meas tran vdout0_49ck850 FIND v(dout0_49) AT=430.025n

.meas tran vdout0_50ck850 FIND v(dout0_50) AT=430.025n

.meas tran vdout0_51ck850 FIND v(dout0_51) AT=430.025n

.meas tran vdout0_52ck850 FIND v(dout0_52) AT=430.025n

.meas tran vdout0_53ck850 FIND v(dout0_53) AT=430.025n

.meas tran vdout0_54ck850 FIND v(dout0_54) AT=430.025n

.meas tran vdout0_55ck850 FIND v(dout0_55) AT=430.025n

.meas tran vdout0_56ck850 FIND v(dout0_56) AT=430.025n

.meas tran vdout0_57ck850 FIND v(dout0_57) AT=430.025n

.meas tran vdout0_58ck850 FIND v(dout0_58) AT=430.025n

.meas tran vdout0_59ck850 FIND v(dout0_59) AT=430.025n

.meas tran vdout0_60ck850 FIND v(dout0_60) AT=430.025n

.meas tran vdout0_61ck850 FIND v(dout0_61) AT=430.025n

.meas tran vdout0_62ck850 FIND v(dout0_62) AT=430.025n

.meas tran vdout0_63ck850 FIND v(dout0_63) AT=430.025n

.meas tran vdout0_64ck850 FIND v(dout0_64) AT=430.025n

.meas tran vdout0_65ck850 FIND v(dout0_65) AT=430.025n

.meas tran vdout0_66ck850 FIND v(dout0_66) AT=430.025n

.meas tran vdout0_67ck850 FIND v(dout0_67) AT=430.025n

.meas tran vdout0_68ck850 FIND v(dout0_68) AT=430.025n

.meas tran vdout0_69ck850 FIND v(dout0_69) AT=430.025n

.meas tran vdout0_70ck850 FIND v(dout0_70) AT=430.025n

.meas tran vdout0_71ck850 FIND v(dout0_71) AT=430.025n

.meas tran vdout0_72ck850 FIND v(dout0_72) AT=430.025n

.meas tran vdout0_73ck850 FIND v(dout0_73) AT=430.025n

.meas tran vdout0_74ck850 FIND v(dout0_74) AT=430.025n

.meas tran vdout0_75ck850 FIND v(dout0_75) AT=430.025n

.meas tran vdout0_76ck850 FIND v(dout0_76) AT=430.025n

.meas tran vdout0_77ck850 FIND v(dout0_77) AT=430.025n

.meas tran vdout0_78ck850 FIND v(dout0_78) AT=430.025n

.meas tran vdout0_79ck850 FIND v(dout0_79) AT=430.025n

.meas tran vdout0_80ck850 FIND v(dout0_80) AT=430.025n

.meas tran vdout0_81ck850 FIND v(dout0_81) AT=430.025n

.meas tran vdout0_82ck850 FIND v(dout0_82) AT=430.025n

.meas tran vdout0_83ck850 FIND v(dout0_83) AT=430.025n

.meas tran vdout0_84ck850 FIND v(dout0_84) AT=430.025n

.meas tran vdout0_85ck850 FIND v(dout0_85) AT=430.025n

.meas tran vdout0_86ck850 FIND v(dout0_86) AT=430.025n

.meas tran vdout0_87ck850 FIND v(dout0_87) AT=430.025n

.meas tran vdout0_88ck850 FIND v(dout0_88) AT=430.025n

.meas tran vdout0_89ck850 FIND v(dout0_89) AT=430.025n

.meas tran vdout0_90ck850 FIND v(dout0_90) AT=430.025n

.meas tran vdout0_91ck850 FIND v(dout0_91) AT=430.025n

.meas tran vdout0_92ck850 FIND v(dout0_92) AT=430.025n

.meas tran vdout0_93ck850 FIND v(dout0_93) AT=430.025n

.meas tran vdout0_94ck850 FIND v(dout0_94) AT=430.025n

.meas tran vdout0_95ck850 FIND v(dout0_95) AT=430.025n

.meas tran vdout0_96ck850 FIND v(dout0_96) AT=430.025n

.meas tran vdout0_97ck850 FIND v(dout0_97) AT=430.025n

.meas tran vdout0_98ck850 FIND v(dout0_98) AT=430.025n

.meas tran vdout0_99ck850 FIND v(dout0_99) AT=430.025n

.meas tran vdout0_100ck850 FIND v(dout0_100) AT=430.025n

.meas tran vdout0_101ck850 FIND v(dout0_101) AT=430.025n

.meas tran vdout0_102ck850 FIND v(dout0_102) AT=430.025n

.meas tran vdout0_103ck850 FIND v(dout0_103) AT=430.025n

.meas tran vdout0_104ck850 FIND v(dout0_104) AT=430.025n

.meas tran vdout0_105ck850 FIND v(dout0_105) AT=430.025n

.meas tran vdout0_106ck850 FIND v(dout0_106) AT=430.025n

.meas tran vdout0_107ck850 FIND v(dout0_107) AT=430.025n

.meas tran vdout0_108ck850 FIND v(dout0_108) AT=430.025n

.meas tran vdout0_109ck850 FIND v(dout0_109) AT=430.025n

.meas tran vdout0_110ck850 FIND v(dout0_110) AT=430.025n

.meas tran vdout0_111ck850 FIND v(dout0_111) AT=430.025n

.meas tran vdout0_112ck850 FIND v(dout0_112) AT=430.025n

.meas tran vdout0_113ck850 FIND v(dout0_113) AT=430.025n

.meas tran vdout0_114ck850 FIND v(dout0_114) AT=430.025n

.meas tran vdout0_115ck850 FIND v(dout0_115) AT=430.025n

.meas tran vdout0_116ck850 FIND v(dout0_116) AT=430.025n

.meas tran vdout0_117ck850 FIND v(dout0_117) AT=430.025n

.meas tran vdout0_118ck850 FIND v(dout0_118) AT=430.025n

.meas tran vdout0_119ck850 FIND v(dout0_119) AT=430.025n

.meas tran vdout0_120ck850 FIND v(dout0_120) AT=430.025n

.meas tran vdout0_121ck850 FIND v(dout0_121) AT=430.025n

.meas tran vdout0_122ck850 FIND v(dout0_122) AT=430.025n

.meas tran vdout0_123ck850 FIND v(dout0_123) AT=430.025n

.meas tran vdout0_124ck850 FIND v(dout0_124) AT=430.025n

.meas tran vdout0_125ck850 FIND v(dout0_125) AT=430.025n

.meas tran vdout0_126ck850 FIND v(dout0_126) AT=430.025n

.meas tran vdout0_127ck850 FIND v(dout0_127) AT=430.025n

.meas tran vdout0_128ck850 FIND v(dout0_128) AT=430.025n

.meas tran vdout0_129ck850 FIND v(dout0_129) AT=430.025n

.meas tran vdout0_130ck850 FIND v(dout0_130) AT=430.025n

.meas tran vdout0_131ck850 FIND v(dout0_131) AT=430.025n

.meas tran vdout0_132ck850 FIND v(dout0_132) AT=430.025n

.meas tran vdout0_133ck850 FIND v(dout0_133) AT=430.025n

.meas tran vdout0_134ck850 FIND v(dout0_134) AT=430.025n

.meas tran vdout0_135ck850 FIND v(dout0_135) AT=430.025n

.meas tran vdout0_136ck850 FIND v(dout0_136) AT=430.025n

.meas tran vdout0_137ck850 FIND v(dout0_137) AT=430.025n

.meas tran vdout0_138ck850 FIND v(dout0_138) AT=430.025n

.meas tran vdout0_139ck850 FIND v(dout0_139) AT=430.025n

.meas tran vdout0_140ck850 FIND v(dout0_140) AT=430.025n

.meas tran vdout0_141ck850 FIND v(dout0_141) AT=430.025n

.meas tran vdout0_142ck850 FIND v(dout0_142) AT=430.025n

.meas tran vdout0_143ck850 FIND v(dout0_143) AT=430.025n

.meas tran vdout0_144ck850 FIND v(dout0_144) AT=430.025n

.meas tran vdout0_145ck850 FIND v(dout0_145) AT=430.025n

.meas tran vdout0_146ck850 FIND v(dout0_146) AT=430.025n

.meas tran vdout0_147ck850 FIND v(dout0_147) AT=430.025n

.meas tran vdout0_148ck850 FIND v(dout0_148) AT=430.025n

.meas tran vdout0_149ck850 FIND v(dout0_149) AT=430.025n

.meas tran vdout0_150ck850 FIND v(dout0_150) AT=430.025n

.meas tran vdout0_151ck850 FIND v(dout0_151) AT=430.025n

.meas tran vdout0_152ck850 FIND v(dout0_152) AT=430.025n

.meas tran vdout0_153ck850 FIND v(dout0_153) AT=430.025n

.meas tran vdout0_154ck850 FIND v(dout0_154) AT=430.025n

.meas tran vdout0_155ck850 FIND v(dout0_155) AT=430.025n

.meas tran vdout0_156ck850 FIND v(dout0_156) AT=430.025n

.meas tran vdout0_157ck850 FIND v(dout0_157) AT=430.025n

.meas tran vdout0_158ck850 FIND v(dout0_158) AT=430.025n

.meas tran vdout0_159ck850 FIND v(dout0_159) AT=430.025n

.meas tran vdout0_160ck850 FIND v(dout0_160) AT=430.025n

.meas tran vdout0_161ck850 FIND v(dout0_161) AT=430.025n

.meas tran vdout0_162ck850 FIND v(dout0_162) AT=430.025n

.meas tran vdout0_163ck850 FIND v(dout0_163) AT=430.025n

.meas tran vdout0_164ck850 FIND v(dout0_164) AT=430.025n

.meas tran vdout0_165ck850 FIND v(dout0_165) AT=430.025n

.meas tran vdout0_166ck850 FIND v(dout0_166) AT=430.025n

.meas tran vdout0_167ck850 FIND v(dout0_167) AT=430.025n

.meas tran vdout0_168ck850 FIND v(dout0_168) AT=430.025n

.meas tran vdout0_169ck850 FIND v(dout0_169) AT=430.025n

.meas tran vdout0_170ck850 FIND v(dout0_170) AT=430.025n

.meas tran vdout0_171ck850 FIND v(dout0_171) AT=430.025n

.meas tran vdout0_172ck850 FIND v(dout0_172) AT=430.025n

.meas tran vdout0_173ck850 FIND v(dout0_173) AT=430.025n

.meas tran vdout0_174ck850 FIND v(dout0_174) AT=430.025n

.meas tran vdout0_175ck850 FIND v(dout0_175) AT=430.025n

.meas tran vdout0_176ck850 FIND v(dout0_176) AT=430.025n

.meas tran vdout0_177ck850 FIND v(dout0_177) AT=430.025n

.meas tran vdout0_178ck850 FIND v(dout0_178) AT=430.025n

.meas tran vdout0_179ck850 FIND v(dout0_179) AT=430.025n

.meas tran vdout0_180ck850 FIND v(dout0_180) AT=430.025n

.meas tran vdout0_181ck850 FIND v(dout0_181) AT=430.025n

.meas tran vdout0_182ck850 FIND v(dout0_182) AT=430.025n

.meas tran vdout0_183ck850 FIND v(dout0_183) AT=430.025n

.meas tran vdout0_184ck850 FIND v(dout0_184) AT=430.025n

.meas tran vdout0_185ck850 FIND v(dout0_185) AT=430.025n

.meas tran vdout0_186ck850 FIND v(dout0_186) AT=430.025n

.meas tran vdout0_187ck850 FIND v(dout0_187) AT=430.025n

.meas tran vdout0_188ck850 FIND v(dout0_188) AT=430.025n

.meas tran vdout0_189ck850 FIND v(dout0_189) AT=430.025n

.meas tran vdout0_190ck850 FIND v(dout0_190) AT=430.025n

.meas tran vdout0_191ck850 FIND v(dout0_191) AT=430.025n

.meas tran vdout0_192ck850 FIND v(dout0_192) AT=430.025n

.meas tran vdout0_193ck850 FIND v(dout0_193) AT=430.025n

.meas tran vdout0_194ck850 FIND v(dout0_194) AT=430.025n

.meas tran vdout0_195ck850 FIND v(dout0_195) AT=430.025n

.meas tran vdout0_196ck850 FIND v(dout0_196) AT=430.025n

.meas tran vdout0_197ck850 FIND v(dout0_197) AT=430.025n

.meas tran vdout0_198ck850 FIND v(dout0_198) AT=430.025n

.meas tran vdout0_199ck850 FIND v(dout0_199) AT=430.025n

.meas tran vdout0_200ck850 FIND v(dout0_200) AT=430.025n

.meas tran vdout0_201ck850 FIND v(dout0_201) AT=430.025n

.meas tran vdout0_202ck850 FIND v(dout0_202) AT=430.025n

.meas tran vdout0_203ck850 FIND v(dout0_203) AT=430.025n

.meas tran vdout0_204ck850 FIND v(dout0_204) AT=430.025n

.meas tran vdout0_205ck850 FIND v(dout0_205) AT=430.025n

.meas tran vdout0_206ck850 FIND v(dout0_206) AT=430.025n

.meas tran vdout0_207ck850 FIND v(dout0_207) AT=430.025n

.meas tran vdout0_208ck850 FIND v(dout0_208) AT=430.025n

.meas tran vdout0_209ck850 FIND v(dout0_209) AT=430.025n

.meas tran vdout0_210ck850 FIND v(dout0_210) AT=430.025n

.meas tran vdout0_211ck850 FIND v(dout0_211) AT=430.025n

.meas tran vdout0_212ck850 FIND v(dout0_212) AT=430.025n

.meas tran vdout0_213ck850 FIND v(dout0_213) AT=430.025n

.meas tran vdout0_214ck850 FIND v(dout0_214) AT=430.025n

.meas tran vdout0_215ck850 FIND v(dout0_215) AT=430.025n

.meas tran vdout0_216ck850 FIND v(dout0_216) AT=430.025n

.meas tran vdout0_217ck850 FIND v(dout0_217) AT=430.025n

.meas tran vdout0_218ck850 FIND v(dout0_218) AT=430.025n

.meas tran vdout0_219ck850 FIND v(dout0_219) AT=430.025n

.meas tran vdout0_220ck850 FIND v(dout0_220) AT=430.025n

.meas tran vdout0_221ck850 FIND v(dout0_221) AT=430.025n

.meas tran vdout0_222ck850 FIND v(dout0_222) AT=430.025n

.meas tran vdout0_223ck850 FIND v(dout0_223) AT=430.025n

.meas tran vdout0_224ck850 FIND v(dout0_224) AT=430.025n

.meas tran vdout0_225ck850 FIND v(dout0_225) AT=430.025n

.meas tran vdout0_226ck850 FIND v(dout0_226) AT=430.025n

.meas tran vdout0_227ck850 FIND v(dout0_227) AT=430.025n

.meas tran vdout0_228ck850 FIND v(dout0_228) AT=430.025n

.meas tran vdout0_229ck850 FIND v(dout0_229) AT=430.025n

.meas tran vdout0_230ck850 FIND v(dout0_230) AT=430.025n

.meas tran vdout0_231ck850 FIND v(dout0_231) AT=430.025n

.meas tran vdout0_232ck850 FIND v(dout0_232) AT=430.025n

.meas tran vdout0_233ck850 FIND v(dout0_233) AT=430.025n

.meas tran vdout0_234ck850 FIND v(dout0_234) AT=430.025n

.meas tran vdout0_235ck850 FIND v(dout0_235) AT=430.025n

.meas tran vdout0_236ck850 FIND v(dout0_236) AT=430.025n

.meas tran vdout0_237ck850 FIND v(dout0_237) AT=430.025n

.meas tran vdout0_238ck850 FIND v(dout0_238) AT=430.025n

.meas tran vdout0_239ck850 FIND v(dout0_239) AT=430.025n

.meas tran vdout0_240ck850 FIND v(dout0_240) AT=430.025n

.meas tran vdout0_241ck850 FIND v(dout0_241) AT=430.025n

.meas tran vdout0_242ck850 FIND v(dout0_242) AT=430.025n

.meas tran vdout0_243ck850 FIND v(dout0_243) AT=430.025n

.meas tran vdout0_244ck850 FIND v(dout0_244) AT=430.025n

.meas tran vdout0_245ck850 FIND v(dout0_245) AT=430.025n

.meas tran vdout0_246ck850 FIND v(dout0_246) AT=430.025n

.meas tran vdout0_247ck850 FIND v(dout0_247) AT=430.025n

.meas tran vdout0_248ck850 FIND v(dout0_248) AT=430.025n

.meas tran vdout0_249ck850 FIND v(dout0_249) AT=430.025n

.meas tran vdout0_250ck850 FIND v(dout0_250) AT=430.025n

.meas tran vdout0_251ck850 FIND v(dout0_251) AT=430.025n

.meas tran vdout0_252ck850 FIND v(dout0_252) AT=430.025n

.meas tran vdout0_253ck850 FIND v(dout0_253) AT=430.025n

.meas tran vdout0_254ck850 FIND v(dout0_254) AT=430.025n

.meas tran vdout0_255ck850 FIND v(dout0_255) AT=430.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_128ck870 FIND v(dout0_128) AT=440.025n

.meas tran vdout0_129ck870 FIND v(dout0_129) AT=440.025n

.meas tran vdout0_130ck870 FIND v(dout0_130) AT=440.025n

.meas tran vdout0_131ck870 FIND v(dout0_131) AT=440.025n

.meas tran vdout0_132ck870 FIND v(dout0_132) AT=440.025n

.meas tran vdout0_133ck870 FIND v(dout0_133) AT=440.025n

.meas tran vdout0_134ck870 FIND v(dout0_134) AT=440.025n

.meas tran vdout0_135ck870 FIND v(dout0_135) AT=440.025n

.meas tran vdout0_136ck870 FIND v(dout0_136) AT=440.025n

.meas tran vdout0_137ck870 FIND v(dout0_137) AT=440.025n

.meas tran vdout0_138ck870 FIND v(dout0_138) AT=440.025n

.meas tran vdout0_139ck870 FIND v(dout0_139) AT=440.025n

.meas tran vdout0_140ck870 FIND v(dout0_140) AT=440.025n

.meas tran vdout0_141ck870 FIND v(dout0_141) AT=440.025n

.meas tran vdout0_142ck870 FIND v(dout0_142) AT=440.025n

.meas tran vdout0_143ck870 FIND v(dout0_143) AT=440.025n

.meas tran vdout0_144ck870 FIND v(dout0_144) AT=440.025n

.meas tran vdout0_145ck870 FIND v(dout0_145) AT=440.025n

.meas tran vdout0_146ck870 FIND v(dout0_146) AT=440.025n

.meas tran vdout0_147ck870 FIND v(dout0_147) AT=440.025n

.meas tran vdout0_148ck870 FIND v(dout0_148) AT=440.025n

.meas tran vdout0_149ck870 FIND v(dout0_149) AT=440.025n

.meas tran vdout0_150ck870 FIND v(dout0_150) AT=440.025n

.meas tran vdout0_151ck870 FIND v(dout0_151) AT=440.025n

.meas tran vdout0_152ck870 FIND v(dout0_152) AT=440.025n

.meas tran vdout0_153ck870 FIND v(dout0_153) AT=440.025n

.meas tran vdout0_154ck870 FIND v(dout0_154) AT=440.025n

.meas tran vdout0_155ck870 FIND v(dout0_155) AT=440.025n

.meas tran vdout0_156ck870 FIND v(dout0_156) AT=440.025n

.meas tran vdout0_157ck870 FIND v(dout0_157) AT=440.025n

.meas tran vdout0_158ck870 FIND v(dout0_158) AT=440.025n

.meas tran vdout0_159ck870 FIND v(dout0_159) AT=440.025n

.meas tran vdout0_160ck870 FIND v(dout0_160) AT=440.025n

.meas tran vdout0_161ck870 FIND v(dout0_161) AT=440.025n

.meas tran vdout0_162ck870 FIND v(dout0_162) AT=440.025n

.meas tran vdout0_163ck870 FIND v(dout0_163) AT=440.025n

.meas tran vdout0_164ck870 FIND v(dout0_164) AT=440.025n

.meas tran vdout0_165ck870 FIND v(dout0_165) AT=440.025n

.meas tran vdout0_166ck870 FIND v(dout0_166) AT=440.025n

.meas tran vdout0_167ck870 FIND v(dout0_167) AT=440.025n

.meas tran vdout0_168ck870 FIND v(dout0_168) AT=440.025n

.meas tran vdout0_169ck870 FIND v(dout0_169) AT=440.025n

.meas tran vdout0_170ck870 FIND v(dout0_170) AT=440.025n

.meas tran vdout0_171ck870 FIND v(dout0_171) AT=440.025n

.meas tran vdout0_172ck870 FIND v(dout0_172) AT=440.025n

.meas tran vdout0_173ck870 FIND v(dout0_173) AT=440.025n

.meas tran vdout0_174ck870 FIND v(dout0_174) AT=440.025n

.meas tran vdout0_175ck870 FIND v(dout0_175) AT=440.025n

.meas tran vdout0_176ck870 FIND v(dout0_176) AT=440.025n

.meas tran vdout0_177ck870 FIND v(dout0_177) AT=440.025n

.meas tran vdout0_178ck870 FIND v(dout0_178) AT=440.025n

.meas tran vdout0_179ck870 FIND v(dout0_179) AT=440.025n

.meas tran vdout0_180ck870 FIND v(dout0_180) AT=440.025n

.meas tran vdout0_181ck870 FIND v(dout0_181) AT=440.025n

.meas tran vdout0_182ck870 FIND v(dout0_182) AT=440.025n

.meas tran vdout0_183ck870 FIND v(dout0_183) AT=440.025n

.meas tran vdout0_184ck870 FIND v(dout0_184) AT=440.025n

.meas tran vdout0_185ck870 FIND v(dout0_185) AT=440.025n

.meas tran vdout0_186ck870 FIND v(dout0_186) AT=440.025n

.meas tran vdout0_187ck870 FIND v(dout0_187) AT=440.025n

.meas tran vdout0_188ck870 FIND v(dout0_188) AT=440.025n

.meas tran vdout0_189ck870 FIND v(dout0_189) AT=440.025n

.meas tran vdout0_190ck870 FIND v(dout0_190) AT=440.025n

.meas tran vdout0_191ck870 FIND v(dout0_191) AT=440.025n

.meas tran vdout0_192ck870 FIND v(dout0_192) AT=440.025n

.meas tran vdout0_193ck870 FIND v(dout0_193) AT=440.025n

.meas tran vdout0_194ck870 FIND v(dout0_194) AT=440.025n

.meas tran vdout0_195ck870 FIND v(dout0_195) AT=440.025n

.meas tran vdout0_196ck870 FIND v(dout0_196) AT=440.025n

.meas tran vdout0_197ck870 FIND v(dout0_197) AT=440.025n

.meas tran vdout0_198ck870 FIND v(dout0_198) AT=440.025n

.meas tran vdout0_199ck870 FIND v(dout0_199) AT=440.025n

.meas tran vdout0_200ck870 FIND v(dout0_200) AT=440.025n

.meas tran vdout0_201ck870 FIND v(dout0_201) AT=440.025n

.meas tran vdout0_202ck870 FIND v(dout0_202) AT=440.025n

.meas tran vdout0_203ck870 FIND v(dout0_203) AT=440.025n

.meas tran vdout0_204ck870 FIND v(dout0_204) AT=440.025n

.meas tran vdout0_205ck870 FIND v(dout0_205) AT=440.025n

.meas tran vdout0_206ck870 FIND v(dout0_206) AT=440.025n

.meas tran vdout0_207ck870 FIND v(dout0_207) AT=440.025n

.meas tran vdout0_208ck870 FIND v(dout0_208) AT=440.025n

.meas tran vdout0_209ck870 FIND v(dout0_209) AT=440.025n

.meas tran vdout0_210ck870 FIND v(dout0_210) AT=440.025n

.meas tran vdout0_211ck870 FIND v(dout0_211) AT=440.025n

.meas tran vdout0_212ck870 FIND v(dout0_212) AT=440.025n

.meas tran vdout0_213ck870 FIND v(dout0_213) AT=440.025n

.meas tran vdout0_214ck870 FIND v(dout0_214) AT=440.025n

.meas tran vdout0_215ck870 FIND v(dout0_215) AT=440.025n

.meas tran vdout0_216ck870 FIND v(dout0_216) AT=440.025n

.meas tran vdout0_217ck870 FIND v(dout0_217) AT=440.025n

.meas tran vdout0_218ck870 FIND v(dout0_218) AT=440.025n

.meas tran vdout0_219ck870 FIND v(dout0_219) AT=440.025n

.meas tran vdout0_220ck870 FIND v(dout0_220) AT=440.025n

.meas tran vdout0_221ck870 FIND v(dout0_221) AT=440.025n

.meas tran vdout0_222ck870 FIND v(dout0_222) AT=440.025n

.meas tran vdout0_223ck870 FIND v(dout0_223) AT=440.025n

.meas tran vdout0_224ck870 FIND v(dout0_224) AT=440.025n

.meas tran vdout0_225ck870 FIND v(dout0_225) AT=440.025n

.meas tran vdout0_226ck870 FIND v(dout0_226) AT=440.025n

.meas tran vdout0_227ck870 FIND v(dout0_227) AT=440.025n

.meas tran vdout0_228ck870 FIND v(dout0_228) AT=440.025n

.meas tran vdout0_229ck870 FIND v(dout0_229) AT=440.025n

.meas tran vdout0_230ck870 FIND v(dout0_230) AT=440.025n

.meas tran vdout0_231ck870 FIND v(dout0_231) AT=440.025n

.meas tran vdout0_232ck870 FIND v(dout0_232) AT=440.025n

.meas tran vdout0_233ck870 FIND v(dout0_233) AT=440.025n

.meas tran vdout0_234ck870 FIND v(dout0_234) AT=440.025n

.meas tran vdout0_235ck870 FIND v(dout0_235) AT=440.025n

.meas tran vdout0_236ck870 FIND v(dout0_236) AT=440.025n

.meas tran vdout0_237ck870 FIND v(dout0_237) AT=440.025n

.meas tran vdout0_238ck870 FIND v(dout0_238) AT=440.025n

.meas tran vdout0_239ck870 FIND v(dout0_239) AT=440.025n

.meas tran vdout0_240ck870 FIND v(dout0_240) AT=440.025n

.meas tran vdout0_241ck870 FIND v(dout0_241) AT=440.025n

.meas tran vdout0_242ck870 FIND v(dout0_242) AT=440.025n

.meas tran vdout0_243ck870 FIND v(dout0_243) AT=440.025n

.meas tran vdout0_244ck870 FIND v(dout0_244) AT=440.025n

.meas tran vdout0_245ck870 FIND v(dout0_245) AT=440.025n

.meas tran vdout0_246ck870 FIND v(dout0_246) AT=440.025n

.meas tran vdout0_247ck870 FIND v(dout0_247) AT=440.025n

.meas tran vdout0_248ck870 FIND v(dout0_248) AT=440.025n

.meas tran vdout0_249ck870 FIND v(dout0_249) AT=440.025n

.meas tran vdout0_250ck870 FIND v(dout0_250) AT=440.025n

.meas tran vdout0_251ck870 FIND v(dout0_251) AT=440.025n

.meas tran vdout0_252ck870 FIND v(dout0_252) AT=440.025n

.meas tran vdout0_253ck870 FIND v(dout0_253) AT=440.025n

.meas tran vdout0_254ck870 FIND v(dout0_254) AT=440.025n

.meas tran vdout0_255ck870 FIND v(dout0_255) AT=440.025n

.meas tran vdout0_0ck880 FIND v(dout0_0) AT=445.025n

.meas tran vdout0_1ck880 FIND v(dout0_1) AT=445.025n

.meas tran vdout0_2ck880 FIND v(dout0_2) AT=445.025n

.meas tran vdout0_3ck880 FIND v(dout0_3) AT=445.025n

.meas tran vdout0_4ck880 FIND v(dout0_4) AT=445.025n

.meas tran vdout0_5ck880 FIND v(dout0_5) AT=445.025n

.meas tran vdout0_6ck880 FIND v(dout0_6) AT=445.025n

.meas tran vdout0_7ck880 FIND v(dout0_7) AT=445.025n

.meas tran vdout0_8ck880 FIND v(dout0_8) AT=445.025n

.meas tran vdout0_9ck880 FIND v(dout0_9) AT=445.025n

.meas tran vdout0_10ck880 FIND v(dout0_10) AT=445.025n

.meas tran vdout0_11ck880 FIND v(dout0_11) AT=445.025n

.meas tran vdout0_12ck880 FIND v(dout0_12) AT=445.025n

.meas tran vdout0_13ck880 FIND v(dout0_13) AT=445.025n

.meas tran vdout0_14ck880 FIND v(dout0_14) AT=445.025n

.meas tran vdout0_15ck880 FIND v(dout0_15) AT=445.025n

.meas tran vdout0_16ck880 FIND v(dout0_16) AT=445.025n

.meas tran vdout0_17ck880 FIND v(dout0_17) AT=445.025n

.meas tran vdout0_18ck880 FIND v(dout0_18) AT=445.025n

.meas tran vdout0_19ck880 FIND v(dout0_19) AT=445.025n

.meas tran vdout0_20ck880 FIND v(dout0_20) AT=445.025n

.meas tran vdout0_21ck880 FIND v(dout0_21) AT=445.025n

.meas tran vdout0_22ck880 FIND v(dout0_22) AT=445.025n

.meas tran vdout0_23ck880 FIND v(dout0_23) AT=445.025n

.meas tran vdout0_24ck880 FIND v(dout0_24) AT=445.025n

.meas tran vdout0_25ck880 FIND v(dout0_25) AT=445.025n

.meas tran vdout0_26ck880 FIND v(dout0_26) AT=445.025n

.meas tran vdout0_27ck880 FIND v(dout0_27) AT=445.025n

.meas tran vdout0_28ck880 FIND v(dout0_28) AT=445.025n

.meas tran vdout0_29ck880 FIND v(dout0_29) AT=445.025n

.meas tran vdout0_30ck880 FIND v(dout0_30) AT=445.025n

.meas tran vdout0_31ck880 FIND v(dout0_31) AT=445.025n

.meas tran vdout0_32ck880 FIND v(dout0_32) AT=445.025n

.meas tran vdout0_33ck880 FIND v(dout0_33) AT=445.025n

.meas tran vdout0_34ck880 FIND v(dout0_34) AT=445.025n

.meas tran vdout0_35ck880 FIND v(dout0_35) AT=445.025n

.meas tran vdout0_36ck880 FIND v(dout0_36) AT=445.025n

.meas tran vdout0_37ck880 FIND v(dout0_37) AT=445.025n

.meas tran vdout0_38ck880 FIND v(dout0_38) AT=445.025n

.meas tran vdout0_39ck880 FIND v(dout0_39) AT=445.025n

.meas tran vdout0_40ck880 FIND v(dout0_40) AT=445.025n

.meas tran vdout0_41ck880 FIND v(dout0_41) AT=445.025n

.meas tran vdout0_42ck880 FIND v(dout0_42) AT=445.025n

.meas tran vdout0_43ck880 FIND v(dout0_43) AT=445.025n

.meas tran vdout0_44ck880 FIND v(dout0_44) AT=445.025n

.meas tran vdout0_45ck880 FIND v(dout0_45) AT=445.025n

.meas tran vdout0_46ck880 FIND v(dout0_46) AT=445.025n

.meas tran vdout0_47ck880 FIND v(dout0_47) AT=445.025n

.meas tran vdout0_48ck880 FIND v(dout0_48) AT=445.025n

.meas tran vdout0_49ck880 FIND v(dout0_49) AT=445.025n

.meas tran vdout0_50ck880 FIND v(dout0_50) AT=445.025n

.meas tran vdout0_51ck880 FIND v(dout0_51) AT=445.025n

.meas tran vdout0_52ck880 FIND v(dout0_52) AT=445.025n

.meas tran vdout0_53ck880 FIND v(dout0_53) AT=445.025n

.meas tran vdout0_54ck880 FIND v(dout0_54) AT=445.025n

.meas tran vdout0_55ck880 FIND v(dout0_55) AT=445.025n

.meas tran vdout0_56ck880 FIND v(dout0_56) AT=445.025n

.meas tran vdout0_57ck880 FIND v(dout0_57) AT=445.025n

.meas tran vdout0_58ck880 FIND v(dout0_58) AT=445.025n

.meas tran vdout0_59ck880 FIND v(dout0_59) AT=445.025n

.meas tran vdout0_60ck880 FIND v(dout0_60) AT=445.025n

.meas tran vdout0_61ck880 FIND v(dout0_61) AT=445.025n

.meas tran vdout0_62ck880 FIND v(dout0_62) AT=445.025n

.meas tran vdout0_63ck880 FIND v(dout0_63) AT=445.025n

.meas tran vdout0_64ck880 FIND v(dout0_64) AT=445.025n

.meas tran vdout0_65ck880 FIND v(dout0_65) AT=445.025n

.meas tran vdout0_66ck880 FIND v(dout0_66) AT=445.025n

.meas tran vdout0_67ck880 FIND v(dout0_67) AT=445.025n

.meas tran vdout0_68ck880 FIND v(dout0_68) AT=445.025n

.meas tran vdout0_69ck880 FIND v(dout0_69) AT=445.025n

.meas tran vdout0_70ck880 FIND v(dout0_70) AT=445.025n

.meas tran vdout0_71ck880 FIND v(dout0_71) AT=445.025n

.meas tran vdout0_72ck880 FIND v(dout0_72) AT=445.025n

.meas tran vdout0_73ck880 FIND v(dout0_73) AT=445.025n

.meas tran vdout0_74ck880 FIND v(dout0_74) AT=445.025n

.meas tran vdout0_75ck880 FIND v(dout0_75) AT=445.025n

.meas tran vdout0_76ck880 FIND v(dout0_76) AT=445.025n

.meas tran vdout0_77ck880 FIND v(dout0_77) AT=445.025n

.meas tran vdout0_78ck880 FIND v(dout0_78) AT=445.025n

.meas tran vdout0_79ck880 FIND v(dout0_79) AT=445.025n

.meas tran vdout0_80ck880 FIND v(dout0_80) AT=445.025n

.meas tran vdout0_81ck880 FIND v(dout0_81) AT=445.025n

.meas tran vdout0_82ck880 FIND v(dout0_82) AT=445.025n

.meas tran vdout0_83ck880 FIND v(dout0_83) AT=445.025n

.meas tran vdout0_84ck880 FIND v(dout0_84) AT=445.025n

.meas tran vdout0_85ck880 FIND v(dout0_85) AT=445.025n

.meas tran vdout0_86ck880 FIND v(dout0_86) AT=445.025n

.meas tran vdout0_87ck880 FIND v(dout0_87) AT=445.025n

.meas tran vdout0_88ck880 FIND v(dout0_88) AT=445.025n

.meas tran vdout0_89ck880 FIND v(dout0_89) AT=445.025n

.meas tran vdout0_90ck880 FIND v(dout0_90) AT=445.025n

.meas tran vdout0_91ck880 FIND v(dout0_91) AT=445.025n

.meas tran vdout0_92ck880 FIND v(dout0_92) AT=445.025n

.meas tran vdout0_93ck880 FIND v(dout0_93) AT=445.025n

.meas tran vdout0_94ck880 FIND v(dout0_94) AT=445.025n

.meas tran vdout0_95ck880 FIND v(dout0_95) AT=445.025n

.meas tran vdout0_96ck880 FIND v(dout0_96) AT=445.025n

.meas tran vdout0_97ck880 FIND v(dout0_97) AT=445.025n

.meas tran vdout0_98ck880 FIND v(dout0_98) AT=445.025n

.meas tran vdout0_99ck880 FIND v(dout0_99) AT=445.025n

.meas tran vdout0_100ck880 FIND v(dout0_100) AT=445.025n

.meas tran vdout0_101ck880 FIND v(dout0_101) AT=445.025n

.meas tran vdout0_102ck880 FIND v(dout0_102) AT=445.025n

.meas tran vdout0_103ck880 FIND v(dout0_103) AT=445.025n

.meas tran vdout0_104ck880 FIND v(dout0_104) AT=445.025n

.meas tran vdout0_105ck880 FIND v(dout0_105) AT=445.025n

.meas tran vdout0_106ck880 FIND v(dout0_106) AT=445.025n

.meas tran vdout0_107ck880 FIND v(dout0_107) AT=445.025n

.meas tran vdout0_108ck880 FIND v(dout0_108) AT=445.025n

.meas tran vdout0_109ck880 FIND v(dout0_109) AT=445.025n

.meas tran vdout0_110ck880 FIND v(dout0_110) AT=445.025n

.meas tran vdout0_111ck880 FIND v(dout0_111) AT=445.025n

.meas tran vdout0_112ck880 FIND v(dout0_112) AT=445.025n

.meas tran vdout0_113ck880 FIND v(dout0_113) AT=445.025n

.meas tran vdout0_114ck880 FIND v(dout0_114) AT=445.025n

.meas tran vdout0_115ck880 FIND v(dout0_115) AT=445.025n

.meas tran vdout0_116ck880 FIND v(dout0_116) AT=445.025n

.meas tran vdout0_117ck880 FIND v(dout0_117) AT=445.025n

.meas tran vdout0_118ck880 FIND v(dout0_118) AT=445.025n

.meas tran vdout0_119ck880 FIND v(dout0_119) AT=445.025n

.meas tran vdout0_120ck880 FIND v(dout0_120) AT=445.025n

.meas tran vdout0_121ck880 FIND v(dout0_121) AT=445.025n

.meas tran vdout0_122ck880 FIND v(dout0_122) AT=445.025n

.meas tran vdout0_123ck880 FIND v(dout0_123) AT=445.025n

.meas tran vdout0_124ck880 FIND v(dout0_124) AT=445.025n

.meas tran vdout0_125ck880 FIND v(dout0_125) AT=445.025n

.meas tran vdout0_126ck880 FIND v(dout0_126) AT=445.025n

.meas tran vdout0_127ck880 FIND v(dout0_127) AT=445.025n

.meas tran vdout0_128ck880 FIND v(dout0_128) AT=445.025n

.meas tran vdout0_129ck880 FIND v(dout0_129) AT=445.025n

.meas tran vdout0_130ck880 FIND v(dout0_130) AT=445.025n

.meas tran vdout0_131ck880 FIND v(dout0_131) AT=445.025n

.meas tran vdout0_132ck880 FIND v(dout0_132) AT=445.025n

.meas tran vdout0_133ck880 FIND v(dout0_133) AT=445.025n

.meas tran vdout0_134ck880 FIND v(dout0_134) AT=445.025n

.meas tran vdout0_135ck880 FIND v(dout0_135) AT=445.025n

.meas tran vdout0_136ck880 FIND v(dout0_136) AT=445.025n

.meas tran vdout0_137ck880 FIND v(dout0_137) AT=445.025n

.meas tran vdout0_138ck880 FIND v(dout0_138) AT=445.025n

.meas tran vdout0_139ck880 FIND v(dout0_139) AT=445.025n

.meas tran vdout0_140ck880 FIND v(dout0_140) AT=445.025n

.meas tran vdout0_141ck880 FIND v(dout0_141) AT=445.025n

.meas tran vdout0_142ck880 FIND v(dout0_142) AT=445.025n

.meas tran vdout0_143ck880 FIND v(dout0_143) AT=445.025n

.meas tran vdout0_144ck880 FIND v(dout0_144) AT=445.025n

.meas tran vdout0_145ck880 FIND v(dout0_145) AT=445.025n

.meas tran vdout0_146ck880 FIND v(dout0_146) AT=445.025n

.meas tran vdout0_147ck880 FIND v(dout0_147) AT=445.025n

.meas tran vdout0_148ck880 FIND v(dout0_148) AT=445.025n

.meas tran vdout0_149ck880 FIND v(dout0_149) AT=445.025n

.meas tran vdout0_150ck880 FIND v(dout0_150) AT=445.025n

.meas tran vdout0_151ck880 FIND v(dout0_151) AT=445.025n

.meas tran vdout0_152ck880 FIND v(dout0_152) AT=445.025n

.meas tran vdout0_153ck880 FIND v(dout0_153) AT=445.025n

.meas tran vdout0_154ck880 FIND v(dout0_154) AT=445.025n

.meas tran vdout0_155ck880 FIND v(dout0_155) AT=445.025n

.meas tran vdout0_156ck880 FIND v(dout0_156) AT=445.025n

.meas tran vdout0_157ck880 FIND v(dout0_157) AT=445.025n

.meas tran vdout0_158ck880 FIND v(dout0_158) AT=445.025n

.meas tran vdout0_159ck880 FIND v(dout0_159) AT=445.025n

.meas tran vdout0_160ck880 FIND v(dout0_160) AT=445.025n

.meas tran vdout0_161ck880 FIND v(dout0_161) AT=445.025n

.meas tran vdout0_162ck880 FIND v(dout0_162) AT=445.025n

.meas tran vdout0_163ck880 FIND v(dout0_163) AT=445.025n

.meas tran vdout0_164ck880 FIND v(dout0_164) AT=445.025n

.meas tran vdout0_165ck880 FIND v(dout0_165) AT=445.025n

.meas tran vdout0_166ck880 FIND v(dout0_166) AT=445.025n

.meas tran vdout0_167ck880 FIND v(dout0_167) AT=445.025n

.meas tran vdout0_168ck880 FIND v(dout0_168) AT=445.025n

.meas tran vdout0_169ck880 FIND v(dout0_169) AT=445.025n

.meas tran vdout0_170ck880 FIND v(dout0_170) AT=445.025n

.meas tran vdout0_171ck880 FIND v(dout0_171) AT=445.025n

.meas tran vdout0_172ck880 FIND v(dout0_172) AT=445.025n

.meas tran vdout0_173ck880 FIND v(dout0_173) AT=445.025n

.meas tran vdout0_174ck880 FIND v(dout0_174) AT=445.025n

.meas tran vdout0_175ck880 FIND v(dout0_175) AT=445.025n

.meas tran vdout0_176ck880 FIND v(dout0_176) AT=445.025n

.meas tran vdout0_177ck880 FIND v(dout0_177) AT=445.025n

.meas tran vdout0_178ck880 FIND v(dout0_178) AT=445.025n

.meas tran vdout0_179ck880 FIND v(dout0_179) AT=445.025n

.meas tran vdout0_180ck880 FIND v(dout0_180) AT=445.025n

.meas tran vdout0_181ck880 FIND v(dout0_181) AT=445.025n

.meas tran vdout0_182ck880 FIND v(dout0_182) AT=445.025n

.meas tran vdout0_183ck880 FIND v(dout0_183) AT=445.025n

.meas tran vdout0_184ck880 FIND v(dout0_184) AT=445.025n

.meas tran vdout0_185ck880 FIND v(dout0_185) AT=445.025n

.meas tran vdout0_186ck880 FIND v(dout0_186) AT=445.025n

.meas tran vdout0_187ck880 FIND v(dout0_187) AT=445.025n

.meas tran vdout0_188ck880 FIND v(dout0_188) AT=445.025n

.meas tran vdout0_189ck880 FIND v(dout0_189) AT=445.025n

.meas tran vdout0_190ck880 FIND v(dout0_190) AT=445.025n

.meas tran vdout0_191ck880 FIND v(dout0_191) AT=445.025n

.meas tran vdout0_192ck880 FIND v(dout0_192) AT=445.025n

.meas tran vdout0_193ck880 FIND v(dout0_193) AT=445.025n

.meas tran vdout0_194ck880 FIND v(dout0_194) AT=445.025n

.meas tran vdout0_195ck880 FIND v(dout0_195) AT=445.025n

.meas tran vdout0_196ck880 FIND v(dout0_196) AT=445.025n

.meas tran vdout0_197ck880 FIND v(dout0_197) AT=445.025n

.meas tran vdout0_198ck880 FIND v(dout0_198) AT=445.025n

.meas tran vdout0_199ck880 FIND v(dout0_199) AT=445.025n

.meas tran vdout0_200ck880 FIND v(dout0_200) AT=445.025n

.meas tran vdout0_201ck880 FIND v(dout0_201) AT=445.025n

.meas tran vdout0_202ck880 FIND v(dout0_202) AT=445.025n

.meas tran vdout0_203ck880 FIND v(dout0_203) AT=445.025n

.meas tran vdout0_204ck880 FIND v(dout0_204) AT=445.025n

.meas tran vdout0_205ck880 FIND v(dout0_205) AT=445.025n

.meas tran vdout0_206ck880 FIND v(dout0_206) AT=445.025n

.meas tran vdout0_207ck880 FIND v(dout0_207) AT=445.025n

.meas tran vdout0_208ck880 FIND v(dout0_208) AT=445.025n

.meas tran vdout0_209ck880 FIND v(dout0_209) AT=445.025n

.meas tran vdout0_210ck880 FIND v(dout0_210) AT=445.025n

.meas tran vdout0_211ck880 FIND v(dout0_211) AT=445.025n

.meas tran vdout0_212ck880 FIND v(dout0_212) AT=445.025n

.meas tran vdout0_213ck880 FIND v(dout0_213) AT=445.025n

.meas tran vdout0_214ck880 FIND v(dout0_214) AT=445.025n

.meas tran vdout0_215ck880 FIND v(dout0_215) AT=445.025n

.meas tran vdout0_216ck880 FIND v(dout0_216) AT=445.025n

.meas tran vdout0_217ck880 FIND v(dout0_217) AT=445.025n

.meas tran vdout0_218ck880 FIND v(dout0_218) AT=445.025n

.meas tran vdout0_219ck880 FIND v(dout0_219) AT=445.025n

.meas tran vdout0_220ck880 FIND v(dout0_220) AT=445.025n

.meas tran vdout0_221ck880 FIND v(dout0_221) AT=445.025n

.meas tran vdout0_222ck880 FIND v(dout0_222) AT=445.025n

.meas tran vdout0_223ck880 FIND v(dout0_223) AT=445.025n

.meas tran vdout0_224ck880 FIND v(dout0_224) AT=445.025n

.meas tran vdout0_225ck880 FIND v(dout0_225) AT=445.025n

.meas tran vdout0_226ck880 FIND v(dout0_226) AT=445.025n

.meas tran vdout0_227ck880 FIND v(dout0_227) AT=445.025n

.meas tran vdout0_228ck880 FIND v(dout0_228) AT=445.025n

.meas tran vdout0_229ck880 FIND v(dout0_229) AT=445.025n

.meas tran vdout0_230ck880 FIND v(dout0_230) AT=445.025n

.meas tran vdout0_231ck880 FIND v(dout0_231) AT=445.025n

.meas tran vdout0_232ck880 FIND v(dout0_232) AT=445.025n

.meas tran vdout0_233ck880 FIND v(dout0_233) AT=445.025n

.meas tran vdout0_234ck880 FIND v(dout0_234) AT=445.025n

.meas tran vdout0_235ck880 FIND v(dout0_235) AT=445.025n

.meas tran vdout0_236ck880 FIND v(dout0_236) AT=445.025n

.meas tran vdout0_237ck880 FIND v(dout0_237) AT=445.025n

.meas tran vdout0_238ck880 FIND v(dout0_238) AT=445.025n

.meas tran vdout0_239ck880 FIND v(dout0_239) AT=445.025n

.meas tran vdout0_240ck880 FIND v(dout0_240) AT=445.025n

.meas tran vdout0_241ck880 FIND v(dout0_241) AT=445.025n

.meas tran vdout0_242ck880 FIND v(dout0_242) AT=445.025n

.meas tran vdout0_243ck880 FIND v(dout0_243) AT=445.025n

.meas tran vdout0_244ck880 FIND v(dout0_244) AT=445.025n

.meas tran vdout0_245ck880 FIND v(dout0_245) AT=445.025n

.meas tran vdout0_246ck880 FIND v(dout0_246) AT=445.025n

.meas tran vdout0_247ck880 FIND v(dout0_247) AT=445.025n

.meas tran vdout0_248ck880 FIND v(dout0_248) AT=445.025n

.meas tran vdout0_249ck880 FIND v(dout0_249) AT=445.025n

.meas tran vdout0_250ck880 FIND v(dout0_250) AT=445.025n

.meas tran vdout0_251ck880 FIND v(dout0_251) AT=445.025n

.meas tran vdout0_252ck880 FIND v(dout0_252) AT=445.025n

.meas tran vdout0_253ck880 FIND v(dout0_253) AT=445.025n

.meas tran vdout0_254ck880 FIND v(dout0_254) AT=445.025n

.meas tran vdout0_255ck880 FIND v(dout0_255) AT=445.025n

.meas tran vdout0_0ck900 FIND v(dout0_0) AT=455.025n

.meas tran vdout0_1ck900 FIND v(dout0_1) AT=455.025n

.meas tran vdout0_2ck900 FIND v(dout0_2) AT=455.025n

.meas tran vdout0_3ck900 FIND v(dout0_3) AT=455.025n

.meas tran vdout0_4ck900 FIND v(dout0_4) AT=455.025n

.meas tran vdout0_5ck900 FIND v(dout0_5) AT=455.025n

.meas tran vdout0_6ck900 FIND v(dout0_6) AT=455.025n

.meas tran vdout0_7ck900 FIND v(dout0_7) AT=455.025n

.meas tran vdout0_8ck900 FIND v(dout0_8) AT=455.025n

.meas tran vdout0_9ck900 FIND v(dout0_9) AT=455.025n

.meas tran vdout0_10ck900 FIND v(dout0_10) AT=455.025n

.meas tran vdout0_11ck900 FIND v(dout0_11) AT=455.025n

.meas tran vdout0_12ck900 FIND v(dout0_12) AT=455.025n

.meas tran vdout0_13ck900 FIND v(dout0_13) AT=455.025n

.meas tran vdout0_14ck900 FIND v(dout0_14) AT=455.025n

.meas tran vdout0_15ck900 FIND v(dout0_15) AT=455.025n

.meas tran vdout0_16ck900 FIND v(dout0_16) AT=455.025n

.meas tran vdout0_17ck900 FIND v(dout0_17) AT=455.025n

.meas tran vdout0_18ck900 FIND v(dout0_18) AT=455.025n

.meas tran vdout0_19ck900 FIND v(dout0_19) AT=455.025n

.meas tran vdout0_20ck900 FIND v(dout0_20) AT=455.025n

.meas tran vdout0_21ck900 FIND v(dout0_21) AT=455.025n

.meas tran vdout0_22ck900 FIND v(dout0_22) AT=455.025n

.meas tran vdout0_23ck900 FIND v(dout0_23) AT=455.025n

.meas tran vdout0_24ck900 FIND v(dout0_24) AT=455.025n

.meas tran vdout0_25ck900 FIND v(dout0_25) AT=455.025n

.meas tran vdout0_26ck900 FIND v(dout0_26) AT=455.025n

.meas tran vdout0_27ck900 FIND v(dout0_27) AT=455.025n

.meas tran vdout0_28ck900 FIND v(dout0_28) AT=455.025n

.meas tran vdout0_29ck900 FIND v(dout0_29) AT=455.025n

.meas tran vdout0_30ck900 FIND v(dout0_30) AT=455.025n

.meas tran vdout0_31ck900 FIND v(dout0_31) AT=455.025n

.meas tran vdout0_32ck900 FIND v(dout0_32) AT=455.025n

.meas tran vdout0_33ck900 FIND v(dout0_33) AT=455.025n

.meas tran vdout0_34ck900 FIND v(dout0_34) AT=455.025n

.meas tran vdout0_35ck900 FIND v(dout0_35) AT=455.025n

.meas tran vdout0_36ck900 FIND v(dout0_36) AT=455.025n

.meas tran vdout0_37ck900 FIND v(dout0_37) AT=455.025n

.meas tran vdout0_38ck900 FIND v(dout0_38) AT=455.025n

.meas tran vdout0_39ck900 FIND v(dout0_39) AT=455.025n

.meas tran vdout0_40ck900 FIND v(dout0_40) AT=455.025n

.meas tran vdout0_41ck900 FIND v(dout0_41) AT=455.025n

.meas tran vdout0_42ck900 FIND v(dout0_42) AT=455.025n

.meas tran vdout0_43ck900 FIND v(dout0_43) AT=455.025n

.meas tran vdout0_44ck900 FIND v(dout0_44) AT=455.025n

.meas tran vdout0_45ck900 FIND v(dout0_45) AT=455.025n

.meas tran vdout0_46ck900 FIND v(dout0_46) AT=455.025n

.meas tran vdout0_47ck900 FIND v(dout0_47) AT=455.025n

.meas tran vdout0_48ck900 FIND v(dout0_48) AT=455.025n

.meas tran vdout0_49ck900 FIND v(dout0_49) AT=455.025n

.meas tran vdout0_50ck900 FIND v(dout0_50) AT=455.025n

.meas tran vdout0_51ck900 FIND v(dout0_51) AT=455.025n

.meas tran vdout0_52ck900 FIND v(dout0_52) AT=455.025n

.meas tran vdout0_53ck900 FIND v(dout0_53) AT=455.025n

.meas tran vdout0_54ck900 FIND v(dout0_54) AT=455.025n

.meas tran vdout0_55ck900 FIND v(dout0_55) AT=455.025n

.meas tran vdout0_56ck900 FIND v(dout0_56) AT=455.025n

.meas tran vdout0_57ck900 FIND v(dout0_57) AT=455.025n

.meas tran vdout0_58ck900 FIND v(dout0_58) AT=455.025n

.meas tran vdout0_59ck900 FIND v(dout0_59) AT=455.025n

.meas tran vdout0_60ck900 FIND v(dout0_60) AT=455.025n

.meas tran vdout0_61ck900 FIND v(dout0_61) AT=455.025n

.meas tran vdout0_62ck900 FIND v(dout0_62) AT=455.025n

.meas tran vdout0_63ck900 FIND v(dout0_63) AT=455.025n

.meas tran vdout0_64ck900 FIND v(dout0_64) AT=455.025n

.meas tran vdout0_65ck900 FIND v(dout0_65) AT=455.025n

.meas tran vdout0_66ck900 FIND v(dout0_66) AT=455.025n

.meas tran vdout0_67ck900 FIND v(dout0_67) AT=455.025n

.meas tran vdout0_68ck900 FIND v(dout0_68) AT=455.025n

.meas tran vdout0_69ck900 FIND v(dout0_69) AT=455.025n

.meas tran vdout0_70ck900 FIND v(dout0_70) AT=455.025n

.meas tran vdout0_71ck900 FIND v(dout0_71) AT=455.025n

.meas tran vdout0_72ck900 FIND v(dout0_72) AT=455.025n

.meas tran vdout0_73ck900 FIND v(dout0_73) AT=455.025n

.meas tran vdout0_74ck900 FIND v(dout0_74) AT=455.025n

.meas tran vdout0_75ck900 FIND v(dout0_75) AT=455.025n

.meas tran vdout0_76ck900 FIND v(dout0_76) AT=455.025n

.meas tran vdout0_77ck900 FIND v(dout0_77) AT=455.025n

.meas tran vdout0_78ck900 FIND v(dout0_78) AT=455.025n

.meas tran vdout0_79ck900 FIND v(dout0_79) AT=455.025n

.meas tran vdout0_80ck900 FIND v(dout0_80) AT=455.025n

.meas tran vdout0_81ck900 FIND v(dout0_81) AT=455.025n

.meas tran vdout0_82ck900 FIND v(dout0_82) AT=455.025n

.meas tran vdout0_83ck900 FIND v(dout0_83) AT=455.025n

.meas tran vdout0_84ck900 FIND v(dout0_84) AT=455.025n

.meas tran vdout0_85ck900 FIND v(dout0_85) AT=455.025n

.meas tran vdout0_86ck900 FIND v(dout0_86) AT=455.025n

.meas tran vdout0_87ck900 FIND v(dout0_87) AT=455.025n

.meas tran vdout0_88ck900 FIND v(dout0_88) AT=455.025n

.meas tran vdout0_89ck900 FIND v(dout0_89) AT=455.025n

.meas tran vdout0_90ck900 FIND v(dout0_90) AT=455.025n

.meas tran vdout0_91ck900 FIND v(dout0_91) AT=455.025n

.meas tran vdout0_92ck900 FIND v(dout0_92) AT=455.025n

.meas tran vdout0_93ck900 FIND v(dout0_93) AT=455.025n

.meas tran vdout0_94ck900 FIND v(dout0_94) AT=455.025n

.meas tran vdout0_95ck900 FIND v(dout0_95) AT=455.025n

.meas tran vdout0_96ck900 FIND v(dout0_96) AT=455.025n

.meas tran vdout0_97ck900 FIND v(dout0_97) AT=455.025n

.meas tran vdout0_98ck900 FIND v(dout0_98) AT=455.025n

.meas tran vdout0_99ck900 FIND v(dout0_99) AT=455.025n

.meas tran vdout0_100ck900 FIND v(dout0_100) AT=455.025n

.meas tran vdout0_101ck900 FIND v(dout0_101) AT=455.025n

.meas tran vdout0_102ck900 FIND v(dout0_102) AT=455.025n

.meas tran vdout0_103ck900 FIND v(dout0_103) AT=455.025n

.meas tran vdout0_104ck900 FIND v(dout0_104) AT=455.025n

.meas tran vdout0_105ck900 FIND v(dout0_105) AT=455.025n

.meas tran vdout0_106ck900 FIND v(dout0_106) AT=455.025n

.meas tran vdout0_107ck900 FIND v(dout0_107) AT=455.025n

.meas tran vdout0_108ck900 FIND v(dout0_108) AT=455.025n

.meas tran vdout0_109ck900 FIND v(dout0_109) AT=455.025n

.meas tran vdout0_110ck900 FIND v(dout0_110) AT=455.025n

.meas tran vdout0_111ck900 FIND v(dout0_111) AT=455.025n

.meas tran vdout0_112ck900 FIND v(dout0_112) AT=455.025n

.meas tran vdout0_113ck900 FIND v(dout0_113) AT=455.025n

.meas tran vdout0_114ck900 FIND v(dout0_114) AT=455.025n

.meas tran vdout0_115ck900 FIND v(dout0_115) AT=455.025n

.meas tran vdout0_116ck900 FIND v(dout0_116) AT=455.025n

.meas tran vdout0_117ck900 FIND v(dout0_117) AT=455.025n

.meas tran vdout0_118ck900 FIND v(dout0_118) AT=455.025n

.meas tran vdout0_119ck900 FIND v(dout0_119) AT=455.025n

.meas tran vdout0_120ck900 FIND v(dout0_120) AT=455.025n

.meas tran vdout0_121ck900 FIND v(dout0_121) AT=455.025n

.meas tran vdout0_122ck900 FIND v(dout0_122) AT=455.025n

.meas tran vdout0_123ck900 FIND v(dout0_123) AT=455.025n

.meas tran vdout0_124ck900 FIND v(dout0_124) AT=455.025n

.meas tran vdout0_125ck900 FIND v(dout0_125) AT=455.025n

.meas tran vdout0_126ck900 FIND v(dout0_126) AT=455.025n

.meas tran vdout0_127ck900 FIND v(dout0_127) AT=455.025n

.meas tran vdout0_128ck900 FIND v(dout0_128) AT=455.025n

.meas tran vdout0_129ck900 FIND v(dout0_129) AT=455.025n

.meas tran vdout0_130ck900 FIND v(dout0_130) AT=455.025n

.meas tran vdout0_131ck900 FIND v(dout0_131) AT=455.025n

.meas tran vdout0_132ck900 FIND v(dout0_132) AT=455.025n

.meas tran vdout0_133ck900 FIND v(dout0_133) AT=455.025n

.meas tran vdout0_134ck900 FIND v(dout0_134) AT=455.025n

.meas tran vdout0_135ck900 FIND v(dout0_135) AT=455.025n

.meas tran vdout0_136ck900 FIND v(dout0_136) AT=455.025n

.meas tran vdout0_137ck900 FIND v(dout0_137) AT=455.025n

.meas tran vdout0_138ck900 FIND v(dout0_138) AT=455.025n

.meas tran vdout0_139ck900 FIND v(dout0_139) AT=455.025n

.meas tran vdout0_140ck900 FIND v(dout0_140) AT=455.025n

.meas tran vdout0_141ck900 FIND v(dout0_141) AT=455.025n

.meas tran vdout0_142ck900 FIND v(dout0_142) AT=455.025n

.meas tran vdout0_143ck900 FIND v(dout0_143) AT=455.025n

.meas tran vdout0_144ck900 FIND v(dout0_144) AT=455.025n

.meas tran vdout0_145ck900 FIND v(dout0_145) AT=455.025n

.meas tran vdout0_146ck900 FIND v(dout0_146) AT=455.025n

.meas tran vdout0_147ck900 FIND v(dout0_147) AT=455.025n

.meas tran vdout0_148ck900 FIND v(dout0_148) AT=455.025n

.meas tran vdout0_149ck900 FIND v(dout0_149) AT=455.025n

.meas tran vdout0_150ck900 FIND v(dout0_150) AT=455.025n

.meas tran vdout0_151ck900 FIND v(dout0_151) AT=455.025n

.meas tran vdout0_152ck900 FIND v(dout0_152) AT=455.025n

.meas tran vdout0_153ck900 FIND v(dout0_153) AT=455.025n

.meas tran vdout0_154ck900 FIND v(dout0_154) AT=455.025n

.meas tran vdout0_155ck900 FIND v(dout0_155) AT=455.025n

.meas tran vdout0_156ck900 FIND v(dout0_156) AT=455.025n

.meas tran vdout0_157ck900 FIND v(dout0_157) AT=455.025n

.meas tran vdout0_158ck900 FIND v(dout0_158) AT=455.025n

.meas tran vdout0_159ck900 FIND v(dout0_159) AT=455.025n

.meas tran vdout0_160ck900 FIND v(dout0_160) AT=455.025n

.meas tran vdout0_161ck900 FIND v(dout0_161) AT=455.025n

.meas tran vdout0_162ck900 FIND v(dout0_162) AT=455.025n

.meas tran vdout0_163ck900 FIND v(dout0_163) AT=455.025n

.meas tran vdout0_164ck900 FIND v(dout0_164) AT=455.025n

.meas tran vdout0_165ck900 FIND v(dout0_165) AT=455.025n

.meas tran vdout0_166ck900 FIND v(dout0_166) AT=455.025n

.meas tran vdout0_167ck900 FIND v(dout0_167) AT=455.025n

.meas tran vdout0_168ck900 FIND v(dout0_168) AT=455.025n

.meas tran vdout0_169ck900 FIND v(dout0_169) AT=455.025n

.meas tran vdout0_170ck900 FIND v(dout0_170) AT=455.025n

.meas tran vdout0_171ck900 FIND v(dout0_171) AT=455.025n

.meas tran vdout0_172ck900 FIND v(dout0_172) AT=455.025n

.meas tran vdout0_173ck900 FIND v(dout0_173) AT=455.025n

.meas tran vdout0_174ck900 FIND v(dout0_174) AT=455.025n

.meas tran vdout0_175ck900 FIND v(dout0_175) AT=455.025n

.meas tran vdout0_176ck900 FIND v(dout0_176) AT=455.025n

.meas tran vdout0_177ck900 FIND v(dout0_177) AT=455.025n

.meas tran vdout0_178ck900 FIND v(dout0_178) AT=455.025n

.meas tran vdout0_179ck900 FIND v(dout0_179) AT=455.025n

.meas tran vdout0_180ck900 FIND v(dout0_180) AT=455.025n

.meas tran vdout0_181ck900 FIND v(dout0_181) AT=455.025n

.meas tran vdout0_182ck900 FIND v(dout0_182) AT=455.025n

.meas tran vdout0_183ck900 FIND v(dout0_183) AT=455.025n

.meas tran vdout0_184ck900 FIND v(dout0_184) AT=455.025n

.meas tran vdout0_185ck900 FIND v(dout0_185) AT=455.025n

.meas tran vdout0_186ck900 FIND v(dout0_186) AT=455.025n

.meas tran vdout0_187ck900 FIND v(dout0_187) AT=455.025n

.meas tran vdout0_188ck900 FIND v(dout0_188) AT=455.025n

.meas tran vdout0_189ck900 FIND v(dout0_189) AT=455.025n

.meas tran vdout0_190ck900 FIND v(dout0_190) AT=455.025n

.meas tran vdout0_191ck900 FIND v(dout0_191) AT=455.025n

.meas tran vdout0_192ck900 FIND v(dout0_192) AT=455.025n

.meas tran vdout0_193ck900 FIND v(dout0_193) AT=455.025n

.meas tran vdout0_194ck900 FIND v(dout0_194) AT=455.025n

.meas tran vdout0_195ck900 FIND v(dout0_195) AT=455.025n

.meas tran vdout0_196ck900 FIND v(dout0_196) AT=455.025n

.meas tran vdout0_197ck900 FIND v(dout0_197) AT=455.025n

.meas tran vdout0_198ck900 FIND v(dout0_198) AT=455.025n

.meas tran vdout0_199ck900 FIND v(dout0_199) AT=455.025n

.meas tran vdout0_200ck900 FIND v(dout0_200) AT=455.025n

.meas tran vdout0_201ck900 FIND v(dout0_201) AT=455.025n

.meas tran vdout0_202ck900 FIND v(dout0_202) AT=455.025n

.meas tran vdout0_203ck900 FIND v(dout0_203) AT=455.025n

.meas tran vdout0_204ck900 FIND v(dout0_204) AT=455.025n

.meas tran vdout0_205ck900 FIND v(dout0_205) AT=455.025n

.meas tran vdout0_206ck900 FIND v(dout0_206) AT=455.025n

.meas tran vdout0_207ck900 FIND v(dout0_207) AT=455.025n

.meas tran vdout0_208ck900 FIND v(dout0_208) AT=455.025n

.meas tran vdout0_209ck900 FIND v(dout0_209) AT=455.025n

.meas tran vdout0_210ck900 FIND v(dout0_210) AT=455.025n

.meas tran vdout0_211ck900 FIND v(dout0_211) AT=455.025n

.meas tran vdout0_212ck900 FIND v(dout0_212) AT=455.025n

.meas tran vdout0_213ck900 FIND v(dout0_213) AT=455.025n

.meas tran vdout0_214ck900 FIND v(dout0_214) AT=455.025n

.meas tran vdout0_215ck900 FIND v(dout0_215) AT=455.025n

.meas tran vdout0_216ck900 FIND v(dout0_216) AT=455.025n

.meas tran vdout0_217ck900 FIND v(dout0_217) AT=455.025n

.meas tran vdout0_218ck900 FIND v(dout0_218) AT=455.025n

.meas tran vdout0_219ck900 FIND v(dout0_219) AT=455.025n

.meas tran vdout0_220ck900 FIND v(dout0_220) AT=455.025n

.meas tran vdout0_221ck900 FIND v(dout0_221) AT=455.025n

.meas tran vdout0_222ck900 FIND v(dout0_222) AT=455.025n

.meas tran vdout0_223ck900 FIND v(dout0_223) AT=455.025n

.meas tran vdout0_224ck900 FIND v(dout0_224) AT=455.025n

.meas tran vdout0_225ck900 FIND v(dout0_225) AT=455.025n

.meas tran vdout0_226ck900 FIND v(dout0_226) AT=455.025n

.meas tran vdout0_227ck900 FIND v(dout0_227) AT=455.025n

.meas tran vdout0_228ck900 FIND v(dout0_228) AT=455.025n

.meas tran vdout0_229ck900 FIND v(dout0_229) AT=455.025n

.meas tran vdout0_230ck900 FIND v(dout0_230) AT=455.025n

.meas tran vdout0_231ck900 FIND v(dout0_231) AT=455.025n

.meas tran vdout0_232ck900 FIND v(dout0_232) AT=455.025n

.meas tran vdout0_233ck900 FIND v(dout0_233) AT=455.025n

.meas tran vdout0_234ck900 FIND v(dout0_234) AT=455.025n

.meas tran vdout0_235ck900 FIND v(dout0_235) AT=455.025n

.meas tran vdout0_236ck900 FIND v(dout0_236) AT=455.025n

.meas tran vdout0_237ck900 FIND v(dout0_237) AT=455.025n

.meas tran vdout0_238ck900 FIND v(dout0_238) AT=455.025n

.meas tran vdout0_239ck900 FIND v(dout0_239) AT=455.025n

.meas tran vdout0_240ck900 FIND v(dout0_240) AT=455.025n

.meas tran vdout0_241ck900 FIND v(dout0_241) AT=455.025n

.meas tran vdout0_242ck900 FIND v(dout0_242) AT=455.025n

.meas tran vdout0_243ck900 FIND v(dout0_243) AT=455.025n

.meas tran vdout0_244ck900 FIND v(dout0_244) AT=455.025n

.meas tran vdout0_245ck900 FIND v(dout0_245) AT=455.025n

.meas tran vdout0_246ck900 FIND v(dout0_246) AT=455.025n

.meas tran vdout0_247ck900 FIND v(dout0_247) AT=455.025n

.meas tran vdout0_248ck900 FIND v(dout0_248) AT=455.025n

.meas tran vdout0_249ck900 FIND v(dout0_249) AT=455.025n

.meas tran vdout0_250ck900 FIND v(dout0_250) AT=455.025n

.meas tran vdout0_251ck900 FIND v(dout0_251) AT=455.025n

.meas tran vdout0_252ck900 FIND v(dout0_252) AT=455.025n

.meas tran vdout0_253ck900 FIND v(dout0_253) AT=455.025n

.meas tran vdout0_254ck900 FIND v(dout0_254) AT=455.025n

.meas tran vdout0_255ck900 FIND v(dout0_255) AT=455.025n

.meas tran vdout0_0ck920 FIND v(dout0_0) AT=465.025n

.meas tran vdout0_1ck920 FIND v(dout0_1) AT=465.025n

.meas tran vdout0_2ck920 FIND v(dout0_2) AT=465.025n

.meas tran vdout0_3ck920 FIND v(dout0_3) AT=465.025n

.meas tran vdout0_4ck920 FIND v(dout0_4) AT=465.025n

.meas tran vdout0_5ck920 FIND v(dout0_5) AT=465.025n

.meas tran vdout0_6ck920 FIND v(dout0_6) AT=465.025n

.meas tran vdout0_7ck920 FIND v(dout0_7) AT=465.025n

.meas tran vdout0_8ck920 FIND v(dout0_8) AT=465.025n

.meas tran vdout0_9ck920 FIND v(dout0_9) AT=465.025n

.meas tran vdout0_10ck920 FIND v(dout0_10) AT=465.025n

.meas tran vdout0_11ck920 FIND v(dout0_11) AT=465.025n

.meas tran vdout0_12ck920 FIND v(dout0_12) AT=465.025n

.meas tran vdout0_13ck920 FIND v(dout0_13) AT=465.025n

.meas tran vdout0_14ck920 FIND v(dout0_14) AT=465.025n

.meas tran vdout0_15ck920 FIND v(dout0_15) AT=465.025n

.meas tran vdout0_16ck920 FIND v(dout0_16) AT=465.025n

.meas tran vdout0_17ck920 FIND v(dout0_17) AT=465.025n

.meas tran vdout0_18ck920 FIND v(dout0_18) AT=465.025n

.meas tran vdout0_19ck920 FIND v(dout0_19) AT=465.025n

.meas tran vdout0_20ck920 FIND v(dout0_20) AT=465.025n

.meas tran vdout0_21ck920 FIND v(dout0_21) AT=465.025n

.meas tran vdout0_22ck920 FIND v(dout0_22) AT=465.025n

.meas tran vdout0_23ck920 FIND v(dout0_23) AT=465.025n

.meas tran vdout0_24ck920 FIND v(dout0_24) AT=465.025n

.meas tran vdout0_25ck920 FIND v(dout0_25) AT=465.025n

.meas tran vdout0_26ck920 FIND v(dout0_26) AT=465.025n

.meas tran vdout0_27ck920 FIND v(dout0_27) AT=465.025n

.meas tran vdout0_28ck920 FIND v(dout0_28) AT=465.025n

.meas tran vdout0_29ck920 FIND v(dout0_29) AT=465.025n

.meas tran vdout0_30ck920 FIND v(dout0_30) AT=465.025n

.meas tran vdout0_31ck920 FIND v(dout0_31) AT=465.025n

.meas tran vdout0_32ck920 FIND v(dout0_32) AT=465.025n

.meas tran vdout0_33ck920 FIND v(dout0_33) AT=465.025n

.meas tran vdout0_34ck920 FIND v(dout0_34) AT=465.025n

.meas tran vdout0_35ck920 FIND v(dout0_35) AT=465.025n

.meas tran vdout0_36ck920 FIND v(dout0_36) AT=465.025n

.meas tran vdout0_37ck920 FIND v(dout0_37) AT=465.025n

.meas tran vdout0_38ck920 FIND v(dout0_38) AT=465.025n

.meas tran vdout0_39ck920 FIND v(dout0_39) AT=465.025n

.meas tran vdout0_40ck920 FIND v(dout0_40) AT=465.025n

.meas tran vdout0_41ck920 FIND v(dout0_41) AT=465.025n

.meas tran vdout0_42ck920 FIND v(dout0_42) AT=465.025n

.meas tran vdout0_43ck920 FIND v(dout0_43) AT=465.025n

.meas tran vdout0_44ck920 FIND v(dout0_44) AT=465.025n

.meas tran vdout0_45ck920 FIND v(dout0_45) AT=465.025n

.meas tran vdout0_46ck920 FIND v(dout0_46) AT=465.025n

.meas tran vdout0_47ck920 FIND v(dout0_47) AT=465.025n

.meas tran vdout0_48ck920 FIND v(dout0_48) AT=465.025n

.meas tran vdout0_49ck920 FIND v(dout0_49) AT=465.025n

.meas tran vdout0_50ck920 FIND v(dout0_50) AT=465.025n

.meas tran vdout0_51ck920 FIND v(dout0_51) AT=465.025n

.meas tran vdout0_52ck920 FIND v(dout0_52) AT=465.025n

.meas tran vdout0_53ck920 FIND v(dout0_53) AT=465.025n

.meas tran vdout0_54ck920 FIND v(dout0_54) AT=465.025n

.meas tran vdout0_55ck920 FIND v(dout0_55) AT=465.025n

.meas tran vdout0_56ck920 FIND v(dout0_56) AT=465.025n

.meas tran vdout0_57ck920 FIND v(dout0_57) AT=465.025n

.meas tran vdout0_58ck920 FIND v(dout0_58) AT=465.025n

.meas tran vdout0_59ck920 FIND v(dout0_59) AT=465.025n

.meas tran vdout0_60ck920 FIND v(dout0_60) AT=465.025n

.meas tran vdout0_61ck920 FIND v(dout0_61) AT=465.025n

.meas tran vdout0_62ck920 FIND v(dout0_62) AT=465.025n

.meas tran vdout0_63ck920 FIND v(dout0_63) AT=465.025n

.meas tran vdout0_64ck920 FIND v(dout0_64) AT=465.025n

.meas tran vdout0_65ck920 FIND v(dout0_65) AT=465.025n

.meas tran vdout0_66ck920 FIND v(dout0_66) AT=465.025n

.meas tran vdout0_67ck920 FIND v(dout0_67) AT=465.025n

.meas tran vdout0_68ck920 FIND v(dout0_68) AT=465.025n

.meas tran vdout0_69ck920 FIND v(dout0_69) AT=465.025n

.meas tran vdout0_70ck920 FIND v(dout0_70) AT=465.025n

.meas tran vdout0_71ck920 FIND v(dout0_71) AT=465.025n

.meas tran vdout0_72ck920 FIND v(dout0_72) AT=465.025n

.meas tran vdout0_73ck920 FIND v(dout0_73) AT=465.025n

.meas tran vdout0_74ck920 FIND v(dout0_74) AT=465.025n

.meas tran vdout0_75ck920 FIND v(dout0_75) AT=465.025n

.meas tran vdout0_76ck920 FIND v(dout0_76) AT=465.025n

.meas tran vdout0_77ck920 FIND v(dout0_77) AT=465.025n

.meas tran vdout0_78ck920 FIND v(dout0_78) AT=465.025n

.meas tran vdout0_79ck920 FIND v(dout0_79) AT=465.025n

.meas tran vdout0_80ck920 FIND v(dout0_80) AT=465.025n

.meas tran vdout0_81ck920 FIND v(dout0_81) AT=465.025n

.meas tran vdout0_82ck920 FIND v(dout0_82) AT=465.025n

.meas tran vdout0_83ck920 FIND v(dout0_83) AT=465.025n

.meas tran vdout0_84ck920 FIND v(dout0_84) AT=465.025n

.meas tran vdout0_85ck920 FIND v(dout0_85) AT=465.025n

.meas tran vdout0_86ck920 FIND v(dout0_86) AT=465.025n

.meas tran vdout0_87ck920 FIND v(dout0_87) AT=465.025n

.meas tran vdout0_88ck920 FIND v(dout0_88) AT=465.025n

.meas tran vdout0_89ck920 FIND v(dout0_89) AT=465.025n

.meas tran vdout0_90ck920 FIND v(dout0_90) AT=465.025n

.meas tran vdout0_91ck920 FIND v(dout0_91) AT=465.025n

.meas tran vdout0_92ck920 FIND v(dout0_92) AT=465.025n

.meas tran vdout0_93ck920 FIND v(dout0_93) AT=465.025n

.meas tran vdout0_94ck920 FIND v(dout0_94) AT=465.025n

.meas tran vdout0_95ck920 FIND v(dout0_95) AT=465.025n

.meas tran vdout0_96ck920 FIND v(dout0_96) AT=465.025n

.meas tran vdout0_97ck920 FIND v(dout0_97) AT=465.025n

.meas tran vdout0_98ck920 FIND v(dout0_98) AT=465.025n

.meas tran vdout0_99ck920 FIND v(dout0_99) AT=465.025n

.meas tran vdout0_100ck920 FIND v(dout0_100) AT=465.025n

.meas tran vdout0_101ck920 FIND v(dout0_101) AT=465.025n

.meas tran vdout0_102ck920 FIND v(dout0_102) AT=465.025n

.meas tran vdout0_103ck920 FIND v(dout0_103) AT=465.025n

.meas tran vdout0_104ck920 FIND v(dout0_104) AT=465.025n

.meas tran vdout0_105ck920 FIND v(dout0_105) AT=465.025n

.meas tran vdout0_106ck920 FIND v(dout0_106) AT=465.025n

.meas tran vdout0_107ck920 FIND v(dout0_107) AT=465.025n

.meas tran vdout0_108ck920 FIND v(dout0_108) AT=465.025n

.meas tran vdout0_109ck920 FIND v(dout0_109) AT=465.025n

.meas tran vdout0_110ck920 FIND v(dout0_110) AT=465.025n

.meas tran vdout0_111ck920 FIND v(dout0_111) AT=465.025n

.meas tran vdout0_112ck920 FIND v(dout0_112) AT=465.025n

.meas tran vdout0_113ck920 FIND v(dout0_113) AT=465.025n

.meas tran vdout0_114ck920 FIND v(dout0_114) AT=465.025n

.meas tran vdout0_115ck920 FIND v(dout0_115) AT=465.025n

.meas tran vdout0_116ck920 FIND v(dout0_116) AT=465.025n

.meas tran vdout0_117ck920 FIND v(dout0_117) AT=465.025n

.meas tran vdout0_118ck920 FIND v(dout0_118) AT=465.025n

.meas tran vdout0_119ck920 FIND v(dout0_119) AT=465.025n

.meas tran vdout0_120ck920 FIND v(dout0_120) AT=465.025n

.meas tran vdout0_121ck920 FIND v(dout0_121) AT=465.025n

.meas tran vdout0_122ck920 FIND v(dout0_122) AT=465.025n

.meas tran vdout0_123ck920 FIND v(dout0_123) AT=465.025n

.meas tran vdout0_124ck920 FIND v(dout0_124) AT=465.025n

.meas tran vdout0_125ck920 FIND v(dout0_125) AT=465.025n

.meas tran vdout0_126ck920 FIND v(dout0_126) AT=465.025n

.meas tran vdout0_127ck920 FIND v(dout0_127) AT=465.025n

.meas tran vdout0_128ck920 FIND v(dout0_128) AT=465.025n

.meas tran vdout0_129ck920 FIND v(dout0_129) AT=465.025n

.meas tran vdout0_130ck920 FIND v(dout0_130) AT=465.025n

.meas tran vdout0_131ck920 FIND v(dout0_131) AT=465.025n

.meas tran vdout0_132ck920 FIND v(dout0_132) AT=465.025n

.meas tran vdout0_133ck920 FIND v(dout0_133) AT=465.025n

.meas tran vdout0_134ck920 FIND v(dout0_134) AT=465.025n

.meas tran vdout0_135ck920 FIND v(dout0_135) AT=465.025n

.meas tran vdout0_136ck920 FIND v(dout0_136) AT=465.025n

.meas tran vdout0_137ck920 FIND v(dout0_137) AT=465.025n

.meas tran vdout0_138ck920 FIND v(dout0_138) AT=465.025n

.meas tran vdout0_139ck920 FIND v(dout0_139) AT=465.025n

.meas tran vdout0_140ck920 FIND v(dout0_140) AT=465.025n

.meas tran vdout0_141ck920 FIND v(dout0_141) AT=465.025n

.meas tran vdout0_142ck920 FIND v(dout0_142) AT=465.025n

.meas tran vdout0_143ck920 FIND v(dout0_143) AT=465.025n

.meas tran vdout0_144ck920 FIND v(dout0_144) AT=465.025n

.meas tran vdout0_145ck920 FIND v(dout0_145) AT=465.025n

.meas tran vdout0_146ck920 FIND v(dout0_146) AT=465.025n

.meas tran vdout0_147ck920 FIND v(dout0_147) AT=465.025n

.meas tran vdout0_148ck920 FIND v(dout0_148) AT=465.025n

.meas tran vdout0_149ck920 FIND v(dout0_149) AT=465.025n

.meas tran vdout0_150ck920 FIND v(dout0_150) AT=465.025n

.meas tran vdout0_151ck920 FIND v(dout0_151) AT=465.025n

.meas tran vdout0_152ck920 FIND v(dout0_152) AT=465.025n

.meas tran vdout0_153ck920 FIND v(dout0_153) AT=465.025n

.meas tran vdout0_154ck920 FIND v(dout0_154) AT=465.025n

.meas tran vdout0_155ck920 FIND v(dout0_155) AT=465.025n

.meas tran vdout0_156ck920 FIND v(dout0_156) AT=465.025n

.meas tran vdout0_157ck920 FIND v(dout0_157) AT=465.025n

.meas tran vdout0_158ck920 FIND v(dout0_158) AT=465.025n

.meas tran vdout0_159ck920 FIND v(dout0_159) AT=465.025n

.meas tran vdout0_160ck920 FIND v(dout0_160) AT=465.025n

.meas tran vdout0_161ck920 FIND v(dout0_161) AT=465.025n

.meas tran vdout0_162ck920 FIND v(dout0_162) AT=465.025n

.meas tran vdout0_163ck920 FIND v(dout0_163) AT=465.025n

.meas tran vdout0_164ck920 FIND v(dout0_164) AT=465.025n

.meas tran vdout0_165ck920 FIND v(dout0_165) AT=465.025n

.meas tran vdout0_166ck920 FIND v(dout0_166) AT=465.025n

.meas tran vdout0_167ck920 FIND v(dout0_167) AT=465.025n

.meas tran vdout0_168ck920 FIND v(dout0_168) AT=465.025n

.meas tran vdout0_169ck920 FIND v(dout0_169) AT=465.025n

.meas tran vdout0_170ck920 FIND v(dout0_170) AT=465.025n

.meas tran vdout0_171ck920 FIND v(dout0_171) AT=465.025n

.meas tran vdout0_172ck920 FIND v(dout0_172) AT=465.025n

.meas tran vdout0_173ck920 FIND v(dout0_173) AT=465.025n

.meas tran vdout0_174ck920 FIND v(dout0_174) AT=465.025n

.meas tran vdout0_175ck920 FIND v(dout0_175) AT=465.025n

.meas tran vdout0_176ck920 FIND v(dout0_176) AT=465.025n

.meas tran vdout0_177ck920 FIND v(dout0_177) AT=465.025n

.meas tran vdout0_178ck920 FIND v(dout0_178) AT=465.025n

.meas tran vdout0_179ck920 FIND v(dout0_179) AT=465.025n

.meas tran vdout0_180ck920 FIND v(dout0_180) AT=465.025n

.meas tran vdout0_181ck920 FIND v(dout0_181) AT=465.025n

.meas tran vdout0_182ck920 FIND v(dout0_182) AT=465.025n

.meas tran vdout0_183ck920 FIND v(dout0_183) AT=465.025n

.meas tran vdout0_184ck920 FIND v(dout0_184) AT=465.025n

.meas tran vdout0_185ck920 FIND v(dout0_185) AT=465.025n

.meas tran vdout0_186ck920 FIND v(dout0_186) AT=465.025n

.meas tran vdout0_187ck920 FIND v(dout0_187) AT=465.025n

.meas tran vdout0_188ck920 FIND v(dout0_188) AT=465.025n

.meas tran vdout0_189ck920 FIND v(dout0_189) AT=465.025n

.meas tran vdout0_190ck920 FIND v(dout0_190) AT=465.025n

.meas tran vdout0_191ck920 FIND v(dout0_191) AT=465.025n

.meas tran vdout0_192ck920 FIND v(dout0_192) AT=465.025n

.meas tran vdout0_193ck920 FIND v(dout0_193) AT=465.025n

.meas tran vdout0_194ck920 FIND v(dout0_194) AT=465.025n

.meas tran vdout0_195ck920 FIND v(dout0_195) AT=465.025n

.meas tran vdout0_196ck920 FIND v(dout0_196) AT=465.025n

.meas tran vdout0_197ck920 FIND v(dout0_197) AT=465.025n

.meas tran vdout0_198ck920 FIND v(dout0_198) AT=465.025n

.meas tran vdout0_199ck920 FIND v(dout0_199) AT=465.025n

.meas tran vdout0_200ck920 FIND v(dout0_200) AT=465.025n

.meas tran vdout0_201ck920 FIND v(dout0_201) AT=465.025n

.meas tran vdout0_202ck920 FIND v(dout0_202) AT=465.025n

.meas tran vdout0_203ck920 FIND v(dout0_203) AT=465.025n

.meas tran vdout0_204ck920 FIND v(dout0_204) AT=465.025n

.meas tran vdout0_205ck920 FIND v(dout0_205) AT=465.025n

.meas tran vdout0_206ck920 FIND v(dout0_206) AT=465.025n

.meas tran vdout0_207ck920 FIND v(dout0_207) AT=465.025n

.meas tran vdout0_208ck920 FIND v(dout0_208) AT=465.025n

.meas tran vdout0_209ck920 FIND v(dout0_209) AT=465.025n

.meas tran vdout0_210ck920 FIND v(dout0_210) AT=465.025n

.meas tran vdout0_211ck920 FIND v(dout0_211) AT=465.025n

.meas tran vdout0_212ck920 FIND v(dout0_212) AT=465.025n

.meas tran vdout0_213ck920 FIND v(dout0_213) AT=465.025n

.meas tran vdout0_214ck920 FIND v(dout0_214) AT=465.025n

.meas tran vdout0_215ck920 FIND v(dout0_215) AT=465.025n

.meas tran vdout0_216ck920 FIND v(dout0_216) AT=465.025n

.meas tran vdout0_217ck920 FIND v(dout0_217) AT=465.025n

.meas tran vdout0_218ck920 FIND v(dout0_218) AT=465.025n

.meas tran vdout0_219ck920 FIND v(dout0_219) AT=465.025n

.meas tran vdout0_220ck920 FIND v(dout0_220) AT=465.025n

.meas tran vdout0_221ck920 FIND v(dout0_221) AT=465.025n

.meas tran vdout0_222ck920 FIND v(dout0_222) AT=465.025n

.meas tran vdout0_223ck920 FIND v(dout0_223) AT=465.025n

.meas tran vdout0_224ck920 FIND v(dout0_224) AT=465.025n

.meas tran vdout0_225ck920 FIND v(dout0_225) AT=465.025n

.meas tran vdout0_226ck920 FIND v(dout0_226) AT=465.025n

.meas tran vdout0_227ck920 FIND v(dout0_227) AT=465.025n

.meas tran vdout0_228ck920 FIND v(dout0_228) AT=465.025n

.meas tran vdout0_229ck920 FIND v(dout0_229) AT=465.025n

.meas tran vdout0_230ck920 FIND v(dout0_230) AT=465.025n

.meas tran vdout0_231ck920 FIND v(dout0_231) AT=465.025n

.meas tran vdout0_232ck920 FIND v(dout0_232) AT=465.025n

.meas tran vdout0_233ck920 FIND v(dout0_233) AT=465.025n

.meas tran vdout0_234ck920 FIND v(dout0_234) AT=465.025n

.meas tran vdout0_235ck920 FIND v(dout0_235) AT=465.025n

.meas tran vdout0_236ck920 FIND v(dout0_236) AT=465.025n

.meas tran vdout0_237ck920 FIND v(dout0_237) AT=465.025n

.meas tran vdout0_238ck920 FIND v(dout0_238) AT=465.025n

.meas tran vdout0_239ck920 FIND v(dout0_239) AT=465.025n

.meas tran vdout0_240ck920 FIND v(dout0_240) AT=465.025n

.meas tran vdout0_241ck920 FIND v(dout0_241) AT=465.025n

.meas tran vdout0_242ck920 FIND v(dout0_242) AT=465.025n

.meas tran vdout0_243ck920 FIND v(dout0_243) AT=465.025n

.meas tran vdout0_244ck920 FIND v(dout0_244) AT=465.025n

.meas tran vdout0_245ck920 FIND v(dout0_245) AT=465.025n

.meas tran vdout0_246ck920 FIND v(dout0_246) AT=465.025n

.meas tran vdout0_247ck920 FIND v(dout0_247) AT=465.025n

.meas tran vdout0_248ck920 FIND v(dout0_248) AT=465.025n

.meas tran vdout0_249ck920 FIND v(dout0_249) AT=465.025n

.meas tran vdout0_250ck920 FIND v(dout0_250) AT=465.025n

.meas tran vdout0_251ck920 FIND v(dout0_251) AT=465.025n

.meas tran vdout0_252ck920 FIND v(dout0_252) AT=465.025n

.meas tran vdout0_253ck920 FIND v(dout0_253) AT=465.025n

.meas tran vdout0_254ck920 FIND v(dout0_254) AT=465.025n

.meas tran vdout0_255ck920 FIND v(dout0_255) AT=465.025n

.meas tran vdout0_0ck950 FIND v(dout0_0) AT=480.025n

.meas tran vdout0_1ck950 FIND v(dout0_1) AT=480.025n

.meas tran vdout0_2ck950 FIND v(dout0_2) AT=480.025n

.meas tran vdout0_3ck950 FIND v(dout0_3) AT=480.025n

.meas tran vdout0_4ck950 FIND v(dout0_4) AT=480.025n

.meas tran vdout0_5ck950 FIND v(dout0_5) AT=480.025n

.meas tran vdout0_6ck950 FIND v(dout0_6) AT=480.025n

.meas tran vdout0_7ck950 FIND v(dout0_7) AT=480.025n

.meas tran vdout0_8ck950 FIND v(dout0_8) AT=480.025n

.meas tran vdout0_9ck950 FIND v(dout0_9) AT=480.025n

.meas tran vdout0_10ck950 FIND v(dout0_10) AT=480.025n

.meas tran vdout0_11ck950 FIND v(dout0_11) AT=480.025n

.meas tran vdout0_12ck950 FIND v(dout0_12) AT=480.025n

.meas tran vdout0_13ck950 FIND v(dout0_13) AT=480.025n

.meas tran vdout0_14ck950 FIND v(dout0_14) AT=480.025n

.meas tran vdout0_15ck950 FIND v(dout0_15) AT=480.025n

.meas tran vdout0_16ck950 FIND v(dout0_16) AT=480.025n

.meas tran vdout0_17ck950 FIND v(dout0_17) AT=480.025n

.meas tran vdout0_18ck950 FIND v(dout0_18) AT=480.025n

.meas tran vdout0_19ck950 FIND v(dout0_19) AT=480.025n

.meas tran vdout0_20ck950 FIND v(dout0_20) AT=480.025n

.meas tran vdout0_21ck950 FIND v(dout0_21) AT=480.025n

.meas tran vdout0_22ck950 FIND v(dout0_22) AT=480.025n

.meas tran vdout0_23ck950 FIND v(dout0_23) AT=480.025n

.meas tran vdout0_24ck950 FIND v(dout0_24) AT=480.025n

.meas tran vdout0_25ck950 FIND v(dout0_25) AT=480.025n

.meas tran vdout0_26ck950 FIND v(dout0_26) AT=480.025n

.meas tran vdout0_27ck950 FIND v(dout0_27) AT=480.025n

.meas tran vdout0_28ck950 FIND v(dout0_28) AT=480.025n

.meas tran vdout0_29ck950 FIND v(dout0_29) AT=480.025n

.meas tran vdout0_30ck950 FIND v(dout0_30) AT=480.025n

.meas tran vdout0_31ck950 FIND v(dout0_31) AT=480.025n

.meas tran vdout0_32ck950 FIND v(dout0_32) AT=480.025n

.meas tran vdout0_33ck950 FIND v(dout0_33) AT=480.025n

.meas tran vdout0_34ck950 FIND v(dout0_34) AT=480.025n

.meas tran vdout0_35ck950 FIND v(dout0_35) AT=480.025n

.meas tran vdout0_36ck950 FIND v(dout0_36) AT=480.025n

.meas tran vdout0_37ck950 FIND v(dout0_37) AT=480.025n

.meas tran vdout0_38ck950 FIND v(dout0_38) AT=480.025n

.meas tran vdout0_39ck950 FIND v(dout0_39) AT=480.025n

.meas tran vdout0_40ck950 FIND v(dout0_40) AT=480.025n

.meas tran vdout0_41ck950 FIND v(dout0_41) AT=480.025n

.meas tran vdout0_42ck950 FIND v(dout0_42) AT=480.025n

.meas tran vdout0_43ck950 FIND v(dout0_43) AT=480.025n

.meas tran vdout0_44ck950 FIND v(dout0_44) AT=480.025n

.meas tran vdout0_45ck950 FIND v(dout0_45) AT=480.025n

.meas tran vdout0_46ck950 FIND v(dout0_46) AT=480.025n

.meas tran vdout0_47ck950 FIND v(dout0_47) AT=480.025n

.meas tran vdout0_48ck950 FIND v(dout0_48) AT=480.025n

.meas tran vdout0_49ck950 FIND v(dout0_49) AT=480.025n

.meas tran vdout0_50ck950 FIND v(dout0_50) AT=480.025n

.meas tran vdout0_51ck950 FIND v(dout0_51) AT=480.025n

.meas tran vdout0_52ck950 FIND v(dout0_52) AT=480.025n

.meas tran vdout0_53ck950 FIND v(dout0_53) AT=480.025n

.meas tran vdout0_54ck950 FIND v(dout0_54) AT=480.025n

.meas tran vdout0_55ck950 FIND v(dout0_55) AT=480.025n

.meas tran vdout0_56ck950 FIND v(dout0_56) AT=480.025n

.meas tran vdout0_57ck950 FIND v(dout0_57) AT=480.025n

.meas tran vdout0_58ck950 FIND v(dout0_58) AT=480.025n

.meas tran vdout0_59ck950 FIND v(dout0_59) AT=480.025n

.meas tran vdout0_60ck950 FIND v(dout0_60) AT=480.025n

.meas tran vdout0_61ck950 FIND v(dout0_61) AT=480.025n

.meas tran vdout0_62ck950 FIND v(dout0_62) AT=480.025n

.meas tran vdout0_63ck950 FIND v(dout0_63) AT=480.025n

.meas tran vdout0_64ck950 FIND v(dout0_64) AT=480.025n

.meas tran vdout0_65ck950 FIND v(dout0_65) AT=480.025n

.meas tran vdout0_66ck950 FIND v(dout0_66) AT=480.025n

.meas tran vdout0_67ck950 FIND v(dout0_67) AT=480.025n

.meas tran vdout0_68ck950 FIND v(dout0_68) AT=480.025n

.meas tran vdout0_69ck950 FIND v(dout0_69) AT=480.025n

.meas tran vdout0_70ck950 FIND v(dout0_70) AT=480.025n

.meas tran vdout0_71ck950 FIND v(dout0_71) AT=480.025n

.meas tran vdout0_72ck950 FIND v(dout0_72) AT=480.025n

.meas tran vdout0_73ck950 FIND v(dout0_73) AT=480.025n

.meas tran vdout0_74ck950 FIND v(dout0_74) AT=480.025n

.meas tran vdout0_75ck950 FIND v(dout0_75) AT=480.025n

.meas tran vdout0_76ck950 FIND v(dout0_76) AT=480.025n

.meas tran vdout0_77ck950 FIND v(dout0_77) AT=480.025n

.meas tran vdout0_78ck950 FIND v(dout0_78) AT=480.025n

.meas tran vdout0_79ck950 FIND v(dout0_79) AT=480.025n

.meas tran vdout0_80ck950 FIND v(dout0_80) AT=480.025n

.meas tran vdout0_81ck950 FIND v(dout0_81) AT=480.025n

.meas tran vdout0_82ck950 FIND v(dout0_82) AT=480.025n

.meas tran vdout0_83ck950 FIND v(dout0_83) AT=480.025n

.meas tran vdout0_84ck950 FIND v(dout0_84) AT=480.025n

.meas tran vdout0_85ck950 FIND v(dout0_85) AT=480.025n

.meas tran vdout0_86ck950 FIND v(dout0_86) AT=480.025n

.meas tran vdout0_87ck950 FIND v(dout0_87) AT=480.025n

.meas tran vdout0_88ck950 FIND v(dout0_88) AT=480.025n

.meas tran vdout0_89ck950 FIND v(dout0_89) AT=480.025n

.meas tran vdout0_90ck950 FIND v(dout0_90) AT=480.025n

.meas tran vdout0_91ck950 FIND v(dout0_91) AT=480.025n

.meas tran vdout0_92ck950 FIND v(dout0_92) AT=480.025n

.meas tran vdout0_93ck950 FIND v(dout0_93) AT=480.025n

.meas tran vdout0_94ck950 FIND v(dout0_94) AT=480.025n

.meas tran vdout0_95ck950 FIND v(dout0_95) AT=480.025n

.meas tran vdout0_96ck950 FIND v(dout0_96) AT=480.025n

.meas tran vdout0_97ck950 FIND v(dout0_97) AT=480.025n

.meas tran vdout0_98ck950 FIND v(dout0_98) AT=480.025n

.meas tran vdout0_99ck950 FIND v(dout0_99) AT=480.025n

.meas tran vdout0_100ck950 FIND v(dout0_100) AT=480.025n

.meas tran vdout0_101ck950 FIND v(dout0_101) AT=480.025n

.meas tran vdout0_102ck950 FIND v(dout0_102) AT=480.025n

.meas tran vdout0_103ck950 FIND v(dout0_103) AT=480.025n

.meas tran vdout0_104ck950 FIND v(dout0_104) AT=480.025n

.meas tran vdout0_105ck950 FIND v(dout0_105) AT=480.025n

.meas tran vdout0_106ck950 FIND v(dout0_106) AT=480.025n

.meas tran vdout0_107ck950 FIND v(dout0_107) AT=480.025n

.meas tran vdout0_108ck950 FIND v(dout0_108) AT=480.025n

.meas tran vdout0_109ck950 FIND v(dout0_109) AT=480.025n

.meas tran vdout0_110ck950 FIND v(dout0_110) AT=480.025n

.meas tran vdout0_111ck950 FIND v(dout0_111) AT=480.025n

.meas tran vdout0_112ck950 FIND v(dout0_112) AT=480.025n

.meas tran vdout0_113ck950 FIND v(dout0_113) AT=480.025n

.meas tran vdout0_114ck950 FIND v(dout0_114) AT=480.025n

.meas tran vdout0_115ck950 FIND v(dout0_115) AT=480.025n

.meas tran vdout0_116ck950 FIND v(dout0_116) AT=480.025n

.meas tran vdout0_117ck950 FIND v(dout0_117) AT=480.025n

.meas tran vdout0_118ck950 FIND v(dout0_118) AT=480.025n

.meas tran vdout0_119ck950 FIND v(dout0_119) AT=480.025n

.meas tran vdout0_120ck950 FIND v(dout0_120) AT=480.025n

.meas tran vdout0_121ck950 FIND v(dout0_121) AT=480.025n

.meas tran vdout0_122ck950 FIND v(dout0_122) AT=480.025n

.meas tran vdout0_123ck950 FIND v(dout0_123) AT=480.025n

.meas tran vdout0_124ck950 FIND v(dout0_124) AT=480.025n

.meas tran vdout0_125ck950 FIND v(dout0_125) AT=480.025n

.meas tran vdout0_126ck950 FIND v(dout0_126) AT=480.025n

.meas tran vdout0_127ck950 FIND v(dout0_127) AT=480.025n

.meas tran vdout0_128ck950 FIND v(dout0_128) AT=480.025n

.meas tran vdout0_129ck950 FIND v(dout0_129) AT=480.025n

.meas tran vdout0_130ck950 FIND v(dout0_130) AT=480.025n

.meas tran vdout0_131ck950 FIND v(dout0_131) AT=480.025n

.meas tran vdout0_132ck950 FIND v(dout0_132) AT=480.025n

.meas tran vdout0_133ck950 FIND v(dout0_133) AT=480.025n

.meas tran vdout0_134ck950 FIND v(dout0_134) AT=480.025n

.meas tran vdout0_135ck950 FIND v(dout0_135) AT=480.025n

.meas tran vdout0_136ck950 FIND v(dout0_136) AT=480.025n

.meas tran vdout0_137ck950 FIND v(dout0_137) AT=480.025n

.meas tran vdout0_138ck950 FIND v(dout0_138) AT=480.025n

.meas tran vdout0_139ck950 FIND v(dout0_139) AT=480.025n

.meas tran vdout0_140ck950 FIND v(dout0_140) AT=480.025n

.meas tran vdout0_141ck950 FIND v(dout0_141) AT=480.025n

.meas tran vdout0_142ck950 FIND v(dout0_142) AT=480.025n

.meas tran vdout0_143ck950 FIND v(dout0_143) AT=480.025n

.meas tran vdout0_144ck950 FIND v(dout0_144) AT=480.025n

.meas tran vdout0_145ck950 FIND v(dout0_145) AT=480.025n

.meas tran vdout0_146ck950 FIND v(dout0_146) AT=480.025n

.meas tran vdout0_147ck950 FIND v(dout0_147) AT=480.025n

.meas tran vdout0_148ck950 FIND v(dout0_148) AT=480.025n

.meas tran vdout0_149ck950 FIND v(dout0_149) AT=480.025n

.meas tran vdout0_150ck950 FIND v(dout0_150) AT=480.025n

.meas tran vdout0_151ck950 FIND v(dout0_151) AT=480.025n

.meas tran vdout0_152ck950 FIND v(dout0_152) AT=480.025n

.meas tran vdout0_153ck950 FIND v(dout0_153) AT=480.025n

.meas tran vdout0_154ck950 FIND v(dout0_154) AT=480.025n

.meas tran vdout0_155ck950 FIND v(dout0_155) AT=480.025n

.meas tran vdout0_156ck950 FIND v(dout0_156) AT=480.025n

.meas tran vdout0_157ck950 FIND v(dout0_157) AT=480.025n

.meas tran vdout0_158ck950 FIND v(dout0_158) AT=480.025n

.meas tran vdout0_159ck950 FIND v(dout0_159) AT=480.025n

.meas tran vdout0_160ck950 FIND v(dout0_160) AT=480.025n

.meas tran vdout0_161ck950 FIND v(dout0_161) AT=480.025n

.meas tran vdout0_162ck950 FIND v(dout0_162) AT=480.025n

.meas tran vdout0_163ck950 FIND v(dout0_163) AT=480.025n

.meas tran vdout0_164ck950 FIND v(dout0_164) AT=480.025n

.meas tran vdout0_165ck950 FIND v(dout0_165) AT=480.025n

.meas tran vdout0_166ck950 FIND v(dout0_166) AT=480.025n

.meas tran vdout0_167ck950 FIND v(dout0_167) AT=480.025n

.meas tran vdout0_168ck950 FIND v(dout0_168) AT=480.025n

.meas tran vdout0_169ck950 FIND v(dout0_169) AT=480.025n

.meas tran vdout0_170ck950 FIND v(dout0_170) AT=480.025n

.meas tran vdout0_171ck950 FIND v(dout0_171) AT=480.025n

.meas tran vdout0_172ck950 FIND v(dout0_172) AT=480.025n

.meas tran vdout0_173ck950 FIND v(dout0_173) AT=480.025n

.meas tran vdout0_174ck950 FIND v(dout0_174) AT=480.025n

.meas tran vdout0_175ck950 FIND v(dout0_175) AT=480.025n

.meas tran vdout0_176ck950 FIND v(dout0_176) AT=480.025n

.meas tran vdout0_177ck950 FIND v(dout0_177) AT=480.025n

.meas tran vdout0_178ck950 FIND v(dout0_178) AT=480.025n

.meas tran vdout0_179ck950 FIND v(dout0_179) AT=480.025n

.meas tran vdout0_180ck950 FIND v(dout0_180) AT=480.025n

.meas tran vdout0_181ck950 FIND v(dout0_181) AT=480.025n

.meas tran vdout0_182ck950 FIND v(dout0_182) AT=480.025n

.meas tran vdout0_183ck950 FIND v(dout0_183) AT=480.025n

.meas tran vdout0_184ck950 FIND v(dout0_184) AT=480.025n

.meas tran vdout0_185ck950 FIND v(dout0_185) AT=480.025n

.meas tran vdout0_186ck950 FIND v(dout0_186) AT=480.025n

.meas tran vdout0_187ck950 FIND v(dout0_187) AT=480.025n

.meas tran vdout0_188ck950 FIND v(dout0_188) AT=480.025n

.meas tran vdout0_189ck950 FIND v(dout0_189) AT=480.025n

.meas tran vdout0_190ck950 FIND v(dout0_190) AT=480.025n

.meas tran vdout0_191ck950 FIND v(dout0_191) AT=480.025n

.meas tran vdout0_192ck950 FIND v(dout0_192) AT=480.025n

.meas tran vdout0_193ck950 FIND v(dout0_193) AT=480.025n

.meas tran vdout0_194ck950 FIND v(dout0_194) AT=480.025n

.meas tran vdout0_195ck950 FIND v(dout0_195) AT=480.025n

.meas tran vdout0_196ck950 FIND v(dout0_196) AT=480.025n

.meas tran vdout0_197ck950 FIND v(dout0_197) AT=480.025n

.meas tran vdout0_198ck950 FIND v(dout0_198) AT=480.025n

.meas tran vdout0_199ck950 FIND v(dout0_199) AT=480.025n

.meas tran vdout0_200ck950 FIND v(dout0_200) AT=480.025n

.meas tran vdout0_201ck950 FIND v(dout0_201) AT=480.025n

.meas tran vdout0_202ck950 FIND v(dout0_202) AT=480.025n

.meas tran vdout0_203ck950 FIND v(dout0_203) AT=480.025n

.meas tran vdout0_204ck950 FIND v(dout0_204) AT=480.025n

.meas tran vdout0_205ck950 FIND v(dout0_205) AT=480.025n

.meas tran vdout0_206ck950 FIND v(dout0_206) AT=480.025n

.meas tran vdout0_207ck950 FIND v(dout0_207) AT=480.025n

.meas tran vdout0_208ck950 FIND v(dout0_208) AT=480.025n

.meas tran vdout0_209ck950 FIND v(dout0_209) AT=480.025n

.meas tran vdout0_210ck950 FIND v(dout0_210) AT=480.025n

.meas tran vdout0_211ck950 FIND v(dout0_211) AT=480.025n

.meas tran vdout0_212ck950 FIND v(dout0_212) AT=480.025n

.meas tran vdout0_213ck950 FIND v(dout0_213) AT=480.025n

.meas tran vdout0_214ck950 FIND v(dout0_214) AT=480.025n

.meas tran vdout0_215ck950 FIND v(dout0_215) AT=480.025n

.meas tran vdout0_216ck950 FIND v(dout0_216) AT=480.025n

.meas tran vdout0_217ck950 FIND v(dout0_217) AT=480.025n

.meas tran vdout0_218ck950 FIND v(dout0_218) AT=480.025n

.meas tran vdout0_219ck950 FIND v(dout0_219) AT=480.025n

.meas tran vdout0_220ck950 FIND v(dout0_220) AT=480.025n

.meas tran vdout0_221ck950 FIND v(dout0_221) AT=480.025n

.meas tran vdout0_222ck950 FIND v(dout0_222) AT=480.025n

.meas tran vdout0_223ck950 FIND v(dout0_223) AT=480.025n

.meas tran vdout0_224ck950 FIND v(dout0_224) AT=480.025n

.meas tran vdout0_225ck950 FIND v(dout0_225) AT=480.025n

.meas tran vdout0_226ck950 FIND v(dout0_226) AT=480.025n

.meas tran vdout0_227ck950 FIND v(dout0_227) AT=480.025n

.meas tran vdout0_228ck950 FIND v(dout0_228) AT=480.025n

.meas tran vdout0_229ck950 FIND v(dout0_229) AT=480.025n

.meas tran vdout0_230ck950 FIND v(dout0_230) AT=480.025n

.meas tran vdout0_231ck950 FIND v(dout0_231) AT=480.025n

.meas tran vdout0_232ck950 FIND v(dout0_232) AT=480.025n

.meas tran vdout0_233ck950 FIND v(dout0_233) AT=480.025n

.meas tran vdout0_234ck950 FIND v(dout0_234) AT=480.025n

.meas tran vdout0_235ck950 FIND v(dout0_235) AT=480.025n

.meas tran vdout0_236ck950 FIND v(dout0_236) AT=480.025n

.meas tran vdout0_237ck950 FIND v(dout0_237) AT=480.025n

.meas tran vdout0_238ck950 FIND v(dout0_238) AT=480.025n

.meas tran vdout0_239ck950 FIND v(dout0_239) AT=480.025n

.meas tran vdout0_240ck950 FIND v(dout0_240) AT=480.025n

.meas tran vdout0_241ck950 FIND v(dout0_241) AT=480.025n

.meas tran vdout0_242ck950 FIND v(dout0_242) AT=480.025n

.meas tran vdout0_243ck950 FIND v(dout0_243) AT=480.025n

.meas tran vdout0_244ck950 FIND v(dout0_244) AT=480.025n

.meas tran vdout0_245ck950 FIND v(dout0_245) AT=480.025n

.meas tran vdout0_246ck950 FIND v(dout0_246) AT=480.025n

.meas tran vdout0_247ck950 FIND v(dout0_247) AT=480.025n

.meas tran vdout0_248ck950 FIND v(dout0_248) AT=480.025n

.meas tran vdout0_249ck950 FIND v(dout0_249) AT=480.025n

.meas tran vdout0_250ck950 FIND v(dout0_250) AT=480.025n

.meas tran vdout0_251ck950 FIND v(dout0_251) AT=480.025n

.meas tran vdout0_252ck950 FIND v(dout0_252) AT=480.025n

.meas tran vdout0_253ck950 FIND v(dout0_253) AT=480.025n

.meas tran vdout0_254ck950 FIND v(dout0_254) AT=480.025n

.meas tran vdout0_255ck950 FIND v(dout0_255) AT=480.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_128ck960 FIND v(dout0_128) AT=485.025n

.meas tran vdout0_129ck960 FIND v(dout0_129) AT=485.025n

.meas tran vdout0_130ck960 FIND v(dout0_130) AT=485.025n

.meas tran vdout0_131ck960 FIND v(dout0_131) AT=485.025n

.meas tran vdout0_132ck960 FIND v(dout0_132) AT=485.025n

.meas tran vdout0_133ck960 FIND v(dout0_133) AT=485.025n

.meas tran vdout0_134ck960 FIND v(dout0_134) AT=485.025n

.meas tran vdout0_135ck960 FIND v(dout0_135) AT=485.025n

.meas tran vdout0_136ck960 FIND v(dout0_136) AT=485.025n

.meas tran vdout0_137ck960 FIND v(dout0_137) AT=485.025n

.meas tran vdout0_138ck960 FIND v(dout0_138) AT=485.025n

.meas tran vdout0_139ck960 FIND v(dout0_139) AT=485.025n

.meas tran vdout0_140ck960 FIND v(dout0_140) AT=485.025n

.meas tran vdout0_141ck960 FIND v(dout0_141) AT=485.025n

.meas tran vdout0_142ck960 FIND v(dout0_142) AT=485.025n

.meas tran vdout0_143ck960 FIND v(dout0_143) AT=485.025n

.meas tran vdout0_144ck960 FIND v(dout0_144) AT=485.025n

.meas tran vdout0_145ck960 FIND v(dout0_145) AT=485.025n

.meas tran vdout0_146ck960 FIND v(dout0_146) AT=485.025n

.meas tran vdout0_147ck960 FIND v(dout0_147) AT=485.025n

.meas tran vdout0_148ck960 FIND v(dout0_148) AT=485.025n

.meas tran vdout0_149ck960 FIND v(dout0_149) AT=485.025n

.meas tran vdout0_150ck960 FIND v(dout0_150) AT=485.025n

.meas tran vdout0_151ck960 FIND v(dout0_151) AT=485.025n

.meas tran vdout0_152ck960 FIND v(dout0_152) AT=485.025n

.meas tran vdout0_153ck960 FIND v(dout0_153) AT=485.025n

.meas tran vdout0_154ck960 FIND v(dout0_154) AT=485.025n

.meas tran vdout0_155ck960 FIND v(dout0_155) AT=485.025n

.meas tran vdout0_156ck960 FIND v(dout0_156) AT=485.025n

.meas tran vdout0_157ck960 FIND v(dout0_157) AT=485.025n

.meas tran vdout0_158ck960 FIND v(dout0_158) AT=485.025n

.meas tran vdout0_159ck960 FIND v(dout0_159) AT=485.025n

.meas tran vdout0_160ck960 FIND v(dout0_160) AT=485.025n

.meas tran vdout0_161ck960 FIND v(dout0_161) AT=485.025n

.meas tran vdout0_162ck960 FIND v(dout0_162) AT=485.025n

.meas tran vdout0_163ck960 FIND v(dout0_163) AT=485.025n

.meas tran vdout0_164ck960 FIND v(dout0_164) AT=485.025n

.meas tran vdout0_165ck960 FIND v(dout0_165) AT=485.025n

.meas tran vdout0_166ck960 FIND v(dout0_166) AT=485.025n

.meas tran vdout0_167ck960 FIND v(dout0_167) AT=485.025n

.meas tran vdout0_168ck960 FIND v(dout0_168) AT=485.025n

.meas tran vdout0_169ck960 FIND v(dout0_169) AT=485.025n

.meas tran vdout0_170ck960 FIND v(dout0_170) AT=485.025n

.meas tran vdout0_171ck960 FIND v(dout0_171) AT=485.025n

.meas tran vdout0_172ck960 FIND v(dout0_172) AT=485.025n

.meas tran vdout0_173ck960 FIND v(dout0_173) AT=485.025n

.meas tran vdout0_174ck960 FIND v(dout0_174) AT=485.025n

.meas tran vdout0_175ck960 FIND v(dout0_175) AT=485.025n

.meas tran vdout0_176ck960 FIND v(dout0_176) AT=485.025n

.meas tran vdout0_177ck960 FIND v(dout0_177) AT=485.025n

.meas tran vdout0_178ck960 FIND v(dout0_178) AT=485.025n

.meas tran vdout0_179ck960 FIND v(dout0_179) AT=485.025n

.meas tran vdout0_180ck960 FIND v(dout0_180) AT=485.025n

.meas tran vdout0_181ck960 FIND v(dout0_181) AT=485.025n

.meas tran vdout0_182ck960 FIND v(dout0_182) AT=485.025n

.meas tran vdout0_183ck960 FIND v(dout0_183) AT=485.025n

.meas tran vdout0_184ck960 FIND v(dout0_184) AT=485.025n

.meas tran vdout0_185ck960 FIND v(dout0_185) AT=485.025n

.meas tran vdout0_186ck960 FIND v(dout0_186) AT=485.025n

.meas tran vdout0_187ck960 FIND v(dout0_187) AT=485.025n

.meas tran vdout0_188ck960 FIND v(dout0_188) AT=485.025n

.meas tran vdout0_189ck960 FIND v(dout0_189) AT=485.025n

.meas tran vdout0_190ck960 FIND v(dout0_190) AT=485.025n

.meas tran vdout0_191ck960 FIND v(dout0_191) AT=485.025n

.meas tran vdout0_192ck960 FIND v(dout0_192) AT=485.025n

.meas tran vdout0_193ck960 FIND v(dout0_193) AT=485.025n

.meas tran vdout0_194ck960 FIND v(dout0_194) AT=485.025n

.meas tran vdout0_195ck960 FIND v(dout0_195) AT=485.025n

.meas tran vdout0_196ck960 FIND v(dout0_196) AT=485.025n

.meas tran vdout0_197ck960 FIND v(dout0_197) AT=485.025n

.meas tran vdout0_198ck960 FIND v(dout0_198) AT=485.025n

.meas tran vdout0_199ck960 FIND v(dout0_199) AT=485.025n

.meas tran vdout0_200ck960 FIND v(dout0_200) AT=485.025n

.meas tran vdout0_201ck960 FIND v(dout0_201) AT=485.025n

.meas tran vdout0_202ck960 FIND v(dout0_202) AT=485.025n

.meas tran vdout0_203ck960 FIND v(dout0_203) AT=485.025n

.meas tran vdout0_204ck960 FIND v(dout0_204) AT=485.025n

.meas tran vdout0_205ck960 FIND v(dout0_205) AT=485.025n

.meas tran vdout0_206ck960 FIND v(dout0_206) AT=485.025n

.meas tran vdout0_207ck960 FIND v(dout0_207) AT=485.025n

.meas tran vdout0_208ck960 FIND v(dout0_208) AT=485.025n

.meas tran vdout0_209ck960 FIND v(dout0_209) AT=485.025n

.meas tran vdout0_210ck960 FIND v(dout0_210) AT=485.025n

.meas tran vdout0_211ck960 FIND v(dout0_211) AT=485.025n

.meas tran vdout0_212ck960 FIND v(dout0_212) AT=485.025n

.meas tran vdout0_213ck960 FIND v(dout0_213) AT=485.025n

.meas tran vdout0_214ck960 FIND v(dout0_214) AT=485.025n

.meas tran vdout0_215ck960 FIND v(dout0_215) AT=485.025n

.meas tran vdout0_216ck960 FIND v(dout0_216) AT=485.025n

.meas tran vdout0_217ck960 FIND v(dout0_217) AT=485.025n

.meas tran vdout0_218ck960 FIND v(dout0_218) AT=485.025n

.meas tran vdout0_219ck960 FIND v(dout0_219) AT=485.025n

.meas tran vdout0_220ck960 FIND v(dout0_220) AT=485.025n

.meas tran vdout0_221ck960 FIND v(dout0_221) AT=485.025n

.meas tran vdout0_222ck960 FIND v(dout0_222) AT=485.025n

.meas tran vdout0_223ck960 FIND v(dout0_223) AT=485.025n

.meas tran vdout0_224ck960 FIND v(dout0_224) AT=485.025n

.meas tran vdout0_225ck960 FIND v(dout0_225) AT=485.025n

.meas tran vdout0_226ck960 FIND v(dout0_226) AT=485.025n

.meas tran vdout0_227ck960 FIND v(dout0_227) AT=485.025n

.meas tran vdout0_228ck960 FIND v(dout0_228) AT=485.025n

.meas tran vdout0_229ck960 FIND v(dout0_229) AT=485.025n

.meas tran vdout0_230ck960 FIND v(dout0_230) AT=485.025n

.meas tran vdout0_231ck960 FIND v(dout0_231) AT=485.025n

.meas tran vdout0_232ck960 FIND v(dout0_232) AT=485.025n

.meas tran vdout0_233ck960 FIND v(dout0_233) AT=485.025n

.meas tran vdout0_234ck960 FIND v(dout0_234) AT=485.025n

.meas tran vdout0_235ck960 FIND v(dout0_235) AT=485.025n

.meas tran vdout0_236ck960 FIND v(dout0_236) AT=485.025n

.meas tran vdout0_237ck960 FIND v(dout0_237) AT=485.025n

.meas tran vdout0_238ck960 FIND v(dout0_238) AT=485.025n

.meas tran vdout0_239ck960 FIND v(dout0_239) AT=485.025n

.meas tran vdout0_240ck960 FIND v(dout0_240) AT=485.025n

.meas tran vdout0_241ck960 FIND v(dout0_241) AT=485.025n

.meas tran vdout0_242ck960 FIND v(dout0_242) AT=485.025n

.meas tran vdout0_243ck960 FIND v(dout0_243) AT=485.025n

.meas tran vdout0_244ck960 FIND v(dout0_244) AT=485.025n

.meas tran vdout0_245ck960 FIND v(dout0_245) AT=485.025n

.meas tran vdout0_246ck960 FIND v(dout0_246) AT=485.025n

.meas tran vdout0_247ck960 FIND v(dout0_247) AT=485.025n

.meas tran vdout0_248ck960 FIND v(dout0_248) AT=485.025n

.meas tran vdout0_249ck960 FIND v(dout0_249) AT=485.025n

.meas tran vdout0_250ck960 FIND v(dout0_250) AT=485.025n

.meas tran vdout0_251ck960 FIND v(dout0_251) AT=485.025n

.meas tran vdout0_252ck960 FIND v(dout0_252) AT=485.025n

.meas tran vdout0_253ck960 FIND v(dout0_253) AT=485.025n

.meas tran vdout0_254ck960 FIND v(dout0_254) AT=485.025n

.meas tran vdout0_255ck960 FIND v(dout0_255) AT=485.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_128ck980 FIND v(dout0_128) AT=495.025n

.meas tran vdout0_129ck980 FIND v(dout0_129) AT=495.025n

.meas tran vdout0_130ck980 FIND v(dout0_130) AT=495.025n

.meas tran vdout0_131ck980 FIND v(dout0_131) AT=495.025n

.meas tran vdout0_132ck980 FIND v(dout0_132) AT=495.025n

.meas tran vdout0_133ck980 FIND v(dout0_133) AT=495.025n

.meas tran vdout0_134ck980 FIND v(dout0_134) AT=495.025n

.meas tran vdout0_135ck980 FIND v(dout0_135) AT=495.025n

.meas tran vdout0_136ck980 FIND v(dout0_136) AT=495.025n

.meas tran vdout0_137ck980 FIND v(dout0_137) AT=495.025n

.meas tran vdout0_138ck980 FIND v(dout0_138) AT=495.025n

.meas tran vdout0_139ck980 FIND v(dout0_139) AT=495.025n

.meas tran vdout0_140ck980 FIND v(dout0_140) AT=495.025n

.meas tran vdout0_141ck980 FIND v(dout0_141) AT=495.025n

.meas tran vdout0_142ck980 FIND v(dout0_142) AT=495.025n

.meas tran vdout0_143ck980 FIND v(dout0_143) AT=495.025n

.meas tran vdout0_144ck980 FIND v(dout0_144) AT=495.025n

.meas tran vdout0_145ck980 FIND v(dout0_145) AT=495.025n

.meas tran vdout0_146ck980 FIND v(dout0_146) AT=495.025n

.meas tran vdout0_147ck980 FIND v(dout0_147) AT=495.025n

.meas tran vdout0_148ck980 FIND v(dout0_148) AT=495.025n

.meas tran vdout0_149ck980 FIND v(dout0_149) AT=495.025n

.meas tran vdout0_150ck980 FIND v(dout0_150) AT=495.025n

.meas tran vdout0_151ck980 FIND v(dout0_151) AT=495.025n

.meas tran vdout0_152ck980 FIND v(dout0_152) AT=495.025n

.meas tran vdout0_153ck980 FIND v(dout0_153) AT=495.025n

.meas tran vdout0_154ck980 FIND v(dout0_154) AT=495.025n

.meas tran vdout0_155ck980 FIND v(dout0_155) AT=495.025n

.meas tran vdout0_156ck980 FIND v(dout0_156) AT=495.025n

.meas tran vdout0_157ck980 FIND v(dout0_157) AT=495.025n

.meas tran vdout0_158ck980 FIND v(dout0_158) AT=495.025n

.meas tran vdout0_159ck980 FIND v(dout0_159) AT=495.025n

.meas tran vdout0_160ck980 FIND v(dout0_160) AT=495.025n

.meas tran vdout0_161ck980 FIND v(dout0_161) AT=495.025n

.meas tran vdout0_162ck980 FIND v(dout0_162) AT=495.025n

.meas tran vdout0_163ck980 FIND v(dout0_163) AT=495.025n

.meas tran vdout0_164ck980 FIND v(dout0_164) AT=495.025n

.meas tran vdout0_165ck980 FIND v(dout0_165) AT=495.025n

.meas tran vdout0_166ck980 FIND v(dout0_166) AT=495.025n

.meas tran vdout0_167ck980 FIND v(dout0_167) AT=495.025n

.meas tran vdout0_168ck980 FIND v(dout0_168) AT=495.025n

.meas tran vdout0_169ck980 FIND v(dout0_169) AT=495.025n

.meas tran vdout0_170ck980 FIND v(dout0_170) AT=495.025n

.meas tran vdout0_171ck980 FIND v(dout0_171) AT=495.025n

.meas tran vdout0_172ck980 FIND v(dout0_172) AT=495.025n

.meas tran vdout0_173ck980 FIND v(dout0_173) AT=495.025n

.meas tran vdout0_174ck980 FIND v(dout0_174) AT=495.025n

.meas tran vdout0_175ck980 FIND v(dout0_175) AT=495.025n

.meas tran vdout0_176ck980 FIND v(dout0_176) AT=495.025n

.meas tran vdout0_177ck980 FIND v(dout0_177) AT=495.025n

.meas tran vdout0_178ck980 FIND v(dout0_178) AT=495.025n

.meas tran vdout0_179ck980 FIND v(dout0_179) AT=495.025n

.meas tran vdout0_180ck980 FIND v(dout0_180) AT=495.025n

.meas tran vdout0_181ck980 FIND v(dout0_181) AT=495.025n

.meas tran vdout0_182ck980 FIND v(dout0_182) AT=495.025n

.meas tran vdout0_183ck980 FIND v(dout0_183) AT=495.025n

.meas tran vdout0_184ck980 FIND v(dout0_184) AT=495.025n

.meas tran vdout0_185ck980 FIND v(dout0_185) AT=495.025n

.meas tran vdout0_186ck980 FIND v(dout0_186) AT=495.025n

.meas tran vdout0_187ck980 FIND v(dout0_187) AT=495.025n

.meas tran vdout0_188ck980 FIND v(dout0_188) AT=495.025n

.meas tran vdout0_189ck980 FIND v(dout0_189) AT=495.025n

.meas tran vdout0_190ck980 FIND v(dout0_190) AT=495.025n

.meas tran vdout0_191ck980 FIND v(dout0_191) AT=495.025n

.meas tran vdout0_192ck980 FIND v(dout0_192) AT=495.025n

.meas tran vdout0_193ck980 FIND v(dout0_193) AT=495.025n

.meas tran vdout0_194ck980 FIND v(dout0_194) AT=495.025n

.meas tran vdout0_195ck980 FIND v(dout0_195) AT=495.025n

.meas tran vdout0_196ck980 FIND v(dout0_196) AT=495.025n

.meas tran vdout0_197ck980 FIND v(dout0_197) AT=495.025n

.meas tran vdout0_198ck980 FIND v(dout0_198) AT=495.025n

.meas tran vdout0_199ck980 FIND v(dout0_199) AT=495.025n

.meas tran vdout0_200ck980 FIND v(dout0_200) AT=495.025n

.meas tran vdout0_201ck980 FIND v(dout0_201) AT=495.025n

.meas tran vdout0_202ck980 FIND v(dout0_202) AT=495.025n

.meas tran vdout0_203ck980 FIND v(dout0_203) AT=495.025n

.meas tran vdout0_204ck980 FIND v(dout0_204) AT=495.025n

.meas tran vdout0_205ck980 FIND v(dout0_205) AT=495.025n

.meas tran vdout0_206ck980 FIND v(dout0_206) AT=495.025n

.meas tran vdout0_207ck980 FIND v(dout0_207) AT=495.025n

.meas tran vdout0_208ck980 FIND v(dout0_208) AT=495.025n

.meas tran vdout0_209ck980 FIND v(dout0_209) AT=495.025n

.meas tran vdout0_210ck980 FIND v(dout0_210) AT=495.025n

.meas tran vdout0_211ck980 FIND v(dout0_211) AT=495.025n

.meas tran vdout0_212ck980 FIND v(dout0_212) AT=495.025n

.meas tran vdout0_213ck980 FIND v(dout0_213) AT=495.025n

.meas tran vdout0_214ck980 FIND v(dout0_214) AT=495.025n

.meas tran vdout0_215ck980 FIND v(dout0_215) AT=495.025n

.meas tran vdout0_216ck980 FIND v(dout0_216) AT=495.025n

.meas tran vdout0_217ck980 FIND v(dout0_217) AT=495.025n

.meas tran vdout0_218ck980 FIND v(dout0_218) AT=495.025n

.meas tran vdout0_219ck980 FIND v(dout0_219) AT=495.025n

.meas tran vdout0_220ck980 FIND v(dout0_220) AT=495.025n

.meas tran vdout0_221ck980 FIND v(dout0_221) AT=495.025n

.meas tran vdout0_222ck980 FIND v(dout0_222) AT=495.025n

.meas tran vdout0_223ck980 FIND v(dout0_223) AT=495.025n

.meas tran vdout0_224ck980 FIND v(dout0_224) AT=495.025n

.meas tran vdout0_225ck980 FIND v(dout0_225) AT=495.025n

.meas tran vdout0_226ck980 FIND v(dout0_226) AT=495.025n

.meas tran vdout0_227ck980 FIND v(dout0_227) AT=495.025n

.meas tran vdout0_228ck980 FIND v(dout0_228) AT=495.025n

.meas tran vdout0_229ck980 FIND v(dout0_229) AT=495.025n

.meas tran vdout0_230ck980 FIND v(dout0_230) AT=495.025n

.meas tran vdout0_231ck980 FIND v(dout0_231) AT=495.025n

.meas tran vdout0_232ck980 FIND v(dout0_232) AT=495.025n

.meas tran vdout0_233ck980 FIND v(dout0_233) AT=495.025n

.meas tran vdout0_234ck980 FIND v(dout0_234) AT=495.025n

.meas tran vdout0_235ck980 FIND v(dout0_235) AT=495.025n

.meas tran vdout0_236ck980 FIND v(dout0_236) AT=495.025n

.meas tran vdout0_237ck980 FIND v(dout0_237) AT=495.025n

.meas tran vdout0_238ck980 FIND v(dout0_238) AT=495.025n

.meas tran vdout0_239ck980 FIND v(dout0_239) AT=495.025n

.meas tran vdout0_240ck980 FIND v(dout0_240) AT=495.025n

.meas tran vdout0_241ck980 FIND v(dout0_241) AT=495.025n

.meas tran vdout0_242ck980 FIND v(dout0_242) AT=495.025n

.meas tran vdout0_243ck980 FIND v(dout0_243) AT=495.025n

.meas tran vdout0_244ck980 FIND v(dout0_244) AT=495.025n

.meas tran vdout0_245ck980 FIND v(dout0_245) AT=495.025n

.meas tran vdout0_246ck980 FIND v(dout0_246) AT=495.025n

.meas tran vdout0_247ck980 FIND v(dout0_247) AT=495.025n

.meas tran vdout0_248ck980 FIND v(dout0_248) AT=495.025n

.meas tran vdout0_249ck980 FIND v(dout0_249) AT=495.025n

.meas tran vdout0_250ck980 FIND v(dout0_250) AT=495.025n

.meas tran vdout0_251ck980 FIND v(dout0_251) AT=495.025n

.meas tran vdout0_252ck980 FIND v(dout0_252) AT=495.025n

.meas tran vdout0_253ck980 FIND v(dout0_253) AT=495.025n

.meas tran vdout0_254ck980 FIND v(dout0_254) AT=495.025n

.meas tran vdout0_255ck980 FIND v(dout0_255) AT=495.025n

.meas tran vdout0_0ck990 FIND v(dout0_0) AT=500.025n

.meas tran vdout0_1ck990 FIND v(dout0_1) AT=500.025n

.meas tran vdout0_2ck990 FIND v(dout0_2) AT=500.025n

.meas tran vdout0_3ck990 FIND v(dout0_3) AT=500.025n

.meas tran vdout0_4ck990 FIND v(dout0_4) AT=500.025n

.meas tran vdout0_5ck990 FIND v(dout0_5) AT=500.025n

.meas tran vdout0_6ck990 FIND v(dout0_6) AT=500.025n

.meas tran vdout0_7ck990 FIND v(dout0_7) AT=500.025n

.meas tran vdout0_8ck990 FIND v(dout0_8) AT=500.025n

.meas tran vdout0_9ck990 FIND v(dout0_9) AT=500.025n

.meas tran vdout0_10ck990 FIND v(dout0_10) AT=500.025n

.meas tran vdout0_11ck990 FIND v(dout0_11) AT=500.025n

.meas tran vdout0_12ck990 FIND v(dout0_12) AT=500.025n

.meas tran vdout0_13ck990 FIND v(dout0_13) AT=500.025n

.meas tran vdout0_14ck990 FIND v(dout0_14) AT=500.025n

.meas tran vdout0_15ck990 FIND v(dout0_15) AT=500.025n

.meas tran vdout0_16ck990 FIND v(dout0_16) AT=500.025n

.meas tran vdout0_17ck990 FIND v(dout0_17) AT=500.025n

.meas tran vdout0_18ck990 FIND v(dout0_18) AT=500.025n

.meas tran vdout0_19ck990 FIND v(dout0_19) AT=500.025n

.meas tran vdout0_20ck990 FIND v(dout0_20) AT=500.025n

.meas tran vdout0_21ck990 FIND v(dout0_21) AT=500.025n

.meas tran vdout0_22ck990 FIND v(dout0_22) AT=500.025n

.meas tran vdout0_23ck990 FIND v(dout0_23) AT=500.025n

.meas tran vdout0_24ck990 FIND v(dout0_24) AT=500.025n

.meas tran vdout0_25ck990 FIND v(dout0_25) AT=500.025n

.meas tran vdout0_26ck990 FIND v(dout0_26) AT=500.025n

.meas tran vdout0_27ck990 FIND v(dout0_27) AT=500.025n

.meas tran vdout0_28ck990 FIND v(dout0_28) AT=500.025n

.meas tran vdout0_29ck990 FIND v(dout0_29) AT=500.025n

.meas tran vdout0_30ck990 FIND v(dout0_30) AT=500.025n

.meas tran vdout0_31ck990 FIND v(dout0_31) AT=500.025n

.meas tran vdout0_32ck990 FIND v(dout0_32) AT=500.025n

.meas tran vdout0_33ck990 FIND v(dout0_33) AT=500.025n

.meas tran vdout0_34ck990 FIND v(dout0_34) AT=500.025n

.meas tran vdout0_35ck990 FIND v(dout0_35) AT=500.025n

.meas tran vdout0_36ck990 FIND v(dout0_36) AT=500.025n

.meas tran vdout0_37ck990 FIND v(dout0_37) AT=500.025n

.meas tran vdout0_38ck990 FIND v(dout0_38) AT=500.025n

.meas tran vdout0_39ck990 FIND v(dout0_39) AT=500.025n

.meas tran vdout0_40ck990 FIND v(dout0_40) AT=500.025n

.meas tran vdout0_41ck990 FIND v(dout0_41) AT=500.025n

.meas tran vdout0_42ck990 FIND v(dout0_42) AT=500.025n

.meas tran vdout0_43ck990 FIND v(dout0_43) AT=500.025n

.meas tran vdout0_44ck990 FIND v(dout0_44) AT=500.025n

.meas tran vdout0_45ck990 FIND v(dout0_45) AT=500.025n

.meas tran vdout0_46ck990 FIND v(dout0_46) AT=500.025n

.meas tran vdout0_47ck990 FIND v(dout0_47) AT=500.025n

.meas tran vdout0_48ck990 FIND v(dout0_48) AT=500.025n

.meas tran vdout0_49ck990 FIND v(dout0_49) AT=500.025n

.meas tran vdout0_50ck990 FIND v(dout0_50) AT=500.025n

.meas tran vdout0_51ck990 FIND v(dout0_51) AT=500.025n

.meas tran vdout0_52ck990 FIND v(dout0_52) AT=500.025n

.meas tran vdout0_53ck990 FIND v(dout0_53) AT=500.025n

.meas tran vdout0_54ck990 FIND v(dout0_54) AT=500.025n

.meas tran vdout0_55ck990 FIND v(dout0_55) AT=500.025n

.meas tran vdout0_56ck990 FIND v(dout0_56) AT=500.025n

.meas tran vdout0_57ck990 FIND v(dout0_57) AT=500.025n

.meas tran vdout0_58ck990 FIND v(dout0_58) AT=500.025n

.meas tran vdout0_59ck990 FIND v(dout0_59) AT=500.025n

.meas tran vdout0_60ck990 FIND v(dout0_60) AT=500.025n

.meas tran vdout0_61ck990 FIND v(dout0_61) AT=500.025n

.meas tran vdout0_62ck990 FIND v(dout0_62) AT=500.025n

.meas tran vdout0_63ck990 FIND v(dout0_63) AT=500.025n

.meas tran vdout0_64ck990 FIND v(dout0_64) AT=500.025n

.meas tran vdout0_65ck990 FIND v(dout0_65) AT=500.025n

.meas tran vdout0_66ck990 FIND v(dout0_66) AT=500.025n

.meas tran vdout0_67ck990 FIND v(dout0_67) AT=500.025n

.meas tran vdout0_68ck990 FIND v(dout0_68) AT=500.025n

.meas tran vdout0_69ck990 FIND v(dout0_69) AT=500.025n

.meas tran vdout0_70ck990 FIND v(dout0_70) AT=500.025n

.meas tran vdout0_71ck990 FIND v(dout0_71) AT=500.025n

.meas tran vdout0_72ck990 FIND v(dout0_72) AT=500.025n

.meas tran vdout0_73ck990 FIND v(dout0_73) AT=500.025n

.meas tran vdout0_74ck990 FIND v(dout0_74) AT=500.025n

.meas tran vdout0_75ck990 FIND v(dout0_75) AT=500.025n

.meas tran vdout0_76ck990 FIND v(dout0_76) AT=500.025n

.meas tran vdout0_77ck990 FIND v(dout0_77) AT=500.025n

.meas tran vdout0_78ck990 FIND v(dout0_78) AT=500.025n

.meas tran vdout0_79ck990 FIND v(dout0_79) AT=500.025n

.meas tran vdout0_80ck990 FIND v(dout0_80) AT=500.025n

.meas tran vdout0_81ck990 FIND v(dout0_81) AT=500.025n

.meas tran vdout0_82ck990 FIND v(dout0_82) AT=500.025n

.meas tran vdout0_83ck990 FIND v(dout0_83) AT=500.025n

.meas tran vdout0_84ck990 FIND v(dout0_84) AT=500.025n

.meas tran vdout0_85ck990 FIND v(dout0_85) AT=500.025n

.meas tran vdout0_86ck990 FIND v(dout0_86) AT=500.025n

.meas tran vdout0_87ck990 FIND v(dout0_87) AT=500.025n

.meas tran vdout0_88ck990 FIND v(dout0_88) AT=500.025n

.meas tran vdout0_89ck990 FIND v(dout0_89) AT=500.025n

.meas tran vdout0_90ck990 FIND v(dout0_90) AT=500.025n

.meas tran vdout0_91ck990 FIND v(dout0_91) AT=500.025n

.meas tran vdout0_92ck990 FIND v(dout0_92) AT=500.025n

.meas tran vdout0_93ck990 FIND v(dout0_93) AT=500.025n

.meas tran vdout0_94ck990 FIND v(dout0_94) AT=500.025n

.meas tran vdout0_95ck990 FIND v(dout0_95) AT=500.025n

.meas tran vdout0_96ck990 FIND v(dout0_96) AT=500.025n

.meas tran vdout0_97ck990 FIND v(dout0_97) AT=500.025n

.meas tran vdout0_98ck990 FIND v(dout0_98) AT=500.025n

.meas tran vdout0_99ck990 FIND v(dout0_99) AT=500.025n

.meas tran vdout0_100ck990 FIND v(dout0_100) AT=500.025n

.meas tran vdout0_101ck990 FIND v(dout0_101) AT=500.025n

.meas tran vdout0_102ck990 FIND v(dout0_102) AT=500.025n

.meas tran vdout0_103ck990 FIND v(dout0_103) AT=500.025n

.meas tran vdout0_104ck990 FIND v(dout0_104) AT=500.025n

.meas tran vdout0_105ck990 FIND v(dout0_105) AT=500.025n

.meas tran vdout0_106ck990 FIND v(dout0_106) AT=500.025n

.meas tran vdout0_107ck990 FIND v(dout0_107) AT=500.025n

.meas tran vdout0_108ck990 FIND v(dout0_108) AT=500.025n

.meas tran vdout0_109ck990 FIND v(dout0_109) AT=500.025n

.meas tran vdout0_110ck990 FIND v(dout0_110) AT=500.025n

.meas tran vdout0_111ck990 FIND v(dout0_111) AT=500.025n

.meas tran vdout0_112ck990 FIND v(dout0_112) AT=500.025n

.meas tran vdout0_113ck990 FIND v(dout0_113) AT=500.025n

.meas tran vdout0_114ck990 FIND v(dout0_114) AT=500.025n

.meas tran vdout0_115ck990 FIND v(dout0_115) AT=500.025n

.meas tran vdout0_116ck990 FIND v(dout0_116) AT=500.025n

.meas tran vdout0_117ck990 FIND v(dout0_117) AT=500.025n

.meas tran vdout0_118ck990 FIND v(dout0_118) AT=500.025n

.meas tran vdout0_119ck990 FIND v(dout0_119) AT=500.025n

.meas tran vdout0_120ck990 FIND v(dout0_120) AT=500.025n

.meas tran vdout0_121ck990 FIND v(dout0_121) AT=500.025n

.meas tran vdout0_122ck990 FIND v(dout0_122) AT=500.025n

.meas tran vdout0_123ck990 FIND v(dout0_123) AT=500.025n

.meas tran vdout0_124ck990 FIND v(dout0_124) AT=500.025n

.meas tran vdout0_125ck990 FIND v(dout0_125) AT=500.025n

.meas tran vdout0_126ck990 FIND v(dout0_126) AT=500.025n

.meas tran vdout0_127ck990 FIND v(dout0_127) AT=500.025n

.meas tran vdout0_128ck990 FIND v(dout0_128) AT=500.025n

.meas tran vdout0_129ck990 FIND v(dout0_129) AT=500.025n

.meas tran vdout0_130ck990 FIND v(dout0_130) AT=500.025n

.meas tran vdout0_131ck990 FIND v(dout0_131) AT=500.025n

.meas tran vdout0_132ck990 FIND v(dout0_132) AT=500.025n

.meas tran vdout0_133ck990 FIND v(dout0_133) AT=500.025n

.meas tran vdout0_134ck990 FIND v(dout0_134) AT=500.025n

.meas tran vdout0_135ck990 FIND v(dout0_135) AT=500.025n

.meas tran vdout0_136ck990 FIND v(dout0_136) AT=500.025n

.meas tran vdout0_137ck990 FIND v(dout0_137) AT=500.025n

.meas tran vdout0_138ck990 FIND v(dout0_138) AT=500.025n

.meas tran vdout0_139ck990 FIND v(dout0_139) AT=500.025n

.meas tran vdout0_140ck990 FIND v(dout0_140) AT=500.025n

.meas tran vdout0_141ck990 FIND v(dout0_141) AT=500.025n

.meas tran vdout0_142ck990 FIND v(dout0_142) AT=500.025n

.meas tran vdout0_143ck990 FIND v(dout0_143) AT=500.025n

.meas tran vdout0_144ck990 FIND v(dout0_144) AT=500.025n

.meas tran vdout0_145ck990 FIND v(dout0_145) AT=500.025n

.meas tran vdout0_146ck990 FIND v(dout0_146) AT=500.025n

.meas tran vdout0_147ck990 FIND v(dout0_147) AT=500.025n

.meas tran vdout0_148ck990 FIND v(dout0_148) AT=500.025n

.meas tran vdout0_149ck990 FIND v(dout0_149) AT=500.025n

.meas tran vdout0_150ck990 FIND v(dout0_150) AT=500.025n

.meas tran vdout0_151ck990 FIND v(dout0_151) AT=500.025n

.meas tran vdout0_152ck990 FIND v(dout0_152) AT=500.025n

.meas tran vdout0_153ck990 FIND v(dout0_153) AT=500.025n

.meas tran vdout0_154ck990 FIND v(dout0_154) AT=500.025n

.meas tran vdout0_155ck990 FIND v(dout0_155) AT=500.025n

.meas tran vdout0_156ck990 FIND v(dout0_156) AT=500.025n

.meas tran vdout0_157ck990 FIND v(dout0_157) AT=500.025n

.meas tran vdout0_158ck990 FIND v(dout0_158) AT=500.025n

.meas tran vdout0_159ck990 FIND v(dout0_159) AT=500.025n

.meas tran vdout0_160ck990 FIND v(dout0_160) AT=500.025n

.meas tran vdout0_161ck990 FIND v(dout0_161) AT=500.025n

.meas tran vdout0_162ck990 FIND v(dout0_162) AT=500.025n

.meas tran vdout0_163ck990 FIND v(dout0_163) AT=500.025n

.meas tran vdout0_164ck990 FIND v(dout0_164) AT=500.025n

.meas tran vdout0_165ck990 FIND v(dout0_165) AT=500.025n

.meas tran vdout0_166ck990 FIND v(dout0_166) AT=500.025n

.meas tran vdout0_167ck990 FIND v(dout0_167) AT=500.025n

.meas tran vdout0_168ck990 FIND v(dout0_168) AT=500.025n

.meas tran vdout0_169ck990 FIND v(dout0_169) AT=500.025n

.meas tran vdout0_170ck990 FIND v(dout0_170) AT=500.025n

.meas tran vdout0_171ck990 FIND v(dout0_171) AT=500.025n

.meas tran vdout0_172ck990 FIND v(dout0_172) AT=500.025n

.meas tran vdout0_173ck990 FIND v(dout0_173) AT=500.025n

.meas tran vdout0_174ck990 FIND v(dout0_174) AT=500.025n

.meas tran vdout0_175ck990 FIND v(dout0_175) AT=500.025n

.meas tran vdout0_176ck990 FIND v(dout0_176) AT=500.025n

.meas tran vdout0_177ck990 FIND v(dout0_177) AT=500.025n

.meas tran vdout0_178ck990 FIND v(dout0_178) AT=500.025n

.meas tran vdout0_179ck990 FIND v(dout0_179) AT=500.025n

.meas tran vdout0_180ck990 FIND v(dout0_180) AT=500.025n

.meas tran vdout0_181ck990 FIND v(dout0_181) AT=500.025n

.meas tran vdout0_182ck990 FIND v(dout0_182) AT=500.025n

.meas tran vdout0_183ck990 FIND v(dout0_183) AT=500.025n

.meas tran vdout0_184ck990 FIND v(dout0_184) AT=500.025n

.meas tran vdout0_185ck990 FIND v(dout0_185) AT=500.025n

.meas tran vdout0_186ck990 FIND v(dout0_186) AT=500.025n

.meas tran vdout0_187ck990 FIND v(dout0_187) AT=500.025n

.meas tran vdout0_188ck990 FIND v(dout0_188) AT=500.025n

.meas tran vdout0_189ck990 FIND v(dout0_189) AT=500.025n

.meas tran vdout0_190ck990 FIND v(dout0_190) AT=500.025n

.meas tran vdout0_191ck990 FIND v(dout0_191) AT=500.025n

.meas tran vdout0_192ck990 FIND v(dout0_192) AT=500.025n

.meas tran vdout0_193ck990 FIND v(dout0_193) AT=500.025n

.meas tran vdout0_194ck990 FIND v(dout0_194) AT=500.025n

.meas tran vdout0_195ck990 FIND v(dout0_195) AT=500.025n

.meas tran vdout0_196ck990 FIND v(dout0_196) AT=500.025n

.meas tran vdout0_197ck990 FIND v(dout0_197) AT=500.025n

.meas tran vdout0_198ck990 FIND v(dout0_198) AT=500.025n

.meas tran vdout0_199ck990 FIND v(dout0_199) AT=500.025n

.meas tran vdout0_200ck990 FIND v(dout0_200) AT=500.025n

.meas tran vdout0_201ck990 FIND v(dout0_201) AT=500.025n

.meas tran vdout0_202ck990 FIND v(dout0_202) AT=500.025n

.meas tran vdout0_203ck990 FIND v(dout0_203) AT=500.025n

.meas tran vdout0_204ck990 FIND v(dout0_204) AT=500.025n

.meas tran vdout0_205ck990 FIND v(dout0_205) AT=500.025n

.meas tran vdout0_206ck990 FIND v(dout0_206) AT=500.025n

.meas tran vdout0_207ck990 FIND v(dout0_207) AT=500.025n

.meas tran vdout0_208ck990 FIND v(dout0_208) AT=500.025n

.meas tran vdout0_209ck990 FIND v(dout0_209) AT=500.025n

.meas tran vdout0_210ck990 FIND v(dout0_210) AT=500.025n

.meas tran vdout0_211ck990 FIND v(dout0_211) AT=500.025n

.meas tran vdout0_212ck990 FIND v(dout0_212) AT=500.025n

.meas tran vdout0_213ck990 FIND v(dout0_213) AT=500.025n

.meas tran vdout0_214ck990 FIND v(dout0_214) AT=500.025n

.meas tran vdout0_215ck990 FIND v(dout0_215) AT=500.025n

.meas tran vdout0_216ck990 FIND v(dout0_216) AT=500.025n

.meas tran vdout0_217ck990 FIND v(dout0_217) AT=500.025n

.meas tran vdout0_218ck990 FIND v(dout0_218) AT=500.025n

.meas tran vdout0_219ck990 FIND v(dout0_219) AT=500.025n

.meas tran vdout0_220ck990 FIND v(dout0_220) AT=500.025n

.meas tran vdout0_221ck990 FIND v(dout0_221) AT=500.025n

.meas tran vdout0_222ck990 FIND v(dout0_222) AT=500.025n

.meas tran vdout0_223ck990 FIND v(dout0_223) AT=500.025n

.meas tran vdout0_224ck990 FIND v(dout0_224) AT=500.025n

.meas tran vdout0_225ck990 FIND v(dout0_225) AT=500.025n

.meas tran vdout0_226ck990 FIND v(dout0_226) AT=500.025n

.meas tran vdout0_227ck990 FIND v(dout0_227) AT=500.025n

.meas tran vdout0_228ck990 FIND v(dout0_228) AT=500.025n

.meas tran vdout0_229ck990 FIND v(dout0_229) AT=500.025n

.meas tran vdout0_230ck990 FIND v(dout0_230) AT=500.025n

.meas tran vdout0_231ck990 FIND v(dout0_231) AT=500.025n

.meas tran vdout0_232ck990 FIND v(dout0_232) AT=500.025n

.meas tran vdout0_233ck990 FIND v(dout0_233) AT=500.025n

.meas tran vdout0_234ck990 FIND v(dout0_234) AT=500.025n

.meas tran vdout0_235ck990 FIND v(dout0_235) AT=500.025n

.meas tran vdout0_236ck990 FIND v(dout0_236) AT=500.025n

.meas tran vdout0_237ck990 FIND v(dout0_237) AT=500.025n

.meas tran vdout0_238ck990 FIND v(dout0_238) AT=500.025n

.meas tran vdout0_239ck990 FIND v(dout0_239) AT=500.025n

.meas tran vdout0_240ck990 FIND v(dout0_240) AT=500.025n

.meas tran vdout0_241ck990 FIND v(dout0_241) AT=500.025n

.meas tran vdout0_242ck990 FIND v(dout0_242) AT=500.025n

.meas tran vdout0_243ck990 FIND v(dout0_243) AT=500.025n

.meas tran vdout0_244ck990 FIND v(dout0_244) AT=500.025n

.meas tran vdout0_245ck990 FIND v(dout0_245) AT=500.025n

.meas tran vdout0_246ck990 FIND v(dout0_246) AT=500.025n

.meas tran vdout0_247ck990 FIND v(dout0_247) AT=500.025n

.meas tran vdout0_248ck990 FIND v(dout0_248) AT=500.025n

.meas tran vdout0_249ck990 FIND v(dout0_249) AT=500.025n

.meas tran vdout0_250ck990 FIND v(dout0_250) AT=500.025n

.meas tran vdout0_251ck990 FIND v(dout0_251) AT=500.025n

.meas tran vdout0_252ck990 FIND v(dout0_252) AT=500.025n

.meas tran vdout0_253ck990 FIND v(dout0_253) AT=500.025n

.meas tran vdout0_254ck990 FIND v(dout0_254) AT=500.025n

.meas tran vdout0_255ck990 FIND v(dout0_255) AT=500.025n

.meas tran vdout0_0ck1010 FIND v(dout0_0) AT=510.025n

.meas tran vdout0_1ck1010 FIND v(dout0_1) AT=510.025n

.meas tran vdout0_2ck1010 FIND v(dout0_2) AT=510.025n

.meas tran vdout0_3ck1010 FIND v(dout0_3) AT=510.025n

.meas tran vdout0_4ck1010 FIND v(dout0_4) AT=510.025n

.meas tran vdout0_5ck1010 FIND v(dout0_5) AT=510.025n

.meas tran vdout0_6ck1010 FIND v(dout0_6) AT=510.025n

.meas tran vdout0_7ck1010 FIND v(dout0_7) AT=510.025n

.meas tran vdout0_8ck1010 FIND v(dout0_8) AT=510.025n

.meas tran vdout0_9ck1010 FIND v(dout0_9) AT=510.025n

.meas tran vdout0_10ck1010 FIND v(dout0_10) AT=510.025n

.meas tran vdout0_11ck1010 FIND v(dout0_11) AT=510.025n

.meas tran vdout0_12ck1010 FIND v(dout0_12) AT=510.025n

.meas tran vdout0_13ck1010 FIND v(dout0_13) AT=510.025n

.meas tran vdout0_14ck1010 FIND v(dout0_14) AT=510.025n

.meas tran vdout0_15ck1010 FIND v(dout0_15) AT=510.025n

.meas tran vdout0_16ck1010 FIND v(dout0_16) AT=510.025n

.meas tran vdout0_17ck1010 FIND v(dout0_17) AT=510.025n

.meas tran vdout0_18ck1010 FIND v(dout0_18) AT=510.025n

.meas tran vdout0_19ck1010 FIND v(dout0_19) AT=510.025n

.meas tran vdout0_20ck1010 FIND v(dout0_20) AT=510.025n

.meas tran vdout0_21ck1010 FIND v(dout0_21) AT=510.025n

.meas tran vdout0_22ck1010 FIND v(dout0_22) AT=510.025n

.meas tran vdout0_23ck1010 FIND v(dout0_23) AT=510.025n

.meas tran vdout0_24ck1010 FIND v(dout0_24) AT=510.025n

.meas tran vdout0_25ck1010 FIND v(dout0_25) AT=510.025n

.meas tran vdout0_26ck1010 FIND v(dout0_26) AT=510.025n

.meas tran vdout0_27ck1010 FIND v(dout0_27) AT=510.025n

.meas tran vdout0_28ck1010 FIND v(dout0_28) AT=510.025n

.meas tran vdout0_29ck1010 FIND v(dout0_29) AT=510.025n

.meas tran vdout0_30ck1010 FIND v(dout0_30) AT=510.025n

.meas tran vdout0_31ck1010 FIND v(dout0_31) AT=510.025n

.meas tran vdout0_32ck1010 FIND v(dout0_32) AT=510.025n

.meas tran vdout0_33ck1010 FIND v(dout0_33) AT=510.025n

.meas tran vdout0_34ck1010 FIND v(dout0_34) AT=510.025n

.meas tran vdout0_35ck1010 FIND v(dout0_35) AT=510.025n

.meas tran vdout0_36ck1010 FIND v(dout0_36) AT=510.025n

.meas tran vdout0_37ck1010 FIND v(dout0_37) AT=510.025n

.meas tran vdout0_38ck1010 FIND v(dout0_38) AT=510.025n

.meas tran vdout0_39ck1010 FIND v(dout0_39) AT=510.025n

.meas tran vdout0_40ck1010 FIND v(dout0_40) AT=510.025n

.meas tran vdout0_41ck1010 FIND v(dout0_41) AT=510.025n

.meas tran vdout0_42ck1010 FIND v(dout0_42) AT=510.025n

.meas tran vdout0_43ck1010 FIND v(dout0_43) AT=510.025n

.meas tran vdout0_44ck1010 FIND v(dout0_44) AT=510.025n

.meas tran vdout0_45ck1010 FIND v(dout0_45) AT=510.025n

.meas tran vdout0_46ck1010 FIND v(dout0_46) AT=510.025n

.meas tran vdout0_47ck1010 FIND v(dout0_47) AT=510.025n

.meas tran vdout0_48ck1010 FIND v(dout0_48) AT=510.025n

.meas tran vdout0_49ck1010 FIND v(dout0_49) AT=510.025n

.meas tran vdout0_50ck1010 FIND v(dout0_50) AT=510.025n

.meas tran vdout0_51ck1010 FIND v(dout0_51) AT=510.025n

.meas tran vdout0_52ck1010 FIND v(dout0_52) AT=510.025n

.meas tran vdout0_53ck1010 FIND v(dout0_53) AT=510.025n

.meas tran vdout0_54ck1010 FIND v(dout0_54) AT=510.025n

.meas tran vdout0_55ck1010 FIND v(dout0_55) AT=510.025n

.meas tran vdout0_56ck1010 FIND v(dout0_56) AT=510.025n

.meas tran vdout0_57ck1010 FIND v(dout0_57) AT=510.025n

.meas tran vdout0_58ck1010 FIND v(dout0_58) AT=510.025n

.meas tran vdout0_59ck1010 FIND v(dout0_59) AT=510.025n

.meas tran vdout0_60ck1010 FIND v(dout0_60) AT=510.025n

.meas tran vdout0_61ck1010 FIND v(dout0_61) AT=510.025n

.meas tran vdout0_62ck1010 FIND v(dout0_62) AT=510.025n

.meas tran vdout0_63ck1010 FIND v(dout0_63) AT=510.025n

.meas tran vdout0_64ck1010 FIND v(dout0_64) AT=510.025n

.meas tran vdout0_65ck1010 FIND v(dout0_65) AT=510.025n

.meas tran vdout0_66ck1010 FIND v(dout0_66) AT=510.025n

.meas tran vdout0_67ck1010 FIND v(dout0_67) AT=510.025n

.meas tran vdout0_68ck1010 FIND v(dout0_68) AT=510.025n

.meas tran vdout0_69ck1010 FIND v(dout0_69) AT=510.025n

.meas tran vdout0_70ck1010 FIND v(dout0_70) AT=510.025n

.meas tran vdout0_71ck1010 FIND v(dout0_71) AT=510.025n

.meas tran vdout0_72ck1010 FIND v(dout0_72) AT=510.025n

.meas tran vdout0_73ck1010 FIND v(dout0_73) AT=510.025n

.meas tran vdout0_74ck1010 FIND v(dout0_74) AT=510.025n

.meas tran vdout0_75ck1010 FIND v(dout0_75) AT=510.025n

.meas tran vdout0_76ck1010 FIND v(dout0_76) AT=510.025n

.meas tran vdout0_77ck1010 FIND v(dout0_77) AT=510.025n

.meas tran vdout0_78ck1010 FIND v(dout0_78) AT=510.025n

.meas tran vdout0_79ck1010 FIND v(dout0_79) AT=510.025n

.meas tran vdout0_80ck1010 FIND v(dout0_80) AT=510.025n

.meas tran vdout0_81ck1010 FIND v(dout0_81) AT=510.025n

.meas tran vdout0_82ck1010 FIND v(dout0_82) AT=510.025n

.meas tran vdout0_83ck1010 FIND v(dout0_83) AT=510.025n

.meas tran vdout0_84ck1010 FIND v(dout0_84) AT=510.025n

.meas tran vdout0_85ck1010 FIND v(dout0_85) AT=510.025n

.meas tran vdout0_86ck1010 FIND v(dout0_86) AT=510.025n

.meas tran vdout0_87ck1010 FIND v(dout0_87) AT=510.025n

.meas tran vdout0_88ck1010 FIND v(dout0_88) AT=510.025n

.meas tran vdout0_89ck1010 FIND v(dout0_89) AT=510.025n

.meas tran vdout0_90ck1010 FIND v(dout0_90) AT=510.025n

.meas tran vdout0_91ck1010 FIND v(dout0_91) AT=510.025n

.meas tran vdout0_92ck1010 FIND v(dout0_92) AT=510.025n

.meas tran vdout0_93ck1010 FIND v(dout0_93) AT=510.025n

.meas tran vdout0_94ck1010 FIND v(dout0_94) AT=510.025n

.meas tran vdout0_95ck1010 FIND v(dout0_95) AT=510.025n

.meas tran vdout0_96ck1010 FIND v(dout0_96) AT=510.025n

.meas tran vdout0_97ck1010 FIND v(dout0_97) AT=510.025n

.meas tran vdout0_98ck1010 FIND v(dout0_98) AT=510.025n

.meas tran vdout0_99ck1010 FIND v(dout0_99) AT=510.025n

.meas tran vdout0_100ck1010 FIND v(dout0_100) AT=510.025n

.meas tran vdout0_101ck1010 FIND v(dout0_101) AT=510.025n

.meas tran vdout0_102ck1010 FIND v(dout0_102) AT=510.025n

.meas tran vdout0_103ck1010 FIND v(dout0_103) AT=510.025n

.meas tran vdout0_104ck1010 FIND v(dout0_104) AT=510.025n

.meas tran vdout0_105ck1010 FIND v(dout0_105) AT=510.025n

.meas tran vdout0_106ck1010 FIND v(dout0_106) AT=510.025n

.meas tran vdout0_107ck1010 FIND v(dout0_107) AT=510.025n

.meas tran vdout0_108ck1010 FIND v(dout0_108) AT=510.025n

.meas tran vdout0_109ck1010 FIND v(dout0_109) AT=510.025n

.meas tran vdout0_110ck1010 FIND v(dout0_110) AT=510.025n

.meas tran vdout0_111ck1010 FIND v(dout0_111) AT=510.025n

.meas tran vdout0_112ck1010 FIND v(dout0_112) AT=510.025n

.meas tran vdout0_113ck1010 FIND v(dout0_113) AT=510.025n

.meas tran vdout0_114ck1010 FIND v(dout0_114) AT=510.025n

.meas tran vdout0_115ck1010 FIND v(dout0_115) AT=510.025n

.meas tran vdout0_116ck1010 FIND v(dout0_116) AT=510.025n

.meas tran vdout0_117ck1010 FIND v(dout0_117) AT=510.025n

.meas tran vdout0_118ck1010 FIND v(dout0_118) AT=510.025n

.meas tran vdout0_119ck1010 FIND v(dout0_119) AT=510.025n

.meas tran vdout0_120ck1010 FIND v(dout0_120) AT=510.025n

.meas tran vdout0_121ck1010 FIND v(dout0_121) AT=510.025n

.meas tran vdout0_122ck1010 FIND v(dout0_122) AT=510.025n

.meas tran vdout0_123ck1010 FIND v(dout0_123) AT=510.025n

.meas tran vdout0_124ck1010 FIND v(dout0_124) AT=510.025n

.meas tran vdout0_125ck1010 FIND v(dout0_125) AT=510.025n

.meas tran vdout0_126ck1010 FIND v(dout0_126) AT=510.025n

.meas tran vdout0_127ck1010 FIND v(dout0_127) AT=510.025n

.meas tran vdout0_128ck1010 FIND v(dout0_128) AT=510.025n

.meas tran vdout0_129ck1010 FIND v(dout0_129) AT=510.025n

.meas tran vdout0_130ck1010 FIND v(dout0_130) AT=510.025n

.meas tran vdout0_131ck1010 FIND v(dout0_131) AT=510.025n

.meas tran vdout0_132ck1010 FIND v(dout0_132) AT=510.025n

.meas tran vdout0_133ck1010 FIND v(dout0_133) AT=510.025n

.meas tran vdout0_134ck1010 FIND v(dout0_134) AT=510.025n

.meas tran vdout0_135ck1010 FIND v(dout0_135) AT=510.025n

.meas tran vdout0_136ck1010 FIND v(dout0_136) AT=510.025n

.meas tran vdout0_137ck1010 FIND v(dout0_137) AT=510.025n

.meas tran vdout0_138ck1010 FIND v(dout0_138) AT=510.025n

.meas tran vdout0_139ck1010 FIND v(dout0_139) AT=510.025n

.meas tran vdout0_140ck1010 FIND v(dout0_140) AT=510.025n

.meas tran vdout0_141ck1010 FIND v(dout0_141) AT=510.025n

.meas tran vdout0_142ck1010 FIND v(dout0_142) AT=510.025n

.meas tran vdout0_143ck1010 FIND v(dout0_143) AT=510.025n

.meas tran vdout0_144ck1010 FIND v(dout0_144) AT=510.025n

.meas tran vdout0_145ck1010 FIND v(dout0_145) AT=510.025n

.meas tran vdout0_146ck1010 FIND v(dout0_146) AT=510.025n

.meas tran vdout0_147ck1010 FIND v(dout0_147) AT=510.025n

.meas tran vdout0_148ck1010 FIND v(dout0_148) AT=510.025n

.meas tran vdout0_149ck1010 FIND v(dout0_149) AT=510.025n

.meas tran vdout0_150ck1010 FIND v(dout0_150) AT=510.025n

.meas tran vdout0_151ck1010 FIND v(dout0_151) AT=510.025n

.meas tran vdout0_152ck1010 FIND v(dout0_152) AT=510.025n

.meas tran vdout0_153ck1010 FIND v(dout0_153) AT=510.025n

.meas tran vdout0_154ck1010 FIND v(dout0_154) AT=510.025n

.meas tran vdout0_155ck1010 FIND v(dout0_155) AT=510.025n

.meas tran vdout0_156ck1010 FIND v(dout0_156) AT=510.025n

.meas tran vdout0_157ck1010 FIND v(dout0_157) AT=510.025n

.meas tran vdout0_158ck1010 FIND v(dout0_158) AT=510.025n

.meas tran vdout0_159ck1010 FIND v(dout0_159) AT=510.025n

.meas tran vdout0_160ck1010 FIND v(dout0_160) AT=510.025n

.meas tran vdout0_161ck1010 FIND v(dout0_161) AT=510.025n

.meas tran vdout0_162ck1010 FIND v(dout0_162) AT=510.025n

.meas tran vdout0_163ck1010 FIND v(dout0_163) AT=510.025n

.meas tran vdout0_164ck1010 FIND v(dout0_164) AT=510.025n

.meas tran vdout0_165ck1010 FIND v(dout0_165) AT=510.025n

.meas tran vdout0_166ck1010 FIND v(dout0_166) AT=510.025n

.meas tran vdout0_167ck1010 FIND v(dout0_167) AT=510.025n

.meas tran vdout0_168ck1010 FIND v(dout0_168) AT=510.025n

.meas tran vdout0_169ck1010 FIND v(dout0_169) AT=510.025n

.meas tran vdout0_170ck1010 FIND v(dout0_170) AT=510.025n

.meas tran vdout0_171ck1010 FIND v(dout0_171) AT=510.025n

.meas tran vdout0_172ck1010 FIND v(dout0_172) AT=510.025n

.meas tran vdout0_173ck1010 FIND v(dout0_173) AT=510.025n

.meas tran vdout0_174ck1010 FIND v(dout0_174) AT=510.025n

.meas tran vdout0_175ck1010 FIND v(dout0_175) AT=510.025n

.meas tran vdout0_176ck1010 FIND v(dout0_176) AT=510.025n

.meas tran vdout0_177ck1010 FIND v(dout0_177) AT=510.025n

.meas tran vdout0_178ck1010 FIND v(dout0_178) AT=510.025n

.meas tran vdout0_179ck1010 FIND v(dout0_179) AT=510.025n

.meas tran vdout0_180ck1010 FIND v(dout0_180) AT=510.025n

.meas tran vdout0_181ck1010 FIND v(dout0_181) AT=510.025n

.meas tran vdout0_182ck1010 FIND v(dout0_182) AT=510.025n

.meas tran vdout0_183ck1010 FIND v(dout0_183) AT=510.025n

.meas tran vdout0_184ck1010 FIND v(dout0_184) AT=510.025n

.meas tran vdout0_185ck1010 FIND v(dout0_185) AT=510.025n

.meas tran vdout0_186ck1010 FIND v(dout0_186) AT=510.025n

.meas tran vdout0_187ck1010 FIND v(dout0_187) AT=510.025n

.meas tran vdout0_188ck1010 FIND v(dout0_188) AT=510.025n

.meas tran vdout0_189ck1010 FIND v(dout0_189) AT=510.025n

.meas tran vdout0_190ck1010 FIND v(dout0_190) AT=510.025n

.meas tran vdout0_191ck1010 FIND v(dout0_191) AT=510.025n

.meas tran vdout0_192ck1010 FIND v(dout0_192) AT=510.025n

.meas tran vdout0_193ck1010 FIND v(dout0_193) AT=510.025n

.meas tran vdout0_194ck1010 FIND v(dout0_194) AT=510.025n

.meas tran vdout0_195ck1010 FIND v(dout0_195) AT=510.025n

.meas tran vdout0_196ck1010 FIND v(dout0_196) AT=510.025n

.meas tran vdout0_197ck1010 FIND v(dout0_197) AT=510.025n

.meas tran vdout0_198ck1010 FIND v(dout0_198) AT=510.025n

.meas tran vdout0_199ck1010 FIND v(dout0_199) AT=510.025n

.meas tran vdout0_200ck1010 FIND v(dout0_200) AT=510.025n

.meas tran vdout0_201ck1010 FIND v(dout0_201) AT=510.025n

.meas tran vdout0_202ck1010 FIND v(dout0_202) AT=510.025n

.meas tran vdout0_203ck1010 FIND v(dout0_203) AT=510.025n

.meas tran vdout0_204ck1010 FIND v(dout0_204) AT=510.025n

.meas tran vdout0_205ck1010 FIND v(dout0_205) AT=510.025n

.meas tran vdout0_206ck1010 FIND v(dout0_206) AT=510.025n

.meas tran vdout0_207ck1010 FIND v(dout0_207) AT=510.025n

.meas tran vdout0_208ck1010 FIND v(dout0_208) AT=510.025n

.meas tran vdout0_209ck1010 FIND v(dout0_209) AT=510.025n

.meas tran vdout0_210ck1010 FIND v(dout0_210) AT=510.025n

.meas tran vdout0_211ck1010 FIND v(dout0_211) AT=510.025n

.meas tran vdout0_212ck1010 FIND v(dout0_212) AT=510.025n

.meas tran vdout0_213ck1010 FIND v(dout0_213) AT=510.025n

.meas tran vdout0_214ck1010 FIND v(dout0_214) AT=510.025n

.meas tran vdout0_215ck1010 FIND v(dout0_215) AT=510.025n

.meas tran vdout0_216ck1010 FIND v(dout0_216) AT=510.025n

.meas tran vdout0_217ck1010 FIND v(dout0_217) AT=510.025n

.meas tran vdout0_218ck1010 FIND v(dout0_218) AT=510.025n

.meas tran vdout0_219ck1010 FIND v(dout0_219) AT=510.025n

.meas tran vdout0_220ck1010 FIND v(dout0_220) AT=510.025n

.meas tran vdout0_221ck1010 FIND v(dout0_221) AT=510.025n

.meas tran vdout0_222ck1010 FIND v(dout0_222) AT=510.025n

.meas tran vdout0_223ck1010 FIND v(dout0_223) AT=510.025n

.meas tran vdout0_224ck1010 FIND v(dout0_224) AT=510.025n

.meas tran vdout0_225ck1010 FIND v(dout0_225) AT=510.025n

.meas tran vdout0_226ck1010 FIND v(dout0_226) AT=510.025n

.meas tran vdout0_227ck1010 FIND v(dout0_227) AT=510.025n

.meas tran vdout0_228ck1010 FIND v(dout0_228) AT=510.025n

.meas tran vdout0_229ck1010 FIND v(dout0_229) AT=510.025n

.meas tran vdout0_230ck1010 FIND v(dout0_230) AT=510.025n

.meas tran vdout0_231ck1010 FIND v(dout0_231) AT=510.025n

.meas tran vdout0_232ck1010 FIND v(dout0_232) AT=510.025n

.meas tran vdout0_233ck1010 FIND v(dout0_233) AT=510.025n

.meas tran vdout0_234ck1010 FIND v(dout0_234) AT=510.025n

.meas tran vdout0_235ck1010 FIND v(dout0_235) AT=510.025n

.meas tran vdout0_236ck1010 FIND v(dout0_236) AT=510.025n

.meas tran vdout0_237ck1010 FIND v(dout0_237) AT=510.025n

.meas tran vdout0_238ck1010 FIND v(dout0_238) AT=510.025n

.meas tran vdout0_239ck1010 FIND v(dout0_239) AT=510.025n

.meas tran vdout0_240ck1010 FIND v(dout0_240) AT=510.025n

.meas tran vdout0_241ck1010 FIND v(dout0_241) AT=510.025n

.meas tran vdout0_242ck1010 FIND v(dout0_242) AT=510.025n

.meas tran vdout0_243ck1010 FIND v(dout0_243) AT=510.025n

.meas tran vdout0_244ck1010 FIND v(dout0_244) AT=510.025n

.meas tran vdout0_245ck1010 FIND v(dout0_245) AT=510.025n

.meas tran vdout0_246ck1010 FIND v(dout0_246) AT=510.025n

.meas tran vdout0_247ck1010 FIND v(dout0_247) AT=510.025n

.meas tran vdout0_248ck1010 FIND v(dout0_248) AT=510.025n

.meas tran vdout0_249ck1010 FIND v(dout0_249) AT=510.025n

.meas tran vdout0_250ck1010 FIND v(dout0_250) AT=510.025n

.meas tran vdout0_251ck1010 FIND v(dout0_251) AT=510.025n

.meas tran vdout0_252ck1010 FIND v(dout0_252) AT=510.025n

.meas tran vdout0_253ck1010 FIND v(dout0_253) AT=510.025n

.meas tran vdout0_254ck1010 FIND v(dout0_254) AT=510.025n

.meas tran vdout0_255ck1010 FIND v(dout0_255) AT=510.025n

.meas tran vdout0_0ck1030 FIND v(dout0_0) AT=520.025n

.meas tran vdout0_1ck1030 FIND v(dout0_1) AT=520.025n

.meas tran vdout0_2ck1030 FIND v(dout0_2) AT=520.025n

.meas tran vdout0_3ck1030 FIND v(dout0_3) AT=520.025n

.meas tran vdout0_4ck1030 FIND v(dout0_4) AT=520.025n

.meas tran vdout0_5ck1030 FIND v(dout0_5) AT=520.025n

.meas tran vdout0_6ck1030 FIND v(dout0_6) AT=520.025n

.meas tran vdout0_7ck1030 FIND v(dout0_7) AT=520.025n

.meas tran vdout0_8ck1030 FIND v(dout0_8) AT=520.025n

.meas tran vdout0_9ck1030 FIND v(dout0_9) AT=520.025n

.meas tran vdout0_10ck1030 FIND v(dout0_10) AT=520.025n

.meas tran vdout0_11ck1030 FIND v(dout0_11) AT=520.025n

.meas tran vdout0_12ck1030 FIND v(dout0_12) AT=520.025n

.meas tran vdout0_13ck1030 FIND v(dout0_13) AT=520.025n

.meas tran vdout0_14ck1030 FIND v(dout0_14) AT=520.025n

.meas tran vdout0_15ck1030 FIND v(dout0_15) AT=520.025n

.meas tran vdout0_16ck1030 FIND v(dout0_16) AT=520.025n

.meas tran vdout0_17ck1030 FIND v(dout0_17) AT=520.025n

.meas tran vdout0_18ck1030 FIND v(dout0_18) AT=520.025n

.meas tran vdout0_19ck1030 FIND v(dout0_19) AT=520.025n

.meas tran vdout0_20ck1030 FIND v(dout0_20) AT=520.025n

.meas tran vdout0_21ck1030 FIND v(dout0_21) AT=520.025n

.meas tran vdout0_22ck1030 FIND v(dout0_22) AT=520.025n

.meas tran vdout0_23ck1030 FIND v(dout0_23) AT=520.025n

.meas tran vdout0_24ck1030 FIND v(dout0_24) AT=520.025n

.meas tran vdout0_25ck1030 FIND v(dout0_25) AT=520.025n

.meas tran vdout0_26ck1030 FIND v(dout0_26) AT=520.025n

.meas tran vdout0_27ck1030 FIND v(dout0_27) AT=520.025n

.meas tran vdout0_28ck1030 FIND v(dout0_28) AT=520.025n

.meas tran vdout0_29ck1030 FIND v(dout0_29) AT=520.025n

.meas tran vdout0_30ck1030 FIND v(dout0_30) AT=520.025n

.meas tran vdout0_31ck1030 FIND v(dout0_31) AT=520.025n

.meas tran vdout0_32ck1030 FIND v(dout0_32) AT=520.025n

.meas tran vdout0_33ck1030 FIND v(dout0_33) AT=520.025n

.meas tran vdout0_34ck1030 FIND v(dout0_34) AT=520.025n

.meas tran vdout0_35ck1030 FIND v(dout0_35) AT=520.025n

.meas tran vdout0_36ck1030 FIND v(dout0_36) AT=520.025n

.meas tran vdout0_37ck1030 FIND v(dout0_37) AT=520.025n

.meas tran vdout0_38ck1030 FIND v(dout0_38) AT=520.025n

.meas tran vdout0_39ck1030 FIND v(dout0_39) AT=520.025n

.meas tran vdout0_40ck1030 FIND v(dout0_40) AT=520.025n

.meas tran vdout0_41ck1030 FIND v(dout0_41) AT=520.025n

.meas tran vdout0_42ck1030 FIND v(dout0_42) AT=520.025n

.meas tran vdout0_43ck1030 FIND v(dout0_43) AT=520.025n

.meas tran vdout0_44ck1030 FIND v(dout0_44) AT=520.025n

.meas tran vdout0_45ck1030 FIND v(dout0_45) AT=520.025n

.meas tran vdout0_46ck1030 FIND v(dout0_46) AT=520.025n

.meas tran vdout0_47ck1030 FIND v(dout0_47) AT=520.025n

.meas tran vdout0_48ck1030 FIND v(dout0_48) AT=520.025n

.meas tran vdout0_49ck1030 FIND v(dout0_49) AT=520.025n

.meas tran vdout0_50ck1030 FIND v(dout0_50) AT=520.025n

.meas tran vdout0_51ck1030 FIND v(dout0_51) AT=520.025n

.meas tran vdout0_52ck1030 FIND v(dout0_52) AT=520.025n

.meas tran vdout0_53ck1030 FIND v(dout0_53) AT=520.025n

.meas tran vdout0_54ck1030 FIND v(dout0_54) AT=520.025n

.meas tran vdout0_55ck1030 FIND v(dout0_55) AT=520.025n

.meas tran vdout0_56ck1030 FIND v(dout0_56) AT=520.025n

.meas tran vdout0_57ck1030 FIND v(dout0_57) AT=520.025n

.meas tran vdout0_58ck1030 FIND v(dout0_58) AT=520.025n

.meas tran vdout0_59ck1030 FIND v(dout0_59) AT=520.025n

.meas tran vdout0_60ck1030 FIND v(dout0_60) AT=520.025n

.meas tran vdout0_61ck1030 FIND v(dout0_61) AT=520.025n

.meas tran vdout0_62ck1030 FIND v(dout0_62) AT=520.025n

.meas tran vdout0_63ck1030 FIND v(dout0_63) AT=520.025n

.meas tran vdout0_64ck1030 FIND v(dout0_64) AT=520.025n

.meas tran vdout0_65ck1030 FIND v(dout0_65) AT=520.025n

.meas tran vdout0_66ck1030 FIND v(dout0_66) AT=520.025n

.meas tran vdout0_67ck1030 FIND v(dout0_67) AT=520.025n

.meas tran vdout0_68ck1030 FIND v(dout0_68) AT=520.025n

.meas tran vdout0_69ck1030 FIND v(dout0_69) AT=520.025n

.meas tran vdout0_70ck1030 FIND v(dout0_70) AT=520.025n

.meas tran vdout0_71ck1030 FIND v(dout0_71) AT=520.025n

.meas tran vdout0_72ck1030 FIND v(dout0_72) AT=520.025n

.meas tran vdout0_73ck1030 FIND v(dout0_73) AT=520.025n

.meas tran vdout0_74ck1030 FIND v(dout0_74) AT=520.025n

.meas tran vdout0_75ck1030 FIND v(dout0_75) AT=520.025n

.meas tran vdout0_76ck1030 FIND v(dout0_76) AT=520.025n

.meas tran vdout0_77ck1030 FIND v(dout0_77) AT=520.025n

.meas tran vdout0_78ck1030 FIND v(dout0_78) AT=520.025n

.meas tran vdout0_79ck1030 FIND v(dout0_79) AT=520.025n

.meas tran vdout0_80ck1030 FIND v(dout0_80) AT=520.025n

.meas tran vdout0_81ck1030 FIND v(dout0_81) AT=520.025n

.meas tran vdout0_82ck1030 FIND v(dout0_82) AT=520.025n

.meas tran vdout0_83ck1030 FIND v(dout0_83) AT=520.025n

.meas tran vdout0_84ck1030 FIND v(dout0_84) AT=520.025n

.meas tran vdout0_85ck1030 FIND v(dout0_85) AT=520.025n

.meas tran vdout0_86ck1030 FIND v(dout0_86) AT=520.025n

.meas tran vdout0_87ck1030 FIND v(dout0_87) AT=520.025n

.meas tran vdout0_88ck1030 FIND v(dout0_88) AT=520.025n

.meas tran vdout0_89ck1030 FIND v(dout0_89) AT=520.025n

.meas tran vdout0_90ck1030 FIND v(dout0_90) AT=520.025n

.meas tran vdout0_91ck1030 FIND v(dout0_91) AT=520.025n

.meas tran vdout0_92ck1030 FIND v(dout0_92) AT=520.025n

.meas tran vdout0_93ck1030 FIND v(dout0_93) AT=520.025n

.meas tran vdout0_94ck1030 FIND v(dout0_94) AT=520.025n

.meas tran vdout0_95ck1030 FIND v(dout0_95) AT=520.025n

.meas tran vdout0_96ck1030 FIND v(dout0_96) AT=520.025n

.meas tran vdout0_97ck1030 FIND v(dout0_97) AT=520.025n

.meas tran vdout0_98ck1030 FIND v(dout0_98) AT=520.025n

.meas tran vdout0_99ck1030 FIND v(dout0_99) AT=520.025n

.meas tran vdout0_100ck1030 FIND v(dout0_100) AT=520.025n

.meas tran vdout0_101ck1030 FIND v(dout0_101) AT=520.025n

.meas tran vdout0_102ck1030 FIND v(dout0_102) AT=520.025n

.meas tran vdout0_103ck1030 FIND v(dout0_103) AT=520.025n

.meas tran vdout0_104ck1030 FIND v(dout0_104) AT=520.025n

.meas tran vdout0_105ck1030 FIND v(dout0_105) AT=520.025n

.meas tran vdout0_106ck1030 FIND v(dout0_106) AT=520.025n

.meas tran vdout0_107ck1030 FIND v(dout0_107) AT=520.025n

.meas tran vdout0_108ck1030 FIND v(dout0_108) AT=520.025n

.meas tran vdout0_109ck1030 FIND v(dout0_109) AT=520.025n

.meas tran vdout0_110ck1030 FIND v(dout0_110) AT=520.025n

.meas tran vdout0_111ck1030 FIND v(dout0_111) AT=520.025n

.meas tran vdout0_112ck1030 FIND v(dout0_112) AT=520.025n

.meas tran vdout0_113ck1030 FIND v(dout0_113) AT=520.025n

.meas tran vdout0_114ck1030 FIND v(dout0_114) AT=520.025n

.meas tran vdout0_115ck1030 FIND v(dout0_115) AT=520.025n

.meas tran vdout0_116ck1030 FIND v(dout0_116) AT=520.025n

.meas tran vdout0_117ck1030 FIND v(dout0_117) AT=520.025n

.meas tran vdout0_118ck1030 FIND v(dout0_118) AT=520.025n

.meas tran vdout0_119ck1030 FIND v(dout0_119) AT=520.025n

.meas tran vdout0_120ck1030 FIND v(dout0_120) AT=520.025n

.meas tran vdout0_121ck1030 FIND v(dout0_121) AT=520.025n

.meas tran vdout0_122ck1030 FIND v(dout0_122) AT=520.025n

.meas tran vdout0_123ck1030 FIND v(dout0_123) AT=520.025n

.meas tran vdout0_124ck1030 FIND v(dout0_124) AT=520.025n

.meas tran vdout0_125ck1030 FIND v(dout0_125) AT=520.025n

.meas tran vdout0_126ck1030 FIND v(dout0_126) AT=520.025n

.meas tran vdout0_127ck1030 FIND v(dout0_127) AT=520.025n

.meas tran vdout0_128ck1030 FIND v(dout0_128) AT=520.025n

.meas tran vdout0_129ck1030 FIND v(dout0_129) AT=520.025n

.meas tran vdout0_130ck1030 FIND v(dout0_130) AT=520.025n

.meas tran vdout0_131ck1030 FIND v(dout0_131) AT=520.025n

.meas tran vdout0_132ck1030 FIND v(dout0_132) AT=520.025n

.meas tran vdout0_133ck1030 FIND v(dout0_133) AT=520.025n

.meas tran vdout0_134ck1030 FIND v(dout0_134) AT=520.025n

.meas tran vdout0_135ck1030 FIND v(dout0_135) AT=520.025n

.meas tran vdout0_136ck1030 FIND v(dout0_136) AT=520.025n

.meas tran vdout0_137ck1030 FIND v(dout0_137) AT=520.025n

.meas tran vdout0_138ck1030 FIND v(dout0_138) AT=520.025n

.meas tran vdout0_139ck1030 FIND v(dout0_139) AT=520.025n

.meas tran vdout0_140ck1030 FIND v(dout0_140) AT=520.025n

.meas tran vdout0_141ck1030 FIND v(dout0_141) AT=520.025n

.meas tran vdout0_142ck1030 FIND v(dout0_142) AT=520.025n

.meas tran vdout0_143ck1030 FIND v(dout0_143) AT=520.025n

.meas tran vdout0_144ck1030 FIND v(dout0_144) AT=520.025n

.meas tran vdout0_145ck1030 FIND v(dout0_145) AT=520.025n

.meas tran vdout0_146ck1030 FIND v(dout0_146) AT=520.025n

.meas tran vdout0_147ck1030 FIND v(dout0_147) AT=520.025n

.meas tran vdout0_148ck1030 FIND v(dout0_148) AT=520.025n

.meas tran vdout0_149ck1030 FIND v(dout0_149) AT=520.025n

.meas tran vdout0_150ck1030 FIND v(dout0_150) AT=520.025n

.meas tran vdout0_151ck1030 FIND v(dout0_151) AT=520.025n

.meas tran vdout0_152ck1030 FIND v(dout0_152) AT=520.025n

.meas tran vdout0_153ck1030 FIND v(dout0_153) AT=520.025n

.meas tran vdout0_154ck1030 FIND v(dout0_154) AT=520.025n

.meas tran vdout0_155ck1030 FIND v(dout0_155) AT=520.025n

.meas tran vdout0_156ck1030 FIND v(dout0_156) AT=520.025n

.meas tran vdout0_157ck1030 FIND v(dout0_157) AT=520.025n

.meas tran vdout0_158ck1030 FIND v(dout0_158) AT=520.025n

.meas tran vdout0_159ck1030 FIND v(dout0_159) AT=520.025n

.meas tran vdout0_160ck1030 FIND v(dout0_160) AT=520.025n

.meas tran vdout0_161ck1030 FIND v(dout0_161) AT=520.025n

.meas tran vdout0_162ck1030 FIND v(dout0_162) AT=520.025n

.meas tran vdout0_163ck1030 FIND v(dout0_163) AT=520.025n

.meas tran vdout0_164ck1030 FIND v(dout0_164) AT=520.025n

.meas tran vdout0_165ck1030 FIND v(dout0_165) AT=520.025n

.meas tran vdout0_166ck1030 FIND v(dout0_166) AT=520.025n

.meas tran vdout0_167ck1030 FIND v(dout0_167) AT=520.025n

.meas tran vdout0_168ck1030 FIND v(dout0_168) AT=520.025n

.meas tran vdout0_169ck1030 FIND v(dout0_169) AT=520.025n

.meas tran vdout0_170ck1030 FIND v(dout0_170) AT=520.025n

.meas tran vdout0_171ck1030 FIND v(dout0_171) AT=520.025n

.meas tran vdout0_172ck1030 FIND v(dout0_172) AT=520.025n

.meas tran vdout0_173ck1030 FIND v(dout0_173) AT=520.025n

.meas tran vdout0_174ck1030 FIND v(dout0_174) AT=520.025n

.meas tran vdout0_175ck1030 FIND v(dout0_175) AT=520.025n

.meas tran vdout0_176ck1030 FIND v(dout0_176) AT=520.025n

.meas tran vdout0_177ck1030 FIND v(dout0_177) AT=520.025n

.meas tran vdout0_178ck1030 FIND v(dout0_178) AT=520.025n

.meas tran vdout0_179ck1030 FIND v(dout0_179) AT=520.025n

.meas tran vdout0_180ck1030 FIND v(dout0_180) AT=520.025n

.meas tran vdout0_181ck1030 FIND v(dout0_181) AT=520.025n

.meas tran vdout0_182ck1030 FIND v(dout0_182) AT=520.025n

.meas tran vdout0_183ck1030 FIND v(dout0_183) AT=520.025n

.meas tran vdout0_184ck1030 FIND v(dout0_184) AT=520.025n

.meas tran vdout0_185ck1030 FIND v(dout0_185) AT=520.025n

.meas tran vdout0_186ck1030 FIND v(dout0_186) AT=520.025n

.meas tran vdout0_187ck1030 FIND v(dout0_187) AT=520.025n

.meas tran vdout0_188ck1030 FIND v(dout0_188) AT=520.025n

.meas tran vdout0_189ck1030 FIND v(dout0_189) AT=520.025n

.meas tran vdout0_190ck1030 FIND v(dout0_190) AT=520.025n

.meas tran vdout0_191ck1030 FIND v(dout0_191) AT=520.025n

.meas tran vdout0_192ck1030 FIND v(dout0_192) AT=520.025n

.meas tran vdout0_193ck1030 FIND v(dout0_193) AT=520.025n

.meas tran vdout0_194ck1030 FIND v(dout0_194) AT=520.025n

.meas tran vdout0_195ck1030 FIND v(dout0_195) AT=520.025n

.meas tran vdout0_196ck1030 FIND v(dout0_196) AT=520.025n

.meas tran vdout0_197ck1030 FIND v(dout0_197) AT=520.025n

.meas tran vdout0_198ck1030 FIND v(dout0_198) AT=520.025n

.meas tran vdout0_199ck1030 FIND v(dout0_199) AT=520.025n

.meas tran vdout0_200ck1030 FIND v(dout0_200) AT=520.025n

.meas tran vdout0_201ck1030 FIND v(dout0_201) AT=520.025n

.meas tran vdout0_202ck1030 FIND v(dout0_202) AT=520.025n

.meas tran vdout0_203ck1030 FIND v(dout0_203) AT=520.025n

.meas tran vdout0_204ck1030 FIND v(dout0_204) AT=520.025n

.meas tran vdout0_205ck1030 FIND v(dout0_205) AT=520.025n

.meas tran vdout0_206ck1030 FIND v(dout0_206) AT=520.025n

.meas tran vdout0_207ck1030 FIND v(dout0_207) AT=520.025n

.meas tran vdout0_208ck1030 FIND v(dout0_208) AT=520.025n

.meas tran vdout0_209ck1030 FIND v(dout0_209) AT=520.025n

.meas tran vdout0_210ck1030 FIND v(dout0_210) AT=520.025n

.meas tran vdout0_211ck1030 FIND v(dout0_211) AT=520.025n

.meas tran vdout0_212ck1030 FIND v(dout0_212) AT=520.025n

.meas tran vdout0_213ck1030 FIND v(dout0_213) AT=520.025n

.meas tran vdout0_214ck1030 FIND v(dout0_214) AT=520.025n

.meas tran vdout0_215ck1030 FIND v(dout0_215) AT=520.025n

.meas tran vdout0_216ck1030 FIND v(dout0_216) AT=520.025n

.meas tran vdout0_217ck1030 FIND v(dout0_217) AT=520.025n

.meas tran vdout0_218ck1030 FIND v(dout0_218) AT=520.025n

.meas tran vdout0_219ck1030 FIND v(dout0_219) AT=520.025n

.meas tran vdout0_220ck1030 FIND v(dout0_220) AT=520.025n

.meas tran vdout0_221ck1030 FIND v(dout0_221) AT=520.025n

.meas tran vdout0_222ck1030 FIND v(dout0_222) AT=520.025n

.meas tran vdout0_223ck1030 FIND v(dout0_223) AT=520.025n

.meas tran vdout0_224ck1030 FIND v(dout0_224) AT=520.025n

.meas tran vdout0_225ck1030 FIND v(dout0_225) AT=520.025n

.meas tran vdout0_226ck1030 FIND v(dout0_226) AT=520.025n

.meas tran vdout0_227ck1030 FIND v(dout0_227) AT=520.025n

.meas tran vdout0_228ck1030 FIND v(dout0_228) AT=520.025n

.meas tran vdout0_229ck1030 FIND v(dout0_229) AT=520.025n

.meas tran vdout0_230ck1030 FIND v(dout0_230) AT=520.025n

.meas tran vdout0_231ck1030 FIND v(dout0_231) AT=520.025n

.meas tran vdout0_232ck1030 FIND v(dout0_232) AT=520.025n

.meas tran vdout0_233ck1030 FIND v(dout0_233) AT=520.025n

.meas tran vdout0_234ck1030 FIND v(dout0_234) AT=520.025n

.meas tran vdout0_235ck1030 FIND v(dout0_235) AT=520.025n

.meas tran vdout0_236ck1030 FIND v(dout0_236) AT=520.025n

.meas tran vdout0_237ck1030 FIND v(dout0_237) AT=520.025n

.meas tran vdout0_238ck1030 FIND v(dout0_238) AT=520.025n

.meas tran vdout0_239ck1030 FIND v(dout0_239) AT=520.025n

.meas tran vdout0_240ck1030 FIND v(dout0_240) AT=520.025n

.meas tran vdout0_241ck1030 FIND v(dout0_241) AT=520.025n

.meas tran vdout0_242ck1030 FIND v(dout0_242) AT=520.025n

.meas tran vdout0_243ck1030 FIND v(dout0_243) AT=520.025n

.meas tran vdout0_244ck1030 FIND v(dout0_244) AT=520.025n

.meas tran vdout0_245ck1030 FIND v(dout0_245) AT=520.025n

.meas tran vdout0_246ck1030 FIND v(dout0_246) AT=520.025n

.meas tran vdout0_247ck1030 FIND v(dout0_247) AT=520.025n

.meas tran vdout0_248ck1030 FIND v(dout0_248) AT=520.025n

.meas tran vdout0_249ck1030 FIND v(dout0_249) AT=520.025n

.meas tran vdout0_250ck1030 FIND v(dout0_250) AT=520.025n

.meas tran vdout0_251ck1030 FIND v(dout0_251) AT=520.025n

.meas tran vdout0_252ck1030 FIND v(dout0_252) AT=520.025n

.meas tran vdout0_253ck1030 FIND v(dout0_253) AT=520.025n

.meas tran vdout0_254ck1030 FIND v(dout0_254) AT=520.025n

.meas tran vdout0_255ck1030 FIND v(dout0_255) AT=520.025n

.meas tran vdout0_0ck1050 FIND v(dout0_0) AT=530.025n

.meas tran vdout0_1ck1050 FIND v(dout0_1) AT=530.025n

.meas tran vdout0_2ck1050 FIND v(dout0_2) AT=530.025n

.meas tran vdout0_3ck1050 FIND v(dout0_3) AT=530.025n

.meas tran vdout0_4ck1050 FIND v(dout0_4) AT=530.025n

.meas tran vdout0_5ck1050 FIND v(dout0_5) AT=530.025n

.meas tran vdout0_6ck1050 FIND v(dout0_6) AT=530.025n

.meas tran vdout0_7ck1050 FIND v(dout0_7) AT=530.025n

.meas tran vdout0_8ck1050 FIND v(dout0_8) AT=530.025n

.meas tran vdout0_9ck1050 FIND v(dout0_9) AT=530.025n

.meas tran vdout0_10ck1050 FIND v(dout0_10) AT=530.025n

.meas tran vdout0_11ck1050 FIND v(dout0_11) AT=530.025n

.meas tran vdout0_12ck1050 FIND v(dout0_12) AT=530.025n

.meas tran vdout0_13ck1050 FIND v(dout0_13) AT=530.025n

.meas tran vdout0_14ck1050 FIND v(dout0_14) AT=530.025n

.meas tran vdout0_15ck1050 FIND v(dout0_15) AT=530.025n

.meas tran vdout0_16ck1050 FIND v(dout0_16) AT=530.025n

.meas tran vdout0_17ck1050 FIND v(dout0_17) AT=530.025n

.meas tran vdout0_18ck1050 FIND v(dout0_18) AT=530.025n

.meas tran vdout0_19ck1050 FIND v(dout0_19) AT=530.025n

.meas tran vdout0_20ck1050 FIND v(dout0_20) AT=530.025n

.meas tran vdout0_21ck1050 FIND v(dout0_21) AT=530.025n

.meas tran vdout0_22ck1050 FIND v(dout0_22) AT=530.025n

.meas tran vdout0_23ck1050 FIND v(dout0_23) AT=530.025n

.meas tran vdout0_24ck1050 FIND v(dout0_24) AT=530.025n

.meas tran vdout0_25ck1050 FIND v(dout0_25) AT=530.025n

.meas tran vdout0_26ck1050 FIND v(dout0_26) AT=530.025n

.meas tran vdout0_27ck1050 FIND v(dout0_27) AT=530.025n

.meas tran vdout0_28ck1050 FIND v(dout0_28) AT=530.025n

.meas tran vdout0_29ck1050 FIND v(dout0_29) AT=530.025n

.meas tran vdout0_30ck1050 FIND v(dout0_30) AT=530.025n

.meas tran vdout0_31ck1050 FIND v(dout0_31) AT=530.025n

.meas tran vdout0_32ck1050 FIND v(dout0_32) AT=530.025n

.meas tran vdout0_33ck1050 FIND v(dout0_33) AT=530.025n

.meas tran vdout0_34ck1050 FIND v(dout0_34) AT=530.025n

.meas tran vdout0_35ck1050 FIND v(dout0_35) AT=530.025n

.meas tran vdout0_36ck1050 FIND v(dout0_36) AT=530.025n

.meas tran vdout0_37ck1050 FIND v(dout0_37) AT=530.025n

.meas tran vdout0_38ck1050 FIND v(dout0_38) AT=530.025n

.meas tran vdout0_39ck1050 FIND v(dout0_39) AT=530.025n

.meas tran vdout0_40ck1050 FIND v(dout0_40) AT=530.025n

.meas tran vdout0_41ck1050 FIND v(dout0_41) AT=530.025n

.meas tran vdout0_42ck1050 FIND v(dout0_42) AT=530.025n

.meas tran vdout0_43ck1050 FIND v(dout0_43) AT=530.025n

.meas tran vdout0_44ck1050 FIND v(dout0_44) AT=530.025n

.meas tran vdout0_45ck1050 FIND v(dout0_45) AT=530.025n

.meas tran vdout0_46ck1050 FIND v(dout0_46) AT=530.025n

.meas tran vdout0_47ck1050 FIND v(dout0_47) AT=530.025n

.meas tran vdout0_48ck1050 FIND v(dout0_48) AT=530.025n

.meas tran vdout0_49ck1050 FIND v(dout0_49) AT=530.025n

.meas tran vdout0_50ck1050 FIND v(dout0_50) AT=530.025n

.meas tran vdout0_51ck1050 FIND v(dout0_51) AT=530.025n

.meas tran vdout0_52ck1050 FIND v(dout0_52) AT=530.025n

.meas tran vdout0_53ck1050 FIND v(dout0_53) AT=530.025n

.meas tran vdout0_54ck1050 FIND v(dout0_54) AT=530.025n

.meas tran vdout0_55ck1050 FIND v(dout0_55) AT=530.025n

.meas tran vdout0_56ck1050 FIND v(dout0_56) AT=530.025n

.meas tran vdout0_57ck1050 FIND v(dout0_57) AT=530.025n

.meas tran vdout0_58ck1050 FIND v(dout0_58) AT=530.025n

.meas tran vdout0_59ck1050 FIND v(dout0_59) AT=530.025n

.meas tran vdout0_60ck1050 FIND v(dout0_60) AT=530.025n

.meas tran vdout0_61ck1050 FIND v(dout0_61) AT=530.025n

.meas tran vdout0_62ck1050 FIND v(dout0_62) AT=530.025n

.meas tran vdout0_63ck1050 FIND v(dout0_63) AT=530.025n

.meas tran vdout0_64ck1050 FIND v(dout0_64) AT=530.025n

.meas tran vdout0_65ck1050 FIND v(dout0_65) AT=530.025n

.meas tran vdout0_66ck1050 FIND v(dout0_66) AT=530.025n

.meas tran vdout0_67ck1050 FIND v(dout0_67) AT=530.025n

.meas tran vdout0_68ck1050 FIND v(dout0_68) AT=530.025n

.meas tran vdout0_69ck1050 FIND v(dout0_69) AT=530.025n

.meas tran vdout0_70ck1050 FIND v(dout0_70) AT=530.025n

.meas tran vdout0_71ck1050 FIND v(dout0_71) AT=530.025n

.meas tran vdout0_72ck1050 FIND v(dout0_72) AT=530.025n

.meas tran vdout0_73ck1050 FIND v(dout0_73) AT=530.025n

.meas tran vdout0_74ck1050 FIND v(dout0_74) AT=530.025n

.meas tran vdout0_75ck1050 FIND v(dout0_75) AT=530.025n

.meas tran vdout0_76ck1050 FIND v(dout0_76) AT=530.025n

.meas tran vdout0_77ck1050 FIND v(dout0_77) AT=530.025n

.meas tran vdout0_78ck1050 FIND v(dout0_78) AT=530.025n

.meas tran vdout0_79ck1050 FIND v(dout0_79) AT=530.025n

.meas tran vdout0_80ck1050 FIND v(dout0_80) AT=530.025n

.meas tran vdout0_81ck1050 FIND v(dout0_81) AT=530.025n

.meas tran vdout0_82ck1050 FIND v(dout0_82) AT=530.025n

.meas tran vdout0_83ck1050 FIND v(dout0_83) AT=530.025n

.meas tran vdout0_84ck1050 FIND v(dout0_84) AT=530.025n

.meas tran vdout0_85ck1050 FIND v(dout0_85) AT=530.025n

.meas tran vdout0_86ck1050 FIND v(dout0_86) AT=530.025n

.meas tran vdout0_87ck1050 FIND v(dout0_87) AT=530.025n

.meas tran vdout0_88ck1050 FIND v(dout0_88) AT=530.025n

.meas tran vdout0_89ck1050 FIND v(dout0_89) AT=530.025n

.meas tran vdout0_90ck1050 FIND v(dout0_90) AT=530.025n

.meas tran vdout0_91ck1050 FIND v(dout0_91) AT=530.025n

.meas tran vdout0_92ck1050 FIND v(dout0_92) AT=530.025n

.meas tran vdout0_93ck1050 FIND v(dout0_93) AT=530.025n

.meas tran vdout0_94ck1050 FIND v(dout0_94) AT=530.025n

.meas tran vdout0_95ck1050 FIND v(dout0_95) AT=530.025n

.meas tran vdout0_96ck1050 FIND v(dout0_96) AT=530.025n

.meas tran vdout0_97ck1050 FIND v(dout0_97) AT=530.025n

.meas tran vdout0_98ck1050 FIND v(dout0_98) AT=530.025n

.meas tran vdout0_99ck1050 FIND v(dout0_99) AT=530.025n

.meas tran vdout0_100ck1050 FIND v(dout0_100) AT=530.025n

.meas tran vdout0_101ck1050 FIND v(dout0_101) AT=530.025n

.meas tran vdout0_102ck1050 FIND v(dout0_102) AT=530.025n

.meas tran vdout0_103ck1050 FIND v(dout0_103) AT=530.025n

.meas tran vdout0_104ck1050 FIND v(dout0_104) AT=530.025n

.meas tran vdout0_105ck1050 FIND v(dout0_105) AT=530.025n

.meas tran vdout0_106ck1050 FIND v(dout0_106) AT=530.025n

.meas tran vdout0_107ck1050 FIND v(dout0_107) AT=530.025n

.meas tran vdout0_108ck1050 FIND v(dout0_108) AT=530.025n

.meas tran vdout0_109ck1050 FIND v(dout0_109) AT=530.025n

.meas tran vdout0_110ck1050 FIND v(dout0_110) AT=530.025n

.meas tran vdout0_111ck1050 FIND v(dout0_111) AT=530.025n

.meas tran vdout0_112ck1050 FIND v(dout0_112) AT=530.025n

.meas tran vdout0_113ck1050 FIND v(dout0_113) AT=530.025n

.meas tran vdout0_114ck1050 FIND v(dout0_114) AT=530.025n

.meas tran vdout0_115ck1050 FIND v(dout0_115) AT=530.025n

.meas tran vdout0_116ck1050 FIND v(dout0_116) AT=530.025n

.meas tran vdout0_117ck1050 FIND v(dout0_117) AT=530.025n

.meas tran vdout0_118ck1050 FIND v(dout0_118) AT=530.025n

.meas tran vdout0_119ck1050 FIND v(dout0_119) AT=530.025n

.meas tran vdout0_120ck1050 FIND v(dout0_120) AT=530.025n

.meas tran vdout0_121ck1050 FIND v(dout0_121) AT=530.025n

.meas tran vdout0_122ck1050 FIND v(dout0_122) AT=530.025n

.meas tran vdout0_123ck1050 FIND v(dout0_123) AT=530.025n

.meas tran vdout0_124ck1050 FIND v(dout0_124) AT=530.025n

.meas tran vdout0_125ck1050 FIND v(dout0_125) AT=530.025n

.meas tran vdout0_126ck1050 FIND v(dout0_126) AT=530.025n

.meas tran vdout0_127ck1050 FIND v(dout0_127) AT=530.025n

.meas tran vdout0_128ck1050 FIND v(dout0_128) AT=530.025n

.meas tran vdout0_129ck1050 FIND v(dout0_129) AT=530.025n

.meas tran vdout0_130ck1050 FIND v(dout0_130) AT=530.025n

.meas tran vdout0_131ck1050 FIND v(dout0_131) AT=530.025n

.meas tran vdout0_132ck1050 FIND v(dout0_132) AT=530.025n

.meas tran vdout0_133ck1050 FIND v(dout0_133) AT=530.025n

.meas tran vdout0_134ck1050 FIND v(dout0_134) AT=530.025n

.meas tran vdout0_135ck1050 FIND v(dout0_135) AT=530.025n

.meas tran vdout0_136ck1050 FIND v(dout0_136) AT=530.025n

.meas tran vdout0_137ck1050 FIND v(dout0_137) AT=530.025n

.meas tran vdout0_138ck1050 FIND v(dout0_138) AT=530.025n

.meas tran vdout0_139ck1050 FIND v(dout0_139) AT=530.025n

.meas tran vdout0_140ck1050 FIND v(dout0_140) AT=530.025n

.meas tran vdout0_141ck1050 FIND v(dout0_141) AT=530.025n

.meas tran vdout0_142ck1050 FIND v(dout0_142) AT=530.025n

.meas tran vdout0_143ck1050 FIND v(dout0_143) AT=530.025n

.meas tran vdout0_144ck1050 FIND v(dout0_144) AT=530.025n

.meas tran vdout0_145ck1050 FIND v(dout0_145) AT=530.025n

.meas tran vdout0_146ck1050 FIND v(dout0_146) AT=530.025n

.meas tran vdout0_147ck1050 FIND v(dout0_147) AT=530.025n

.meas tran vdout0_148ck1050 FIND v(dout0_148) AT=530.025n

.meas tran vdout0_149ck1050 FIND v(dout0_149) AT=530.025n

.meas tran vdout0_150ck1050 FIND v(dout0_150) AT=530.025n

.meas tran vdout0_151ck1050 FIND v(dout0_151) AT=530.025n

.meas tran vdout0_152ck1050 FIND v(dout0_152) AT=530.025n

.meas tran vdout0_153ck1050 FIND v(dout0_153) AT=530.025n

.meas tran vdout0_154ck1050 FIND v(dout0_154) AT=530.025n

.meas tran vdout0_155ck1050 FIND v(dout0_155) AT=530.025n

.meas tran vdout0_156ck1050 FIND v(dout0_156) AT=530.025n

.meas tran vdout0_157ck1050 FIND v(dout0_157) AT=530.025n

.meas tran vdout0_158ck1050 FIND v(dout0_158) AT=530.025n

.meas tran vdout0_159ck1050 FIND v(dout0_159) AT=530.025n

.meas tran vdout0_160ck1050 FIND v(dout0_160) AT=530.025n

.meas tran vdout0_161ck1050 FIND v(dout0_161) AT=530.025n

.meas tran vdout0_162ck1050 FIND v(dout0_162) AT=530.025n

.meas tran vdout0_163ck1050 FIND v(dout0_163) AT=530.025n

.meas tran vdout0_164ck1050 FIND v(dout0_164) AT=530.025n

.meas tran vdout0_165ck1050 FIND v(dout0_165) AT=530.025n

.meas tran vdout0_166ck1050 FIND v(dout0_166) AT=530.025n

.meas tran vdout0_167ck1050 FIND v(dout0_167) AT=530.025n

.meas tran vdout0_168ck1050 FIND v(dout0_168) AT=530.025n

.meas tran vdout0_169ck1050 FIND v(dout0_169) AT=530.025n

.meas tran vdout0_170ck1050 FIND v(dout0_170) AT=530.025n

.meas tran vdout0_171ck1050 FIND v(dout0_171) AT=530.025n

.meas tran vdout0_172ck1050 FIND v(dout0_172) AT=530.025n

.meas tran vdout0_173ck1050 FIND v(dout0_173) AT=530.025n

.meas tran vdout0_174ck1050 FIND v(dout0_174) AT=530.025n

.meas tran vdout0_175ck1050 FIND v(dout0_175) AT=530.025n

.meas tran vdout0_176ck1050 FIND v(dout0_176) AT=530.025n

.meas tran vdout0_177ck1050 FIND v(dout0_177) AT=530.025n

.meas tran vdout0_178ck1050 FIND v(dout0_178) AT=530.025n

.meas tran vdout0_179ck1050 FIND v(dout0_179) AT=530.025n

.meas tran vdout0_180ck1050 FIND v(dout0_180) AT=530.025n

.meas tran vdout0_181ck1050 FIND v(dout0_181) AT=530.025n

.meas tran vdout0_182ck1050 FIND v(dout0_182) AT=530.025n

.meas tran vdout0_183ck1050 FIND v(dout0_183) AT=530.025n

.meas tran vdout0_184ck1050 FIND v(dout0_184) AT=530.025n

.meas tran vdout0_185ck1050 FIND v(dout0_185) AT=530.025n

.meas tran vdout0_186ck1050 FIND v(dout0_186) AT=530.025n

.meas tran vdout0_187ck1050 FIND v(dout0_187) AT=530.025n

.meas tran vdout0_188ck1050 FIND v(dout0_188) AT=530.025n

.meas tran vdout0_189ck1050 FIND v(dout0_189) AT=530.025n

.meas tran vdout0_190ck1050 FIND v(dout0_190) AT=530.025n

.meas tran vdout0_191ck1050 FIND v(dout0_191) AT=530.025n

.meas tran vdout0_192ck1050 FIND v(dout0_192) AT=530.025n

.meas tran vdout0_193ck1050 FIND v(dout0_193) AT=530.025n

.meas tran vdout0_194ck1050 FIND v(dout0_194) AT=530.025n

.meas tran vdout0_195ck1050 FIND v(dout0_195) AT=530.025n

.meas tran vdout0_196ck1050 FIND v(dout0_196) AT=530.025n

.meas tran vdout0_197ck1050 FIND v(dout0_197) AT=530.025n

.meas tran vdout0_198ck1050 FIND v(dout0_198) AT=530.025n

.meas tran vdout0_199ck1050 FIND v(dout0_199) AT=530.025n

.meas tran vdout0_200ck1050 FIND v(dout0_200) AT=530.025n

.meas tran vdout0_201ck1050 FIND v(dout0_201) AT=530.025n

.meas tran vdout0_202ck1050 FIND v(dout0_202) AT=530.025n

.meas tran vdout0_203ck1050 FIND v(dout0_203) AT=530.025n

.meas tran vdout0_204ck1050 FIND v(dout0_204) AT=530.025n

.meas tran vdout0_205ck1050 FIND v(dout0_205) AT=530.025n

.meas tran vdout0_206ck1050 FIND v(dout0_206) AT=530.025n

.meas tran vdout0_207ck1050 FIND v(dout0_207) AT=530.025n

.meas tran vdout0_208ck1050 FIND v(dout0_208) AT=530.025n

.meas tran vdout0_209ck1050 FIND v(dout0_209) AT=530.025n

.meas tran vdout0_210ck1050 FIND v(dout0_210) AT=530.025n

.meas tran vdout0_211ck1050 FIND v(dout0_211) AT=530.025n

.meas tran vdout0_212ck1050 FIND v(dout0_212) AT=530.025n

.meas tran vdout0_213ck1050 FIND v(dout0_213) AT=530.025n

.meas tran vdout0_214ck1050 FIND v(dout0_214) AT=530.025n

.meas tran vdout0_215ck1050 FIND v(dout0_215) AT=530.025n

.meas tran vdout0_216ck1050 FIND v(dout0_216) AT=530.025n

.meas tran vdout0_217ck1050 FIND v(dout0_217) AT=530.025n

.meas tran vdout0_218ck1050 FIND v(dout0_218) AT=530.025n

.meas tran vdout0_219ck1050 FIND v(dout0_219) AT=530.025n

.meas tran vdout0_220ck1050 FIND v(dout0_220) AT=530.025n

.meas tran vdout0_221ck1050 FIND v(dout0_221) AT=530.025n

.meas tran vdout0_222ck1050 FIND v(dout0_222) AT=530.025n

.meas tran vdout0_223ck1050 FIND v(dout0_223) AT=530.025n

.meas tran vdout0_224ck1050 FIND v(dout0_224) AT=530.025n

.meas tran vdout0_225ck1050 FIND v(dout0_225) AT=530.025n

.meas tran vdout0_226ck1050 FIND v(dout0_226) AT=530.025n

.meas tran vdout0_227ck1050 FIND v(dout0_227) AT=530.025n

.meas tran vdout0_228ck1050 FIND v(dout0_228) AT=530.025n

.meas tran vdout0_229ck1050 FIND v(dout0_229) AT=530.025n

.meas tran vdout0_230ck1050 FIND v(dout0_230) AT=530.025n

.meas tran vdout0_231ck1050 FIND v(dout0_231) AT=530.025n

.meas tran vdout0_232ck1050 FIND v(dout0_232) AT=530.025n

.meas tran vdout0_233ck1050 FIND v(dout0_233) AT=530.025n

.meas tran vdout0_234ck1050 FIND v(dout0_234) AT=530.025n

.meas tran vdout0_235ck1050 FIND v(dout0_235) AT=530.025n

.meas tran vdout0_236ck1050 FIND v(dout0_236) AT=530.025n

.meas tran vdout0_237ck1050 FIND v(dout0_237) AT=530.025n

.meas tran vdout0_238ck1050 FIND v(dout0_238) AT=530.025n

.meas tran vdout0_239ck1050 FIND v(dout0_239) AT=530.025n

.meas tran vdout0_240ck1050 FIND v(dout0_240) AT=530.025n

.meas tran vdout0_241ck1050 FIND v(dout0_241) AT=530.025n

.meas tran vdout0_242ck1050 FIND v(dout0_242) AT=530.025n

.meas tran vdout0_243ck1050 FIND v(dout0_243) AT=530.025n

.meas tran vdout0_244ck1050 FIND v(dout0_244) AT=530.025n

.meas tran vdout0_245ck1050 FIND v(dout0_245) AT=530.025n

.meas tran vdout0_246ck1050 FIND v(dout0_246) AT=530.025n

.meas tran vdout0_247ck1050 FIND v(dout0_247) AT=530.025n

.meas tran vdout0_248ck1050 FIND v(dout0_248) AT=530.025n

.meas tran vdout0_249ck1050 FIND v(dout0_249) AT=530.025n

.meas tran vdout0_250ck1050 FIND v(dout0_250) AT=530.025n

.meas tran vdout0_251ck1050 FIND v(dout0_251) AT=530.025n

.meas tran vdout0_252ck1050 FIND v(dout0_252) AT=530.025n

.meas tran vdout0_253ck1050 FIND v(dout0_253) AT=530.025n

.meas tran vdout0_254ck1050 FIND v(dout0_254) AT=530.025n

.meas tran vdout0_255ck1050 FIND v(dout0_255) AT=530.025n

.meas tran vdout0_0ck1060 FIND v(dout0_0) AT=535.025n

.meas tran vdout0_1ck1060 FIND v(dout0_1) AT=535.025n

.meas tran vdout0_2ck1060 FIND v(dout0_2) AT=535.025n

.meas tran vdout0_3ck1060 FIND v(dout0_3) AT=535.025n

.meas tran vdout0_4ck1060 FIND v(dout0_4) AT=535.025n

.meas tran vdout0_5ck1060 FIND v(dout0_5) AT=535.025n

.meas tran vdout0_6ck1060 FIND v(dout0_6) AT=535.025n

.meas tran vdout0_7ck1060 FIND v(dout0_7) AT=535.025n

.meas tran vdout0_8ck1060 FIND v(dout0_8) AT=535.025n

.meas tran vdout0_9ck1060 FIND v(dout0_9) AT=535.025n

.meas tran vdout0_10ck1060 FIND v(dout0_10) AT=535.025n

.meas tran vdout0_11ck1060 FIND v(dout0_11) AT=535.025n

.meas tran vdout0_12ck1060 FIND v(dout0_12) AT=535.025n

.meas tran vdout0_13ck1060 FIND v(dout0_13) AT=535.025n

.meas tran vdout0_14ck1060 FIND v(dout0_14) AT=535.025n

.meas tran vdout0_15ck1060 FIND v(dout0_15) AT=535.025n

.meas tran vdout0_16ck1060 FIND v(dout0_16) AT=535.025n

.meas tran vdout0_17ck1060 FIND v(dout0_17) AT=535.025n

.meas tran vdout0_18ck1060 FIND v(dout0_18) AT=535.025n

.meas tran vdout0_19ck1060 FIND v(dout0_19) AT=535.025n

.meas tran vdout0_20ck1060 FIND v(dout0_20) AT=535.025n

.meas tran vdout0_21ck1060 FIND v(dout0_21) AT=535.025n

.meas tran vdout0_22ck1060 FIND v(dout0_22) AT=535.025n

.meas tran vdout0_23ck1060 FIND v(dout0_23) AT=535.025n

.meas tran vdout0_24ck1060 FIND v(dout0_24) AT=535.025n

.meas tran vdout0_25ck1060 FIND v(dout0_25) AT=535.025n

.meas tran vdout0_26ck1060 FIND v(dout0_26) AT=535.025n

.meas tran vdout0_27ck1060 FIND v(dout0_27) AT=535.025n

.meas tran vdout0_28ck1060 FIND v(dout0_28) AT=535.025n

.meas tran vdout0_29ck1060 FIND v(dout0_29) AT=535.025n

.meas tran vdout0_30ck1060 FIND v(dout0_30) AT=535.025n

.meas tran vdout0_31ck1060 FIND v(dout0_31) AT=535.025n

.meas tran vdout0_32ck1060 FIND v(dout0_32) AT=535.025n

.meas tran vdout0_33ck1060 FIND v(dout0_33) AT=535.025n

.meas tran vdout0_34ck1060 FIND v(dout0_34) AT=535.025n

.meas tran vdout0_35ck1060 FIND v(dout0_35) AT=535.025n

.meas tran vdout0_36ck1060 FIND v(dout0_36) AT=535.025n

.meas tran vdout0_37ck1060 FIND v(dout0_37) AT=535.025n

.meas tran vdout0_38ck1060 FIND v(dout0_38) AT=535.025n

.meas tran vdout0_39ck1060 FIND v(dout0_39) AT=535.025n

.meas tran vdout0_40ck1060 FIND v(dout0_40) AT=535.025n

.meas tran vdout0_41ck1060 FIND v(dout0_41) AT=535.025n

.meas tran vdout0_42ck1060 FIND v(dout0_42) AT=535.025n

.meas tran vdout0_43ck1060 FIND v(dout0_43) AT=535.025n

.meas tran vdout0_44ck1060 FIND v(dout0_44) AT=535.025n

.meas tran vdout0_45ck1060 FIND v(dout0_45) AT=535.025n

.meas tran vdout0_46ck1060 FIND v(dout0_46) AT=535.025n

.meas tran vdout0_47ck1060 FIND v(dout0_47) AT=535.025n

.meas tran vdout0_48ck1060 FIND v(dout0_48) AT=535.025n

.meas tran vdout0_49ck1060 FIND v(dout0_49) AT=535.025n

.meas tran vdout0_50ck1060 FIND v(dout0_50) AT=535.025n

.meas tran vdout0_51ck1060 FIND v(dout0_51) AT=535.025n

.meas tran vdout0_52ck1060 FIND v(dout0_52) AT=535.025n

.meas tran vdout0_53ck1060 FIND v(dout0_53) AT=535.025n

.meas tran vdout0_54ck1060 FIND v(dout0_54) AT=535.025n

.meas tran vdout0_55ck1060 FIND v(dout0_55) AT=535.025n

.meas tran vdout0_56ck1060 FIND v(dout0_56) AT=535.025n

.meas tran vdout0_57ck1060 FIND v(dout0_57) AT=535.025n

.meas tran vdout0_58ck1060 FIND v(dout0_58) AT=535.025n

.meas tran vdout0_59ck1060 FIND v(dout0_59) AT=535.025n

.meas tran vdout0_60ck1060 FIND v(dout0_60) AT=535.025n

.meas tran vdout0_61ck1060 FIND v(dout0_61) AT=535.025n

.meas tran vdout0_62ck1060 FIND v(dout0_62) AT=535.025n

.meas tran vdout0_63ck1060 FIND v(dout0_63) AT=535.025n

.meas tran vdout0_64ck1060 FIND v(dout0_64) AT=535.025n

.meas tran vdout0_65ck1060 FIND v(dout0_65) AT=535.025n

.meas tran vdout0_66ck1060 FIND v(dout0_66) AT=535.025n

.meas tran vdout0_67ck1060 FIND v(dout0_67) AT=535.025n

.meas tran vdout0_68ck1060 FIND v(dout0_68) AT=535.025n

.meas tran vdout0_69ck1060 FIND v(dout0_69) AT=535.025n

.meas tran vdout0_70ck1060 FIND v(dout0_70) AT=535.025n

.meas tran vdout0_71ck1060 FIND v(dout0_71) AT=535.025n

.meas tran vdout0_72ck1060 FIND v(dout0_72) AT=535.025n

.meas tran vdout0_73ck1060 FIND v(dout0_73) AT=535.025n

.meas tran vdout0_74ck1060 FIND v(dout0_74) AT=535.025n

.meas tran vdout0_75ck1060 FIND v(dout0_75) AT=535.025n

.meas tran vdout0_76ck1060 FIND v(dout0_76) AT=535.025n

.meas tran vdout0_77ck1060 FIND v(dout0_77) AT=535.025n

.meas tran vdout0_78ck1060 FIND v(dout0_78) AT=535.025n

.meas tran vdout0_79ck1060 FIND v(dout0_79) AT=535.025n

.meas tran vdout0_80ck1060 FIND v(dout0_80) AT=535.025n

.meas tran vdout0_81ck1060 FIND v(dout0_81) AT=535.025n

.meas tran vdout0_82ck1060 FIND v(dout0_82) AT=535.025n

.meas tran vdout0_83ck1060 FIND v(dout0_83) AT=535.025n

.meas tran vdout0_84ck1060 FIND v(dout0_84) AT=535.025n

.meas tran vdout0_85ck1060 FIND v(dout0_85) AT=535.025n

.meas tran vdout0_86ck1060 FIND v(dout0_86) AT=535.025n

.meas tran vdout0_87ck1060 FIND v(dout0_87) AT=535.025n

.meas tran vdout0_88ck1060 FIND v(dout0_88) AT=535.025n

.meas tran vdout0_89ck1060 FIND v(dout0_89) AT=535.025n

.meas tran vdout0_90ck1060 FIND v(dout0_90) AT=535.025n

.meas tran vdout0_91ck1060 FIND v(dout0_91) AT=535.025n

.meas tran vdout0_92ck1060 FIND v(dout0_92) AT=535.025n

.meas tran vdout0_93ck1060 FIND v(dout0_93) AT=535.025n

.meas tran vdout0_94ck1060 FIND v(dout0_94) AT=535.025n

.meas tran vdout0_95ck1060 FIND v(dout0_95) AT=535.025n

.meas tran vdout0_96ck1060 FIND v(dout0_96) AT=535.025n

.meas tran vdout0_97ck1060 FIND v(dout0_97) AT=535.025n

.meas tran vdout0_98ck1060 FIND v(dout0_98) AT=535.025n

.meas tran vdout0_99ck1060 FIND v(dout0_99) AT=535.025n

.meas tran vdout0_100ck1060 FIND v(dout0_100) AT=535.025n

.meas tran vdout0_101ck1060 FIND v(dout0_101) AT=535.025n

.meas tran vdout0_102ck1060 FIND v(dout0_102) AT=535.025n

.meas tran vdout0_103ck1060 FIND v(dout0_103) AT=535.025n

.meas tran vdout0_104ck1060 FIND v(dout0_104) AT=535.025n

.meas tran vdout0_105ck1060 FIND v(dout0_105) AT=535.025n

.meas tran vdout0_106ck1060 FIND v(dout0_106) AT=535.025n

.meas tran vdout0_107ck1060 FIND v(dout0_107) AT=535.025n

.meas tran vdout0_108ck1060 FIND v(dout0_108) AT=535.025n

.meas tran vdout0_109ck1060 FIND v(dout0_109) AT=535.025n

.meas tran vdout0_110ck1060 FIND v(dout0_110) AT=535.025n

.meas tran vdout0_111ck1060 FIND v(dout0_111) AT=535.025n

.meas tran vdout0_112ck1060 FIND v(dout0_112) AT=535.025n

.meas tran vdout0_113ck1060 FIND v(dout0_113) AT=535.025n

.meas tran vdout0_114ck1060 FIND v(dout0_114) AT=535.025n

.meas tran vdout0_115ck1060 FIND v(dout0_115) AT=535.025n

.meas tran vdout0_116ck1060 FIND v(dout0_116) AT=535.025n

.meas tran vdout0_117ck1060 FIND v(dout0_117) AT=535.025n

.meas tran vdout0_118ck1060 FIND v(dout0_118) AT=535.025n

.meas tran vdout0_119ck1060 FIND v(dout0_119) AT=535.025n

.meas tran vdout0_120ck1060 FIND v(dout0_120) AT=535.025n

.meas tran vdout0_121ck1060 FIND v(dout0_121) AT=535.025n

.meas tran vdout0_122ck1060 FIND v(dout0_122) AT=535.025n

.meas tran vdout0_123ck1060 FIND v(dout0_123) AT=535.025n

.meas tran vdout0_124ck1060 FIND v(dout0_124) AT=535.025n

.meas tran vdout0_125ck1060 FIND v(dout0_125) AT=535.025n

.meas tran vdout0_126ck1060 FIND v(dout0_126) AT=535.025n

.meas tran vdout0_127ck1060 FIND v(dout0_127) AT=535.025n

.meas tran vdout0_128ck1060 FIND v(dout0_128) AT=535.025n

.meas tran vdout0_129ck1060 FIND v(dout0_129) AT=535.025n

.meas tran vdout0_130ck1060 FIND v(dout0_130) AT=535.025n

.meas tran vdout0_131ck1060 FIND v(dout0_131) AT=535.025n

.meas tran vdout0_132ck1060 FIND v(dout0_132) AT=535.025n

.meas tran vdout0_133ck1060 FIND v(dout0_133) AT=535.025n

.meas tran vdout0_134ck1060 FIND v(dout0_134) AT=535.025n

.meas tran vdout0_135ck1060 FIND v(dout0_135) AT=535.025n

.meas tran vdout0_136ck1060 FIND v(dout0_136) AT=535.025n

.meas tran vdout0_137ck1060 FIND v(dout0_137) AT=535.025n

.meas tran vdout0_138ck1060 FIND v(dout0_138) AT=535.025n

.meas tran vdout0_139ck1060 FIND v(dout0_139) AT=535.025n

.meas tran vdout0_140ck1060 FIND v(dout0_140) AT=535.025n

.meas tran vdout0_141ck1060 FIND v(dout0_141) AT=535.025n

.meas tran vdout0_142ck1060 FIND v(dout0_142) AT=535.025n

.meas tran vdout0_143ck1060 FIND v(dout0_143) AT=535.025n

.meas tran vdout0_144ck1060 FIND v(dout0_144) AT=535.025n

.meas tran vdout0_145ck1060 FIND v(dout0_145) AT=535.025n

.meas tran vdout0_146ck1060 FIND v(dout0_146) AT=535.025n

.meas tran vdout0_147ck1060 FIND v(dout0_147) AT=535.025n

.meas tran vdout0_148ck1060 FIND v(dout0_148) AT=535.025n

.meas tran vdout0_149ck1060 FIND v(dout0_149) AT=535.025n

.meas tran vdout0_150ck1060 FIND v(dout0_150) AT=535.025n

.meas tran vdout0_151ck1060 FIND v(dout0_151) AT=535.025n

.meas tran vdout0_152ck1060 FIND v(dout0_152) AT=535.025n

.meas tran vdout0_153ck1060 FIND v(dout0_153) AT=535.025n

.meas tran vdout0_154ck1060 FIND v(dout0_154) AT=535.025n

.meas tran vdout0_155ck1060 FIND v(dout0_155) AT=535.025n

.meas tran vdout0_156ck1060 FIND v(dout0_156) AT=535.025n

.meas tran vdout0_157ck1060 FIND v(dout0_157) AT=535.025n

.meas tran vdout0_158ck1060 FIND v(dout0_158) AT=535.025n

.meas tran vdout0_159ck1060 FIND v(dout0_159) AT=535.025n

.meas tran vdout0_160ck1060 FIND v(dout0_160) AT=535.025n

.meas tran vdout0_161ck1060 FIND v(dout0_161) AT=535.025n

.meas tran vdout0_162ck1060 FIND v(dout0_162) AT=535.025n

.meas tran vdout0_163ck1060 FIND v(dout0_163) AT=535.025n

.meas tran vdout0_164ck1060 FIND v(dout0_164) AT=535.025n

.meas tran vdout0_165ck1060 FIND v(dout0_165) AT=535.025n

.meas tran vdout0_166ck1060 FIND v(dout0_166) AT=535.025n

.meas tran vdout0_167ck1060 FIND v(dout0_167) AT=535.025n

.meas tran vdout0_168ck1060 FIND v(dout0_168) AT=535.025n

.meas tran vdout0_169ck1060 FIND v(dout0_169) AT=535.025n

.meas tran vdout0_170ck1060 FIND v(dout0_170) AT=535.025n

.meas tran vdout0_171ck1060 FIND v(dout0_171) AT=535.025n

.meas tran vdout0_172ck1060 FIND v(dout0_172) AT=535.025n

.meas tran vdout0_173ck1060 FIND v(dout0_173) AT=535.025n

.meas tran vdout0_174ck1060 FIND v(dout0_174) AT=535.025n

.meas tran vdout0_175ck1060 FIND v(dout0_175) AT=535.025n

.meas tran vdout0_176ck1060 FIND v(dout0_176) AT=535.025n

.meas tran vdout0_177ck1060 FIND v(dout0_177) AT=535.025n

.meas tran vdout0_178ck1060 FIND v(dout0_178) AT=535.025n

.meas tran vdout0_179ck1060 FIND v(dout0_179) AT=535.025n

.meas tran vdout0_180ck1060 FIND v(dout0_180) AT=535.025n

.meas tran vdout0_181ck1060 FIND v(dout0_181) AT=535.025n

.meas tran vdout0_182ck1060 FIND v(dout0_182) AT=535.025n

.meas tran vdout0_183ck1060 FIND v(dout0_183) AT=535.025n

.meas tran vdout0_184ck1060 FIND v(dout0_184) AT=535.025n

.meas tran vdout0_185ck1060 FIND v(dout0_185) AT=535.025n

.meas tran vdout0_186ck1060 FIND v(dout0_186) AT=535.025n

.meas tran vdout0_187ck1060 FIND v(dout0_187) AT=535.025n

.meas tran vdout0_188ck1060 FIND v(dout0_188) AT=535.025n

.meas tran vdout0_189ck1060 FIND v(dout0_189) AT=535.025n

.meas tran vdout0_190ck1060 FIND v(dout0_190) AT=535.025n

.meas tran vdout0_191ck1060 FIND v(dout0_191) AT=535.025n

.meas tran vdout0_192ck1060 FIND v(dout0_192) AT=535.025n

.meas tran vdout0_193ck1060 FIND v(dout0_193) AT=535.025n

.meas tran vdout0_194ck1060 FIND v(dout0_194) AT=535.025n

.meas tran vdout0_195ck1060 FIND v(dout0_195) AT=535.025n

.meas tran vdout0_196ck1060 FIND v(dout0_196) AT=535.025n

.meas tran vdout0_197ck1060 FIND v(dout0_197) AT=535.025n

.meas tran vdout0_198ck1060 FIND v(dout0_198) AT=535.025n

.meas tran vdout0_199ck1060 FIND v(dout0_199) AT=535.025n

.meas tran vdout0_200ck1060 FIND v(dout0_200) AT=535.025n

.meas tran vdout0_201ck1060 FIND v(dout0_201) AT=535.025n

.meas tran vdout0_202ck1060 FIND v(dout0_202) AT=535.025n

.meas tran vdout0_203ck1060 FIND v(dout0_203) AT=535.025n

.meas tran vdout0_204ck1060 FIND v(dout0_204) AT=535.025n

.meas tran vdout0_205ck1060 FIND v(dout0_205) AT=535.025n

.meas tran vdout0_206ck1060 FIND v(dout0_206) AT=535.025n

.meas tran vdout0_207ck1060 FIND v(dout0_207) AT=535.025n

.meas tran vdout0_208ck1060 FIND v(dout0_208) AT=535.025n

.meas tran vdout0_209ck1060 FIND v(dout0_209) AT=535.025n

.meas tran vdout0_210ck1060 FIND v(dout0_210) AT=535.025n

.meas tran vdout0_211ck1060 FIND v(dout0_211) AT=535.025n

.meas tran vdout0_212ck1060 FIND v(dout0_212) AT=535.025n

.meas tran vdout0_213ck1060 FIND v(dout0_213) AT=535.025n

.meas tran vdout0_214ck1060 FIND v(dout0_214) AT=535.025n

.meas tran vdout0_215ck1060 FIND v(dout0_215) AT=535.025n

.meas tran vdout0_216ck1060 FIND v(dout0_216) AT=535.025n

.meas tran vdout0_217ck1060 FIND v(dout0_217) AT=535.025n

.meas tran vdout0_218ck1060 FIND v(dout0_218) AT=535.025n

.meas tran vdout0_219ck1060 FIND v(dout0_219) AT=535.025n

.meas tran vdout0_220ck1060 FIND v(dout0_220) AT=535.025n

.meas tran vdout0_221ck1060 FIND v(dout0_221) AT=535.025n

.meas tran vdout0_222ck1060 FIND v(dout0_222) AT=535.025n

.meas tran vdout0_223ck1060 FIND v(dout0_223) AT=535.025n

.meas tran vdout0_224ck1060 FIND v(dout0_224) AT=535.025n

.meas tran vdout0_225ck1060 FIND v(dout0_225) AT=535.025n

.meas tran vdout0_226ck1060 FIND v(dout0_226) AT=535.025n

.meas tran vdout0_227ck1060 FIND v(dout0_227) AT=535.025n

.meas tran vdout0_228ck1060 FIND v(dout0_228) AT=535.025n

.meas tran vdout0_229ck1060 FIND v(dout0_229) AT=535.025n

.meas tran vdout0_230ck1060 FIND v(dout0_230) AT=535.025n

.meas tran vdout0_231ck1060 FIND v(dout0_231) AT=535.025n

.meas tran vdout0_232ck1060 FIND v(dout0_232) AT=535.025n

.meas tran vdout0_233ck1060 FIND v(dout0_233) AT=535.025n

.meas tran vdout0_234ck1060 FIND v(dout0_234) AT=535.025n

.meas tran vdout0_235ck1060 FIND v(dout0_235) AT=535.025n

.meas tran vdout0_236ck1060 FIND v(dout0_236) AT=535.025n

.meas tran vdout0_237ck1060 FIND v(dout0_237) AT=535.025n

.meas tran vdout0_238ck1060 FIND v(dout0_238) AT=535.025n

.meas tran vdout0_239ck1060 FIND v(dout0_239) AT=535.025n

.meas tran vdout0_240ck1060 FIND v(dout0_240) AT=535.025n

.meas tran vdout0_241ck1060 FIND v(dout0_241) AT=535.025n

.meas tran vdout0_242ck1060 FIND v(dout0_242) AT=535.025n

.meas tran vdout0_243ck1060 FIND v(dout0_243) AT=535.025n

.meas tran vdout0_244ck1060 FIND v(dout0_244) AT=535.025n

.meas tran vdout0_245ck1060 FIND v(dout0_245) AT=535.025n

.meas tran vdout0_246ck1060 FIND v(dout0_246) AT=535.025n

.meas tran vdout0_247ck1060 FIND v(dout0_247) AT=535.025n

.meas tran vdout0_248ck1060 FIND v(dout0_248) AT=535.025n

.meas tran vdout0_249ck1060 FIND v(dout0_249) AT=535.025n

.meas tran vdout0_250ck1060 FIND v(dout0_250) AT=535.025n

.meas tran vdout0_251ck1060 FIND v(dout0_251) AT=535.025n

.meas tran vdout0_252ck1060 FIND v(dout0_252) AT=535.025n

.meas tran vdout0_253ck1060 FIND v(dout0_253) AT=535.025n

.meas tran vdout0_254ck1060 FIND v(dout0_254) AT=535.025n

.meas tran vdout0_255ck1060 FIND v(dout0_255) AT=535.025n

.meas tran vdout0_0ck1170 FIND v(dout0_0) AT=590.025n

.meas tran vdout0_1ck1170 FIND v(dout0_1) AT=590.025n

.meas tran vdout0_2ck1170 FIND v(dout0_2) AT=590.025n

.meas tran vdout0_3ck1170 FIND v(dout0_3) AT=590.025n

.meas tran vdout0_4ck1170 FIND v(dout0_4) AT=590.025n

.meas tran vdout0_5ck1170 FIND v(dout0_5) AT=590.025n

.meas tran vdout0_6ck1170 FIND v(dout0_6) AT=590.025n

.meas tran vdout0_7ck1170 FIND v(dout0_7) AT=590.025n

.meas tran vdout0_8ck1170 FIND v(dout0_8) AT=590.025n

.meas tran vdout0_9ck1170 FIND v(dout0_9) AT=590.025n

.meas tran vdout0_10ck1170 FIND v(dout0_10) AT=590.025n

.meas tran vdout0_11ck1170 FIND v(dout0_11) AT=590.025n

.meas tran vdout0_12ck1170 FIND v(dout0_12) AT=590.025n

.meas tran vdout0_13ck1170 FIND v(dout0_13) AT=590.025n

.meas tran vdout0_14ck1170 FIND v(dout0_14) AT=590.025n

.meas tran vdout0_15ck1170 FIND v(dout0_15) AT=590.025n

.meas tran vdout0_16ck1170 FIND v(dout0_16) AT=590.025n

.meas tran vdout0_17ck1170 FIND v(dout0_17) AT=590.025n

.meas tran vdout0_18ck1170 FIND v(dout0_18) AT=590.025n

.meas tran vdout0_19ck1170 FIND v(dout0_19) AT=590.025n

.meas tran vdout0_20ck1170 FIND v(dout0_20) AT=590.025n

.meas tran vdout0_21ck1170 FIND v(dout0_21) AT=590.025n

.meas tran vdout0_22ck1170 FIND v(dout0_22) AT=590.025n

.meas tran vdout0_23ck1170 FIND v(dout0_23) AT=590.025n

.meas tran vdout0_24ck1170 FIND v(dout0_24) AT=590.025n

.meas tran vdout0_25ck1170 FIND v(dout0_25) AT=590.025n

.meas tran vdout0_26ck1170 FIND v(dout0_26) AT=590.025n

.meas tran vdout0_27ck1170 FIND v(dout0_27) AT=590.025n

.meas tran vdout0_28ck1170 FIND v(dout0_28) AT=590.025n

.meas tran vdout0_29ck1170 FIND v(dout0_29) AT=590.025n

.meas tran vdout0_30ck1170 FIND v(dout0_30) AT=590.025n

.meas tran vdout0_31ck1170 FIND v(dout0_31) AT=590.025n

.meas tran vdout0_32ck1170 FIND v(dout0_32) AT=590.025n

.meas tran vdout0_33ck1170 FIND v(dout0_33) AT=590.025n

.meas tran vdout0_34ck1170 FIND v(dout0_34) AT=590.025n

.meas tran vdout0_35ck1170 FIND v(dout0_35) AT=590.025n

.meas tran vdout0_36ck1170 FIND v(dout0_36) AT=590.025n

.meas tran vdout0_37ck1170 FIND v(dout0_37) AT=590.025n

.meas tran vdout0_38ck1170 FIND v(dout0_38) AT=590.025n

.meas tran vdout0_39ck1170 FIND v(dout0_39) AT=590.025n

.meas tran vdout0_40ck1170 FIND v(dout0_40) AT=590.025n

.meas tran vdout0_41ck1170 FIND v(dout0_41) AT=590.025n

.meas tran vdout0_42ck1170 FIND v(dout0_42) AT=590.025n

.meas tran vdout0_43ck1170 FIND v(dout0_43) AT=590.025n

.meas tran vdout0_44ck1170 FIND v(dout0_44) AT=590.025n

.meas tran vdout0_45ck1170 FIND v(dout0_45) AT=590.025n

.meas tran vdout0_46ck1170 FIND v(dout0_46) AT=590.025n

.meas tran vdout0_47ck1170 FIND v(dout0_47) AT=590.025n

.meas tran vdout0_48ck1170 FIND v(dout0_48) AT=590.025n

.meas tran vdout0_49ck1170 FIND v(dout0_49) AT=590.025n

.meas tran vdout0_50ck1170 FIND v(dout0_50) AT=590.025n

.meas tran vdout0_51ck1170 FIND v(dout0_51) AT=590.025n

.meas tran vdout0_52ck1170 FIND v(dout0_52) AT=590.025n

.meas tran vdout0_53ck1170 FIND v(dout0_53) AT=590.025n

.meas tran vdout0_54ck1170 FIND v(dout0_54) AT=590.025n

.meas tran vdout0_55ck1170 FIND v(dout0_55) AT=590.025n

.meas tran vdout0_56ck1170 FIND v(dout0_56) AT=590.025n

.meas tran vdout0_57ck1170 FIND v(dout0_57) AT=590.025n

.meas tran vdout0_58ck1170 FIND v(dout0_58) AT=590.025n

.meas tran vdout0_59ck1170 FIND v(dout0_59) AT=590.025n

.meas tran vdout0_60ck1170 FIND v(dout0_60) AT=590.025n

.meas tran vdout0_61ck1170 FIND v(dout0_61) AT=590.025n

.meas tran vdout0_62ck1170 FIND v(dout0_62) AT=590.025n

.meas tran vdout0_63ck1170 FIND v(dout0_63) AT=590.025n

.meas tran vdout0_64ck1170 FIND v(dout0_64) AT=590.025n

.meas tran vdout0_65ck1170 FIND v(dout0_65) AT=590.025n

.meas tran vdout0_66ck1170 FIND v(dout0_66) AT=590.025n

.meas tran vdout0_67ck1170 FIND v(dout0_67) AT=590.025n

.meas tran vdout0_68ck1170 FIND v(dout0_68) AT=590.025n

.meas tran vdout0_69ck1170 FIND v(dout0_69) AT=590.025n

.meas tran vdout0_70ck1170 FIND v(dout0_70) AT=590.025n

.meas tran vdout0_71ck1170 FIND v(dout0_71) AT=590.025n

.meas tran vdout0_72ck1170 FIND v(dout0_72) AT=590.025n

.meas tran vdout0_73ck1170 FIND v(dout0_73) AT=590.025n

.meas tran vdout0_74ck1170 FIND v(dout0_74) AT=590.025n

.meas tran vdout0_75ck1170 FIND v(dout0_75) AT=590.025n

.meas tran vdout0_76ck1170 FIND v(dout0_76) AT=590.025n

.meas tran vdout0_77ck1170 FIND v(dout0_77) AT=590.025n

.meas tran vdout0_78ck1170 FIND v(dout0_78) AT=590.025n

.meas tran vdout0_79ck1170 FIND v(dout0_79) AT=590.025n

.meas tran vdout0_80ck1170 FIND v(dout0_80) AT=590.025n

.meas tran vdout0_81ck1170 FIND v(dout0_81) AT=590.025n

.meas tran vdout0_82ck1170 FIND v(dout0_82) AT=590.025n

.meas tran vdout0_83ck1170 FIND v(dout0_83) AT=590.025n

.meas tran vdout0_84ck1170 FIND v(dout0_84) AT=590.025n

.meas tran vdout0_85ck1170 FIND v(dout0_85) AT=590.025n

.meas tran vdout0_86ck1170 FIND v(dout0_86) AT=590.025n

.meas tran vdout0_87ck1170 FIND v(dout0_87) AT=590.025n

.meas tran vdout0_88ck1170 FIND v(dout0_88) AT=590.025n

.meas tran vdout0_89ck1170 FIND v(dout0_89) AT=590.025n

.meas tran vdout0_90ck1170 FIND v(dout0_90) AT=590.025n

.meas tran vdout0_91ck1170 FIND v(dout0_91) AT=590.025n

.meas tran vdout0_92ck1170 FIND v(dout0_92) AT=590.025n

.meas tran vdout0_93ck1170 FIND v(dout0_93) AT=590.025n

.meas tran vdout0_94ck1170 FIND v(dout0_94) AT=590.025n

.meas tran vdout0_95ck1170 FIND v(dout0_95) AT=590.025n

.meas tran vdout0_96ck1170 FIND v(dout0_96) AT=590.025n

.meas tran vdout0_97ck1170 FIND v(dout0_97) AT=590.025n

.meas tran vdout0_98ck1170 FIND v(dout0_98) AT=590.025n

.meas tran vdout0_99ck1170 FIND v(dout0_99) AT=590.025n

.meas tran vdout0_100ck1170 FIND v(dout0_100) AT=590.025n

.meas tran vdout0_101ck1170 FIND v(dout0_101) AT=590.025n

.meas tran vdout0_102ck1170 FIND v(dout0_102) AT=590.025n

.meas tran vdout0_103ck1170 FIND v(dout0_103) AT=590.025n

.meas tran vdout0_104ck1170 FIND v(dout0_104) AT=590.025n

.meas tran vdout0_105ck1170 FIND v(dout0_105) AT=590.025n

.meas tran vdout0_106ck1170 FIND v(dout0_106) AT=590.025n

.meas tran vdout0_107ck1170 FIND v(dout0_107) AT=590.025n

.meas tran vdout0_108ck1170 FIND v(dout0_108) AT=590.025n

.meas tran vdout0_109ck1170 FIND v(dout0_109) AT=590.025n

.meas tran vdout0_110ck1170 FIND v(dout0_110) AT=590.025n

.meas tran vdout0_111ck1170 FIND v(dout0_111) AT=590.025n

.meas tran vdout0_112ck1170 FIND v(dout0_112) AT=590.025n

.meas tran vdout0_113ck1170 FIND v(dout0_113) AT=590.025n

.meas tran vdout0_114ck1170 FIND v(dout0_114) AT=590.025n

.meas tran vdout0_115ck1170 FIND v(dout0_115) AT=590.025n

.meas tran vdout0_116ck1170 FIND v(dout0_116) AT=590.025n

.meas tran vdout0_117ck1170 FIND v(dout0_117) AT=590.025n

.meas tran vdout0_118ck1170 FIND v(dout0_118) AT=590.025n

.meas tran vdout0_119ck1170 FIND v(dout0_119) AT=590.025n

.meas tran vdout0_120ck1170 FIND v(dout0_120) AT=590.025n

.meas tran vdout0_121ck1170 FIND v(dout0_121) AT=590.025n

.meas tran vdout0_122ck1170 FIND v(dout0_122) AT=590.025n

.meas tran vdout0_123ck1170 FIND v(dout0_123) AT=590.025n

.meas tran vdout0_124ck1170 FIND v(dout0_124) AT=590.025n

.meas tran vdout0_125ck1170 FIND v(dout0_125) AT=590.025n

.meas tran vdout0_126ck1170 FIND v(dout0_126) AT=590.025n

.meas tran vdout0_127ck1170 FIND v(dout0_127) AT=590.025n

.meas tran vdout0_128ck1170 FIND v(dout0_128) AT=590.025n

.meas tran vdout0_129ck1170 FIND v(dout0_129) AT=590.025n

.meas tran vdout0_130ck1170 FIND v(dout0_130) AT=590.025n

.meas tran vdout0_131ck1170 FIND v(dout0_131) AT=590.025n

.meas tran vdout0_132ck1170 FIND v(dout0_132) AT=590.025n

.meas tran vdout0_133ck1170 FIND v(dout0_133) AT=590.025n

.meas tran vdout0_134ck1170 FIND v(dout0_134) AT=590.025n

.meas tran vdout0_135ck1170 FIND v(dout0_135) AT=590.025n

.meas tran vdout0_136ck1170 FIND v(dout0_136) AT=590.025n

.meas tran vdout0_137ck1170 FIND v(dout0_137) AT=590.025n

.meas tran vdout0_138ck1170 FIND v(dout0_138) AT=590.025n

.meas tran vdout0_139ck1170 FIND v(dout0_139) AT=590.025n

.meas tran vdout0_140ck1170 FIND v(dout0_140) AT=590.025n

.meas tran vdout0_141ck1170 FIND v(dout0_141) AT=590.025n

.meas tran vdout0_142ck1170 FIND v(dout0_142) AT=590.025n

.meas tran vdout0_143ck1170 FIND v(dout0_143) AT=590.025n

.meas tran vdout0_144ck1170 FIND v(dout0_144) AT=590.025n

.meas tran vdout0_145ck1170 FIND v(dout0_145) AT=590.025n

.meas tran vdout0_146ck1170 FIND v(dout0_146) AT=590.025n

.meas tran vdout0_147ck1170 FIND v(dout0_147) AT=590.025n

.meas tran vdout0_148ck1170 FIND v(dout0_148) AT=590.025n

.meas tran vdout0_149ck1170 FIND v(dout0_149) AT=590.025n

.meas tran vdout0_150ck1170 FIND v(dout0_150) AT=590.025n

.meas tran vdout0_151ck1170 FIND v(dout0_151) AT=590.025n

.meas tran vdout0_152ck1170 FIND v(dout0_152) AT=590.025n

.meas tran vdout0_153ck1170 FIND v(dout0_153) AT=590.025n

.meas tran vdout0_154ck1170 FIND v(dout0_154) AT=590.025n

.meas tran vdout0_155ck1170 FIND v(dout0_155) AT=590.025n

.meas tran vdout0_156ck1170 FIND v(dout0_156) AT=590.025n

.meas tran vdout0_157ck1170 FIND v(dout0_157) AT=590.025n

.meas tran vdout0_158ck1170 FIND v(dout0_158) AT=590.025n

.meas tran vdout0_159ck1170 FIND v(dout0_159) AT=590.025n

.meas tran vdout0_160ck1170 FIND v(dout0_160) AT=590.025n

.meas tran vdout0_161ck1170 FIND v(dout0_161) AT=590.025n

.meas tran vdout0_162ck1170 FIND v(dout0_162) AT=590.025n

.meas tran vdout0_163ck1170 FIND v(dout0_163) AT=590.025n

.meas tran vdout0_164ck1170 FIND v(dout0_164) AT=590.025n

.meas tran vdout0_165ck1170 FIND v(dout0_165) AT=590.025n

.meas tran vdout0_166ck1170 FIND v(dout0_166) AT=590.025n

.meas tran vdout0_167ck1170 FIND v(dout0_167) AT=590.025n

.meas tran vdout0_168ck1170 FIND v(dout0_168) AT=590.025n

.meas tran vdout0_169ck1170 FIND v(dout0_169) AT=590.025n

.meas tran vdout0_170ck1170 FIND v(dout0_170) AT=590.025n

.meas tran vdout0_171ck1170 FIND v(dout0_171) AT=590.025n

.meas tran vdout0_172ck1170 FIND v(dout0_172) AT=590.025n

.meas tran vdout0_173ck1170 FIND v(dout0_173) AT=590.025n

.meas tran vdout0_174ck1170 FIND v(dout0_174) AT=590.025n

.meas tran vdout0_175ck1170 FIND v(dout0_175) AT=590.025n

.meas tran vdout0_176ck1170 FIND v(dout0_176) AT=590.025n

.meas tran vdout0_177ck1170 FIND v(dout0_177) AT=590.025n

.meas tran vdout0_178ck1170 FIND v(dout0_178) AT=590.025n

.meas tran vdout0_179ck1170 FIND v(dout0_179) AT=590.025n

.meas tran vdout0_180ck1170 FIND v(dout0_180) AT=590.025n

.meas tran vdout0_181ck1170 FIND v(dout0_181) AT=590.025n

.meas tran vdout0_182ck1170 FIND v(dout0_182) AT=590.025n

.meas tran vdout0_183ck1170 FIND v(dout0_183) AT=590.025n

.meas tran vdout0_184ck1170 FIND v(dout0_184) AT=590.025n

.meas tran vdout0_185ck1170 FIND v(dout0_185) AT=590.025n

.meas tran vdout0_186ck1170 FIND v(dout0_186) AT=590.025n

.meas tran vdout0_187ck1170 FIND v(dout0_187) AT=590.025n

.meas tran vdout0_188ck1170 FIND v(dout0_188) AT=590.025n

.meas tran vdout0_189ck1170 FIND v(dout0_189) AT=590.025n

.meas tran vdout0_190ck1170 FIND v(dout0_190) AT=590.025n

.meas tran vdout0_191ck1170 FIND v(dout0_191) AT=590.025n

.meas tran vdout0_192ck1170 FIND v(dout0_192) AT=590.025n

.meas tran vdout0_193ck1170 FIND v(dout0_193) AT=590.025n

.meas tran vdout0_194ck1170 FIND v(dout0_194) AT=590.025n

.meas tran vdout0_195ck1170 FIND v(dout0_195) AT=590.025n

.meas tran vdout0_196ck1170 FIND v(dout0_196) AT=590.025n

.meas tran vdout0_197ck1170 FIND v(dout0_197) AT=590.025n

.meas tran vdout0_198ck1170 FIND v(dout0_198) AT=590.025n

.meas tran vdout0_199ck1170 FIND v(dout0_199) AT=590.025n

.meas tran vdout0_200ck1170 FIND v(dout0_200) AT=590.025n

.meas tran vdout0_201ck1170 FIND v(dout0_201) AT=590.025n

.meas tran vdout0_202ck1170 FIND v(dout0_202) AT=590.025n

.meas tran vdout0_203ck1170 FIND v(dout0_203) AT=590.025n

.meas tran vdout0_204ck1170 FIND v(dout0_204) AT=590.025n

.meas tran vdout0_205ck1170 FIND v(dout0_205) AT=590.025n

.meas tran vdout0_206ck1170 FIND v(dout0_206) AT=590.025n

.meas tran vdout0_207ck1170 FIND v(dout0_207) AT=590.025n

.meas tran vdout0_208ck1170 FIND v(dout0_208) AT=590.025n

.meas tran vdout0_209ck1170 FIND v(dout0_209) AT=590.025n

.meas tran vdout0_210ck1170 FIND v(dout0_210) AT=590.025n

.meas tran vdout0_211ck1170 FIND v(dout0_211) AT=590.025n

.meas tran vdout0_212ck1170 FIND v(dout0_212) AT=590.025n

.meas tran vdout0_213ck1170 FIND v(dout0_213) AT=590.025n

.meas tran vdout0_214ck1170 FIND v(dout0_214) AT=590.025n

.meas tran vdout0_215ck1170 FIND v(dout0_215) AT=590.025n

.meas tran vdout0_216ck1170 FIND v(dout0_216) AT=590.025n

.meas tran vdout0_217ck1170 FIND v(dout0_217) AT=590.025n

.meas tran vdout0_218ck1170 FIND v(dout0_218) AT=590.025n

.meas tran vdout0_219ck1170 FIND v(dout0_219) AT=590.025n

.meas tran vdout0_220ck1170 FIND v(dout0_220) AT=590.025n

.meas tran vdout0_221ck1170 FIND v(dout0_221) AT=590.025n

.meas tran vdout0_222ck1170 FIND v(dout0_222) AT=590.025n

.meas tran vdout0_223ck1170 FIND v(dout0_223) AT=590.025n

.meas tran vdout0_224ck1170 FIND v(dout0_224) AT=590.025n

.meas tran vdout0_225ck1170 FIND v(dout0_225) AT=590.025n

.meas tran vdout0_226ck1170 FIND v(dout0_226) AT=590.025n

.meas tran vdout0_227ck1170 FIND v(dout0_227) AT=590.025n

.meas tran vdout0_228ck1170 FIND v(dout0_228) AT=590.025n

.meas tran vdout0_229ck1170 FIND v(dout0_229) AT=590.025n

.meas tran vdout0_230ck1170 FIND v(dout0_230) AT=590.025n

.meas tran vdout0_231ck1170 FIND v(dout0_231) AT=590.025n

.meas tran vdout0_232ck1170 FIND v(dout0_232) AT=590.025n

.meas tran vdout0_233ck1170 FIND v(dout0_233) AT=590.025n

.meas tran vdout0_234ck1170 FIND v(dout0_234) AT=590.025n

.meas tran vdout0_235ck1170 FIND v(dout0_235) AT=590.025n

.meas tran vdout0_236ck1170 FIND v(dout0_236) AT=590.025n

.meas tran vdout0_237ck1170 FIND v(dout0_237) AT=590.025n

.meas tran vdout0_238ck1170 FIND v(dout0_238) AT=590.025n

.meas tran vdout0_239ck1170 FIND v(dout0_239) AT=590.025n

.meas tran vdout0_240ck1170 FIND v(dout0_240) AT=590.025n

.meas tran vdout0_241ck1170 FIND v(dout0_241) AT=590.025n

.meas tran vdout0_242ck1170 FIND v(dout0_242) AT=590.025n

.meas tran vdout0_243ck1170 FIND v(dout0_243) AT=590.025n

.meas tran vdout0_244ck1170 FIND v(dout0_244) AT=590.025n

.meas tran vdout0_245ck1170 FIND v(dout0_245) AT=590.025n

.meas tran vdout0_246ck1170 FIND v(dout0_246) AT=590.025n

.meas tran vdout0_247ck1170 FIND v(dout0_247) AT=590.025n

.meas tran vdout0_248ck1170 FIND v(dout0_248) AT=590.025n

.meas tran vdout0_249ck1170 FIND v(dout0_249) AT=590.025n

.meas tran vdout0_250ck1170 FIND v(dout0_250) AT=590.025n

.meas tran vdout0_251ck1170 FIND v(dout0_251) AT=590.025n

.meas tran vdout0_252ck1170 FIND v(dout0_252) AT=590.025n

.meas tran vdout0_253ck1170 FIND v(dout0_253) AT=590.025n

.meas tran vdout0_254ck1170 FIND v(dout0_254) AT=590.025n

.meas tran vdout0_255ck1170 FIND v(dout0_255) AT=590.025n

.meas tran vdout0_0ck1180 FIND v(dout0_0) AT=595.025n

.meas tran vdout0_1ck1180 FIND v(dout0_1) AT=595.025n

.meas tran vdout0_2ck1180 FIND v(dout0_2) AT=595.025n

.meas tran vdout0_3ck1180 FIND v(dout0_3) AT=595.025n

.meas tran vdout0_4ck1180 FIND v(dout0_4) AT=595.025n

.meas tran vdout0_5ck1180 FIND v(dout0_5) AT=595.025n

.meas tran vdout0_6ck1180 FIND v(dout0_6) AT=595.025n

.meas tran vdout0_7ck1180 FIND v(dout0_7) AT=595.025n

.meas tran vdout0_8ck1180 FIND v(dout0_8) AT=595.025n

.meas tran vdout0_9ck1180 FIND v(dout0_9) AT=595.025n

.meas tran vdout0_10ck1180 FIND v(dout0_10) AT=595.025n

.meas tran vdout0_11ck1180 FIND v(dout0_11) AT=595.025n

.meas tran vdout0_12ck1180 FIND v(dout0_12) AT=595.025n

.meas tran vdout0_13ck1180 FIND v(dout0_13) AT=595.025n

.meas tran vdout0_14ck1180 FIND v(dout0_14) AT=595.025n

.meas tran vdout0_15ck1180 FIND v(dout0_15) AT=595.025n

.meas tran vdout0_16ck1180 FIND v(dout0_16) AT=595.025n

.meas tran vdout0_17ck1180 FIND v(dout0_17) AT=595.025n

.meas tran vdout0_18ck1180 FIND v(dout0_18) AT=595.025n

.meas tran vdout0_19ck1180 FIND v(dout0_19) AT=595.025n

.meas tran vdout0_20ck1180 FIND v(dout0_20) AT=595.025n

.meas tran vdout0_21ck1180 FIND v(dout0_21) AT=595.025n

.meas tran vdout0_22ck1180 FIND v(dout0_22) AT=595.025n

.meas tran vdout0_23ck1180 FIND v(dout0_23) AT=595.025n

.meas tran vdout0_24ck1180 FIND v(dout0_24) AT=595.025n

.meas tran vdout0_25ck1180 FIND v(dout0_25) AT=595.025n

.meas tran vdout0_26ck1180 FIND v(dout0_26) AT=595.025n

.meas tran vdout0_27ck1180 FIND v(dout0_27) AT=595.025n

.meas tran vdout0_28ck1180 FIND v(dout0_28) AT=595.025n

.meas tran vdout0_29ck1180 FIND v(dout0_29) AT=595.025n

.meas tran vdout0_30ck1180 FIND v(dout0_30) AT=595.025n

.meas tran vdout0_31ck1180 FIND v(dout0_31) AT=595.025n

.meas tran vdout0_32ck1180 FIND v(dout0_32) AT=595.025n

.meas tran vdout0_33ck1180 FIND v(dout0_33) AT=595.025n

.meas tran vdout0_34ck1180 FIND v(dout0_34) AT=595.025n

.meas tran vdout0_35ck1180 FIND v(dout0_35) AT=595.025n

.meas tran vdout0_36ck1180 FIND v(dout0_36) AT=595.025n

.meas tran vdout0_37ck1180 FIND v(dout0_37) AT=595.025n

.meas tran vdout0_38ck1180 FIND v(dout0_38) AT=595.025n

.meas tran vdout0_39ck1180 FIND v(dout0_39) AT=595.025n

.meas tran vdout0_40ck1180 FIND v(dout0_40) AT=595.025n

.meas tran vdout0_41ck1180 FIND v(dout0_41) AT=595.025n

.meas tran vdout0_42ck1180 FIND v(dout0_42) AT=595.025n

.meas tran vdout0_43ck1180 FIND v(dout0_43) AT=595.025n

.meas tran vdout0_44ck1180 FIND v(dout0_44) AT=595.025n

.meas tran vdout0_45ck1180 FIND v(dout0_45) AT=595.025n

.meas tran vdout0_46ck1180 FIND v(dout0_46) AT=595.025n

.meas tran vdout0_47ck1180 FIND v(dout0_47) AT=595.025n

.meas tran vdout0_48ck1180 FIND v(dout0_48) AT=595.025n

.meas tran vdout0_49ck1180 FIND v(dout0_49) AT=595.025n

.meas tran vdout0_50ck1180 FIND v(dout0_50) AT=595.025n

.meas tran vdout0_51ck1180 FIND v(dout0_51) AT=595.025n

.meas tran vdout0_52ck1180 FIND v(dout0_52) AT=595.025n

.meas tran vdout0_53ck1180 FIND v(dout0_53) AT=595.025n

.meas tran vdout0_54ck1180 FIND v(dout0_54) AT=595.025n

.meas tran vdout0_55ck1180 FIND v(dout0_55) AT=595.025n

.meas tran vdout0_56ck1180 FIND v(dout0_56) AT=595.025n

.meas tran vdout0_57ck1180 FIND v(dout0_57) AT=595.025n

.meas tran vdout0_58ck1180 FIND v(dout0_58) AT=595.025n

.meas tran vdout0_59ck1180 FIND v(dout0_59) AT=595.025n

.meas tran vdout0_60ck1180 FIND v(dout0_60) AT=595.025n

.meas tran vdout0_61ck1180 FIND v(dout0_61) AT=595.025n

.meas tran vdout0_62ck1180 FIND v(dout0_62) AT=595.025n

.meas tran vdout0_63ck1180 FIND v(dout0_63) AT=595.025n

.meas tran vdout0_64ck1180 FIND v(dout0_64) AT=595.025n

.meas tran vdout0_65ck1180 FIND v(dout0_65) AT=595.025n

.meas tran vdout0_66ck1180 FIND v(dout0_66) AT=595.025n

.meas tran vdout0_67ck1180 FIND v(dout0_67) AT=595.025n

.meas tran vdout0_68ck1180 FIND v(dout0_68) AT=595.025n

.meas tran vdout0_69ck1180 FIND v(dout0_69) AT=595.025n

.meas tran vdout0_70ck1180 FIND v(dout0_70) AT=595.025n

.meas tran vdout0_71ck1180 FIND v(dout0_71) AT=595.025n

.meas tran vdout0_72ck1180 FIND v(dout0_72) AT=595.025n

.meas tran vdout0_73ck1180 FIND v(dout0_73) AT=595.025n

.meas tran vdout0_74ck1180 FIND v(dout0_74) AT=595.025n

.meas tran vdout0_75ck1180 FIND v(dout0_75) AT=595.025n

.meas tran vdout0_76ck1180 FIND v(dout0_76) AT=595.025n

.meas tran vdout0_77ck1180 FIND v(dout0_77) AT=595.025n

.meas tran vdout0_78ck1180 FIND v(dout0_78) AT=595.025n

.meas tran vdout0_79ck1180 FIND v(dout0_79) AT=595.025n

.meas tran vdout0_80ck1180 FIND v(dout0_80) AT=595.025n

.meas tran vdout0_81ck1180 FIND v(dout0_81) AT=595.025n

.meas tran vdout0_82ck1180 FIND v(dout0_82) AT=595.025n

.meas tran vdout0_83ck1180 FIND v(dout0_83) AT=595.025n

.meas tran vdout0_84ck1180 FIND v(dout0_84) AT=595.025n

.meas tran vdout0_85ck1180 FIND v(dout0_85) AT=595.025n

.meas tran vdout0_86ck1180 FIND v(dout0_86) AT=595.025n

.meas tran vdout0_87ck1180 FIND v(dout0_87) AT=595.025n

.meas tran vdout0_88ck1180 FIND v(dout0_88) AT=595.025n

.meas tran vdout0_89ck1180 FIND v(dout0_89) AT=595.025n

.meas tran vdout0_90ck1180 FIND v(dout0_90) AT=595.025n

.meas tran vdout0_91ck1180 FIND v(dout0_91) AT=595.025n

.meas tran vdout0_92ck1180 FIND v(dout0_92) AT=595.025n

.meas tran vdout0_93ck1180 FIND v(dout0_93) AT=595.025n

.meas tran vdout0_94ck1180 FIND v(dout0_94) AT=595.025n

.meas tran vdout0_95ck1180 FIND v(dout0_95) AT=595.025n

.meas tran vdout0_96ck1180 FIND v(dout0_96) AT=595.025n

.meas tran vdout0_97ck1180 FIND v(dout0_97) AT=595.025n

.meas tran vdout0_98ck1180 FIND v(dout0_98) AT=595.025n

.meas tran vdout0_99ck1180 FIND v(dout0_99) AT=595.025n

.meas tran vdout0_100ck1180 FIND v(dout0_100) AT=595.025n

.meas tran vdout0_101ck1180 FIND v(dout0_101) AT=595.025n

.meas tran vdout0_102ck1180 FIND v(dout0_102) AT=595.025n

.meas tran vdout0_103ck1180 FIND v(dout0_103) AT=595.025n

.meas tran vdout0_104ck1180 FIND v(dout0_104) AT=595.025n

.meas tran vdout0_105ck1180 FIND v(dout0_105) AT=595.025n

.meas tran vdout0_106ck1180 FIND v(dout0_106) AT=595.025n

.meas tran vdout0_107ck1180 FIND v(dout0_107) AT=595.025n

.meas tran vdout0_108ck1180 FIND v(dout0_108) AT=595.025n

.meas tran vdout0_109ck1180 FIND v(dout0_109) AT=595.025n

.meas tran vdout0_110ck1180 FIND v(dout0_110) AT=595.025n

.meas tran vdout0_111ck1180 FIND v(dout0_111) AT=595.025n

.meas tran vdout0_112ck1180 FIND v(dout0_112) AT=595.025n

.meas tran vdout0_113ck1180 FIND v(dout0_113) AT=595.025n

.meas tran vdout0_114ck1180 FIND v(dout0_114) AT=595.025n

.meas tran vdout0_115ck1180 FIND v(dout0_115) AT=595.025n

.meas tran vdout0_116ck1180 FIND v(dout0_116) AT=595.025n

.meas tran vdout0_117ck1180 FIND v(dout0_117) AT=595.025n

.meas tran vdout0_118ck1180 FIND v(dout0_118) AT=595.025n

.meas tran vdout0_119ck1180 FIND v(dout0_119) AT=595.025n

.meas tran vdout0_120ck1180 FIND v(dout0_120) AT=595.025n

.meas tran vdout0_121ck1180 FIND v(dout0_121) AT=595.025n

.meas tran vdout0_122ck1180 FIND v(dout0_122) AT=595.025n

.meas tran vdout0_123ck1180 FIND v(dout0_123) AT=595.025n

.meas tran vdout0_124ck1180 FIND v(dout0_124) AT=595.025n

.meas tran vdout0_125ck1180 FIND v(dout0_125) AT=595.025n

.meas tran vdout0_126ck1180 FIND v(dout0_126) AT=595.025n

.meas tran vdout0_127ck1180 FIND v(dout0_127) AT=595.025n

.meas tran vdout0_128ck1180 FIND v(dout0_128) AT=595.025n

.meas tran vdout0_129ck1180 FIND v(dout0_129) AT=595.025n

.meas tran vdout0_130ck1180 FIND v(dout0_130) AT=595.025n

.meas tran vdout0_131ck1180 FIND v(dout0_131) AT=595.025n

.meas tran vdout0_132ck1180 FIND v(dout0_132) AT=595.025n

.meas tran vdout0_133ck1180 FIND v(dout0_133) AT=595.025n

.meas tran vdout0_134ck1180 FIND v(dout0_134) AT=595.025n

.meas tran vdout0_135ck1180 FIND v(dout0_135) AT=595.025n

.meas tran vdout0_136ck1180 FIND v(dout0_136) AT=595.025n

.meas tran vdout0_137ck1180 FIND v(dout0_137) AT=595.025n

.meas tran vdout0_138ck1180 FIND v(dout0_138) AT=595.025n

.meas tran vdout0_139ck1180 FIND v(dout0_139) AT=595.025n

.meas tran vdout0_140ck1180 FIND v(dout0_140) AT=595.025n

.meas tran vdout0_141ck1180 FIND v(dout0_141) AT=595.025n

.meas tran vdout0_142ck1180 FIND v(dout0_142) AT=595.025n

.meas tran vdout0_143ck1180 FIND v(dout0_143) AT=595.025n

.meas tran vdout0_144ck1180 FIND v(dout0_144) AT=595.025n

.meas tran vdout0_145ck1180 FIND v(dout0_145) AT=595.025n

.meas tran vdout0_146ck1180 FIND v(dout0_146) AT=595.025n

.meas tran vdout0_147ck1180 FIND v(dout0_147) AT=595.025n

.meas tran vdout0_148ck1180 FIND v(dout0_148) AT=595.025n

.meas tran vdout0_149ck1180 FIND v(dout0_149) AT=595.025n

.meas tran vdout0_150ck1180 FIND v(dout0_150) AT=595.025n

.meas tran vdout0_151ck1180 FIND v(dout0_151) AT=595.025n

.meas tran vdout0_152ck1180 FIND v(dout0_152) AT=595.025n

.meas tran vdout0_153ck1180 FIND v(dout0_153) AT=595.025n

.meas tran vdout0_154ck1180 FIND v(dout0_154) AT=595.025n

.meas tran vdout0_155ck1180 FIND v(dout0_155) AT=595.025n

.meas tran vdout0_156ck1180 FIND v(dout0_156) AT=595.025n

.meas tran vdout0_157ck1180 FIND v(dout0_157) AT=595.025n

.meas tran vdout0_158ck1180 FIND v(dout0_158) AT=595.025n

.meas tran vdout0_159ck1180 FIND v(dout0_159) AT=595.025n

.meas tran vdout0_160ck1180 FIND v(dout0_160) AT=595.025n

.meas tran vdout0_161ck1180 FIND v(dout0_161) AT=595.025n

.meas tran vdout0_162ck1180 FIND v(dout0_162) AT=595.025n

.meas tran vdout0_163ck1180 FIND v(dout0_163) AT=595.025n

.meas tran vdout0_164ck1180 FIND v(dout0_164) AT=595.025n

.meas tran vdout0_165ck1180 FIND v(dout0_165) AT=595.025n

.meas tran vdout0_166ck1180 FIND v(dout0_166) AT=595.025n

.meas tran vdout0_167ck1180 FIND v(dout0_167) AT=595.025n

.meas tran vdout0_168ck1180 FIND v(dout0_168) AT=595.025n

.meas tran vdout0_169ck1180 FIND v(dout0_169) AT=595.025n

.meas tran vdout0_170ck1180 FIND v(dout0_170) AT=595.025n

.meas tran vdout0_171ck1180 FIND v(dout0_171) AT=595.025n

.meas tran vdout0_172ck1180 FIND v(dout0_172) AT=595.025n

.meas tran vdout0_173ck1180 FIND v(dout0_173) AT=595.025n

.meas tran vdout0_174ck1180 FIND v(dout0_174) AT=595.025n

.meas tran vdout0_175ck1180 FIND v(dout0_175) AT=595.025n

.meas tran vdout0_176ck1180 FIND v(dout0_176) AT=595.025n

.meas tran vdout0_177ck1180 FIND v(dout0_177) AT=595.025n

.meas tran vdout0_178ck1180 FIND v(dout0_178) AT=595.025n

.meas tran vdout0_179ck1180 FIND v(dout0_179) AT=595.025n

.meas tran vdout0_180ck1180 FIND v(dout0_180) AT=595.025n

.meas tran vdout0_181ck1180 FIND v(dout0_181) AT=595.025n

.meas tran vdout0_182ck1180 FIND v(dout0_182) AT=595.025n

.meas tran vdout0_183ck1180 FIND v(dout0_183) AT=595.025n

.meas tran vdout0_184ck1180 FIND v(dout0_184) AT=595.025n

.meas tran vdout0_185ck1180 FIND v(dout0_185) AT=595.025n

.meas tran vdout0_186ck1180 FIND v(dout0_186) AT=595.025n

.meas tran vdout0_187ck1180 FIND v(dout0_187) AT=595.025n

.meas tran vdout0_188ck1180 FIND v(dout0_188) AT=595.025n

.meas tran vdout0_189ck1180 FIND v(dout0_189) AT=595.025n

.meas tran vdout0_190ck1180 FIND v(dout0_190) AT=595.025n

.meas tran vdout0_191ck1180 FIND v(dout0_191) AT=595.025n

.meas tran vdout0_192ck1180 FIND v(dout0_192) AT=595.025n

.meas tran vdout0_193ck1180 FIND v(dout0_193) AT=595.025n

.meas tran vdout0_194ck1180 FIND v(dout0_194) AT=595.025n

.meas tran vdout0_195ck1180 FIND v(dout0_195) AT=595.025n

.meas tran vdout0_196ck1180 FIND v(dout0_196) AT=595.025n

.meas tran vdout0_197ck1180 FIND v(dout0_197) AT=595.025n

.meas tran vdout0_198ck1180 FIND v(dout0_198) AT=595.025n

.meas tran vdout0_199ck1180 FIND v(dout0_199) AT=595.025n

.meas tran vdout0_200ck1180 FIND v(dout0_200) AT=595.025n

.meas tran vdout0_201ck1180 FIND v(dout0_201) AT=595.025n

.meas tran vdout0_202ck1180 FIND v(dout0_202) AT=595.025n

.meas tran vdout0_203ck1180 FIND v(dout0_203) AT=595.025n

.meas tran vdout0_204ck1180 FIND v(dout0_204) AT=595.025n

.meas tran vdout0_205ck1180 FIND v(dout0_205) AT=595.025n

.meas tran vdout0_206ck1180 FIND v(dout0_206) AT=595.025n

.meas tran vdout0_207ck1180 FIND v(dout0_207) AT=595.025n

.meas tran vdout0_208ck1180 FIND v(dout0_208) AT=595.025n

.meas tran vdout0_209ck1180 FIND v(dout0_209) AT=595.025n

.meas tran vdout0_210ck1180 FIND v(dout0_210) AT=595.025n

.meas tran vdout0_211ck1180 FIND v(dout0_211) AT=595.025n

.meas tran vdout0_212ck1180 FIND v(dout0_212) AT=595.025n

.meas tran vdout0_213ck1180 FIND v(dout0_213) AT=595.025n

.meas tran vdout0_214ck1180 FIND v(dout0_214) AT=595.025n

.meas tran vdout0_215ck1180 FIND v(dout0_215) AT=595.025n

.meas tran vdout0_216ck1180 FIND v(dout0_216) AT=595.025n

.meas tran vdout0_217ck1180 FIND v(dout0_217) AT=595.025n

.meas tran vdout0_218ck1180 FIND v(dout0_218) AT=595.025n

.meas tran vdout0_219ck1180 FIND v(dout0_219) AT=595.025n

.meas tran vdout0_220ck1180 FIND v(dout0_220) AT=595.025n

.meas tran vdout0_221ck1180 FIND v(dout0_221) AT=595.025n

.meas tran vdout0_222ck1180 FIND v(dout0_222) AT=595.025n

.meas tran vdout0_223ck1180 FIND v(dout0_223) AT=595.025n

.meas tran vdout0_224ck1180 FIND v(dout0_224) AT=595.025n

.meas tran vdout0_225ck1180 FIND v(dout0_225) AT=595.025n

.meas tran vdout0_226ck1180 FIND v(dout0_226) AT=595.025n

.meas tran vdout0_227ck1180 FIND v(dout0_227) AT=595.025n

.meas tran vdout0_228ck1180 FIND v(dout0_228) AT=595.025n

.meas tran vdout0_229ck1180 FIND v(dout0_229) AT=595.025n

.meas tran vdout0_230ck1180 FIND v(dout0_230) AT=595.025n

.meas tran vdout0_231ck1180 FIND v(dout0_231) AT=595.025n

.meas tran vdout0_232ck1180 FIND v(dout0_232) AT=595.025n

.meas tran vdout0_233ck1180 FIND v(dout0_233) AT=595.025n

.meas tran vdout0_234ck1180 FIND v(dout0_234) AT=595.025n

.meas tran vdout0_235ck1180 FIND v(dout0_235) AT=595.025n

.meas tran vdout0_236ck1180 FIND v(dout0_236) AT=595.025n

.meas tran vdout0_237ck1180 FIND v(dout0_237) AT=595.025n

.meas tran vdout0_238ck1180 FIND v(dout0_238) AT=595.025n

.meas tran vdout0_239ck1180 FIND v(dout0_239) AT=595.025n

.meas tran vdout0_240ck1180 FIND v(dout0_240) AT=595.025n

.meas tran vdout0_241ck1180 FIND v(dout0_241) AT=595.025n

.meas tran vdout0_242ck1180 FIND v(dout0_242) AT=595.025n

.meas tran vdout0_243ck1180 FIND v(dout0_243) AT=595.025n

.meas tran vdout0_244ck1180 FIND v(dout0_244) AT=595.025n

.meas tran vdout0_245ck1180 FIND v(dout0_245) AT=595.025n

.meas tran vdout0_246ck1180 FIND v(dout0_246) AT=595.025n

.meas tran vdout0_247ck1180 FIND v(dout0_247) AT=595.025n

.meas tran vdout0_248ck1180 FIND v(dout0_248) AT=595.025n

.meas tran vdout0_249ck1180 FIND v(dout0_249) AT=595.025n

.meas tran vdout0_250ck1180 FIND v(dout0_250) AT=595.025n

.meas tran vdout0_251ck1180 FIND v(dout0_251) AT=595.025n

.meas tran vdout0_252ck1180 FIND v(dout0_252) AT=595.025n

.meas tran vdout0_253ck1180 FIND v(dout0_253) AT=595.025n

.meas tran vdout0_254ck1180 FIND v(dout0_254) AT=595.025n

.meas tran vdout0_255ck1180 FIND v(dout0_255) AT=595.025n

.meas tran vdout0_0ck1200 FIND v(dout0_0) AT=605.025n

.meas tran vdout0_1ck1200 FIND v(dout0_1) AT=605.025n

.meas tran vdout0_2ck1200 FIND v(dout0_2) AT=605.025n

.meas tran vdout0_3ck1200 FIND v(dout0_3) AT=605.025n

.meas tran vdout0_4ck1200 FIND v(dout0_4) AT=605.025n

.meas tran vdout0_5ck1200 FIND v(dout0_5) AT=605.025n

.meas tran vdout0_6ck1200 FIND v(dout0_6) AT=605.025n

.meas tran vdout0_7ck1200 FIND v(dout0_7) AT=605.025n

.meas tran vdout0_8ck1200 FIND v(dout0_8) AT=605.025n

.meas tran vdout0_9ck1200 FIND v(dout0_9) AT=605.025n

.meas tran vdout0_10ck1200 FIND v(dout0_10) AT=605.025n

.meas tran vdout0_11ck1200 FIND v(dout0_11) AT=605.025n

.meas tran vdout0_12ck1200 FIND v(dout0_12) AT=605.025n

.meas tran vdout0_13ck1200 FIND v(dout0_13) AT=605.025n

.meas tran vdout0_14ck1200 FIND v(dout0_14) AT=605.025n

.meas tran vdout0_15ck1200 FIND v(dout0_15) AT=605.025n

.meas tran vdout0_16ck1200 FIND v(dout0_16) AT=605.025n

.meas tran vdout0_17ck1200 FIND v(dout0_17) AT=605.025n

.meas tran vdout0_18ck1200 FIND v(dout0_18) AT=605.025n

.meas tran vdout0_19ck1200 FIND v(dout0_19) AT=605.025n

.meas tran vdout0_20ck1200 FIND v(dout0_20) AT=605.025n

.meas tran vdout0_21ck1200 FIND v(dout0_21) AT=605.025n

.meas tran vdout0_22ck1200 FIND v(dout0_22) AT=605.025n

.meas tran vdout0_23ck1200 FIND v(dout0_23) AT=605.025n

.meas tran vdout0_24ck1200 FIND v(dout0_24) AT=605.025n

.meas tran vdout0_25ck1200 FIND v(dout0_25) AT=605.025n

.meas tran vdout0_26ck1200 FIND v(dout0_26) AT=605.025n

.meas tran vdout0_27ck1200 FIND v(dout0_27) AT=605.025n

.meas tran vdout0_28ck1200 FIND v(dout0_28) AT=605.025n

.meas tran vdout0_29ck1200 FIND v(dout0_29) AT=605.025n

.meas tran vdout0_30ck1200 FIND v(dout0_30) AT=605.025n

.meas tran vdout0_31ck1200 FIND v(dout0_31) AT=605.025n

.meas tran vdout0_32ck1200 FIND v(dout0_32) AT=605.025n

.meas tran vdout0_33ck1200 FIND v(dout0_33) AT=605.025n

.meas tran vdout0_34ck1200 FIND v(dout0_34) AT=605.025n

.meas tran vdout0_35ck1200 FIND v(dout0_35) AT=605.025n

.meas tran vdout0_36ck1200 FIND v(dout0_36) AT=605.025n

.meas tran vdout0_37ck1200 FIND v(dout0_37) AT=605.025n

.meas tran vdout0_38ck1200 FIND v(dout0_38) AT=605.025n

.meas tran vdout0_39ck1200 FIND v(dout0_39) AT=605.025n

.meas tran vdout0_40ck1200 FIND v(dout0_40) AT=605.025n

.meas tran vdout0_41ck1200 FIND v(dout0_41) AT=605.025n

.meas tran vdout0_42ck1200 FIND v(dout0_42) AT=605.025n

.meas tran vdout0_43ck1200 FIND v(dout0_43) AT=605.025n

.meas tran vdout0_44ck1200 FIND v(dout0_44) AT=605.025n

.meas tran vdout0_45ck1200 FIND v(dout0_45) AT=605.025n

.meas tran vdout0_46ck1200 FIND v(dout0_46) AT=605.025n

.meas tran vdout0_47ck1200 FIND v(dout0_47) AT=605.025n

.meas tran vdout0_48ck1200 FIND v(dout0_48) AT=605.025n

.meas tran vdout0_49ck1200 FIND v(dout0_49) AT=605.025n

.meas tran vdout0_50ck1200 FIND v(dout0_50) AT=605.025n

.meas tran vdout0_51ck1200 FIND v(dout0_51) AT=605.025n

.meas tran vdout0_52ck1200 FIND v(dout0_52) AT=605.025n

.meas tran vdout0_53ck1200 FIND v(dout0_53) AT=605.025n

.meas tran vdout0_54ck1200 FIND v(dout0_54) AT=605.025n

.meas tran vdout0_55ck1200 FIND v(dout0_55) AT=605.025n

.meas tran vdout0_56ck1200 FIND v(dout0_56) AT=605.025n

.meas tran vdout0_57ck1200 FIND v(dout0_57) AT=605.025n

.meas tran vdout0_58ck1200 FIND v(dout0_58) AT=605.025n

.meas tran vdout0_59ck1200 FIND v(dout0_59) AT=605.025n

.meas tran vdout0_60ck1200 FIND v(dout0_60) AT=605.025n

.meas tran vdout0_61ck1200 FIND v(dout0_61) AT=605.025n

.meas tran vdout0_62ck1200 FIND v(dout0_62) AT=605.025n

.meas tran vdout0_63ck1200 FIND v(dout0_63) AT=605.025n

.meas tran vdout0_64ck1200 FIND v(dout0_64) AT=605.025n

.meas tran vdout0_65ck1200 FIND v(dout0_65) AT=605.025n

.meas tran vdout0_66ck1200 FIND v(dout0_66) AT=605.025n

.meas tran vdout0_67ck1200 FIND v(dout0_67) AT=605.025n

.meas tran vdout0_68ck1200 FIND v(dout0_68) AT=605.025n

.meas tran vdout0_69ck1200 FIND v(dout0_69) AT=605.025n

.meas tran vdout0_70ck1200 FIND v(dout0_70) AT=605.025n

.meas tran vdout0_71ck1200 FIND v(dout0_71) AT=605.025n

.meas tran vdout0_72ck1200 FIND v(dout0_72) AT=605.025n

.meas tran vdout0_73ck1200 FIND v(dout0_73) AT=605.025n

.meas tran vdout0_74ck1200 FIND v(dout0_74) AT=605.025n

.meas tran vdout0_75ck1200 FIND v(dout0_75) AT=605.025n

.meas tran vdout0_76ck1200 FIND v(dout0_76) AT=605.025n

.meas tran vdout0_77ck1200 FIND v(dout0_77) AT=605.025n

.meas tran vdout0_78ck1200 FIND v(dout0_78) AT=605.025n

.meas tran vdout0_79ck1200 FIND v(dout0_79) AT=605.025n

.meas tran vdout0_80ck1200 FIND v(dout0_80) AT=605.025n

.meas tran vdout0_81ck1200 FIND v(dout0_81) AT=605.025n

.meas tran vdout0_82ck1200 FIND v(dout0_82) AT=605.025n

.meas tran vdout0_83ck1200 FIND v(dout0_83) AT=605.025n

.meas tran vdout0_84ck1200 FIND v(dout0_84) AT=605.025n

.meas tran vdout0_85ck1200 FIND v(dout0_85) AT=605.025n

.meas tran vdout0_86ck1200 FIND v(dout0_86) AT=605.025n

.meas tran vdout0_87ck1200 FIND v(dout0_87) AT=605.025n

.meas tran vdout0_88ck1200 FIND v(dout0_88) AT=605.025n

.meas tran vdout0_89ck1200 FIND v(dout0_89) AT=605.025n

.meas tran vdout0_90ck1200 FIND v(dout0_90) AT=605.025n

.meas tran vdout0_91ck1200 FIND v(dout0_91) AT=605.025n

.meas tran vdout0_92ck1200 FIND v(dout0_92) AT=605.025n

.meas tran vdout0_93ck1200 FIND v(dout0_93) AT=605.025n

.meas tran vdout0_94ck1200 FIND v(dout0_94) AT=605.025n

.meas tran vdout0_95ck1200 FIND v(dout0_95) AT=605.025n

.meas tran vdout0_96ck1200 FIND v(dout0_96) AT=605.025n

.meas tran vdout0_97ck1200 FIND v(dout0_97) AT=605.025n

.meas tran vdout0_98ck1200 FIND v(dout0_98) AT=605.025n

.meas tran vdout0_99ck1200 FIND v(dout0_99) AT=605.025n

.meas tran vdout0_100ck1200 FIND v(dout0_100) AT=605.025n

.meas tran vdout0_101ck1200 FIND v(dout0_101) AT=605.025n

.meas tran vdout0_102ck1200 FIND v(dout0_102) AT=605.025n

.meas tran vdout0_103ck1200 FIND v(dout0_103) AT=605.025n

.meas tran vdout0_104ck1200 FIND v(dout0_104) AT=605.025n

.meas tran vdout0_105ck1200 FIND v(dout0_105) AT=605.025n

.meas tran vdout0_106ck1200 FIND v(dout0_106) AT=605.025n

.meas tran vdout0_107ck1200 FIND v(dout0_107) AT=605.025n

.meas tran vdout0_108ck1200 FIND v(dout0_108) AT=605.025n

.meas tran vdout0_109ck1200 FIND v(dout0_109) AT=605.025n

.meas tran vdout0_110ck1200 FIND v(dout0_110) AT=605.025n

.meas tran vdout0_111ck1200 FIND v(dout0_111) AT=605.025n

.meas tran vdout0_112ck1200 FIND v(dout0_112) AT=605.025n

.meas tran vdout0_113ck1200 FIND v(dout0_113) AT=605.025n

.meas tran vdout0_114ck1200 FIND v(dout0_114) AT=605.025n

.meas tran vdout0_115ck1200 FIND v(dout0_115) AT=605.025n

.meas tran vdout0_116ck1200 FIND v(dout0_116) AT=605.025n

.meas tran vdout0_117ck1200 FIND v(dout0_117) AT=605.025n

.meas tran vdout0_118ck1200 FIND v(dout0_118) AT=605.025n

.meas tran vdout0_119ck1200 FIND v(dout0_119) AT=605.025n

.meas tran vdout0_120ck1200 FIND v(dout0_120) AT=605.025n

.meas tran vdout0_121ck1200 FIND v(dout0_121) AT=605.025n

.meas tran vdout0_122ck1200 FIND v(dout0_122) AT=605.025n

.meas tran vdout0_123ck1200 FIND v(dout0_123) AT=605.025n

.meas tran vdout0_124ck1200 FIND v(dout0_124) AT=605.025n

.meas tran vdout0_125ck1200 FIND v(dout0_125) AT=605.025n

.meas tran vdout0_126ck1200 FIND v(dout0_126) AT=605.025n

.meas tran vdout0_127ck1200 FIND v(dout0_127) AT=605.025n

.meas tran vdout0_128ck1200 FIND v(dout0_128) AT=605.025n

.meas tran vdout0_129ck1200 FIND v(dout0_129) AT=605.025n

.meas tran vdout0_130ck1200 FIND v(dout0_130) AT=605.025n

.meas tran vdout0_131ck1200 FIND v(dout0_131) AT=605.025n

.meas tran vdout0_132ck1200 FIND v(dout0_132) AT=605.025n

.meas tran vdout0_133ck1200 FIND v(dout0_133) AT=605.025n

.meas tran vdout0_134ck1200 FIND v(dout0_134) AT=605.025n

.meas tran vdout0_135ck1200 FIND v(dout0_135) AT=605.025n

.meas tran vdout0_136ck1200 FIND v(dout0_136) AT=605.025n

.meas tran vdout0_137ck1200 FIND v(dout0_137) AT=605.025n

.meas tran vdout0_138ck1200 FIND v(dout0_138) AT=605.025n

.meas tran vdout0_139ck1200 FIND v(dout0_139) AT=605.025n

.meas tran vdout0_140ck1200 FIND v(dout0_140) AT=605.025n

.meas tran vdout0_141ck1200 FIND v(dout0_141) AT=605.025n

.meas tran vdout0_142ck1200 FIND v(dout0_142) AT=605.025n

.meas tran vdout0_143ck1200 FIND v(dout0_143) AT=605.025n

.meas tran vdout0_144ck1200 FIND v(dout0_144) AT=605.025n

.meas tran vdout0_145ck1200 FIND v(dout0_145) AT=605.025n

.meas tran vdout0_146ck1200 FIND v(dout0_146) AT=605.025n

.meas tran vdout0_147ck1200 FIND v(dout0_147) AT=605.025n

.meas tran vdout0_148ck1200 FIND v(dout0_148) AT=605.025n

.meas tran vdout0_149ck1200 FIND v(dout0_149) AT=605.025n

.meas tran vdout0_150ck1200 FIND v(dout0_150) AT=605.025n

.meas tran vdout0_151ck1200 FIND v(dout0_151) AT=605.025n

.meas tran vdout0_152ck1200 FIND v(dout0_152) AT=605.025n

.meas tran vdout0_153ck1200 FIND v(dout0_153) AT=605.025n

.meas tran vdout0_154ck1200 FIND v(dout0_154) AT=605.025n

.meas tran vdout0_155ck1200 FIND v(dout0_155) AT=605.025n

.meas tran vdout0_156ck1200 FIND v(dout0_156) AT=605.025n

.meas tran vdout0_157ck1200 FIND v(dout0_157) AT=605.025n

.meas tran vdout0_158ck1200 FIND v(dout0_158) AT=605.025n

.meas tran vdout0_159ck1200 FIND v(dout0_159) AT=605.025n

.meas tran vdout0_160ck1200 FIND v(dout0_160) AT=605.025n

.meas tran vdout0_161ck1200 FIND v(dout0_161) AT=605.025n

.meas tran vdout0_162ck1200 FIND v(dout0_162) AT=605.025n

.meas tran vdout0_163ck1200 FIND v(dout0_163) AT=605.025n

.meas tran vdout0_164ck1200 FIND v(dout0_164) AT=605.025n

.meas tran vdout0_165ck1200 FIND v(dout0_165) AT=605.025n

.meas tran vdout0_166ck1200 FIND v(dout0_166) AT=605.025n

.meas tran vdout0_167ck1200 FIND v(dout0_167) AT=605.025n

.meas tran vdout0_168ck1200 FIND v(dout0_168) AT=605.025n

.meas tran vdout0_169ck1200 FIND v(dout0_169) AT=605.025n

.meas tran vdout0_170ck1200 FIND v(dout0_170) AT=605.025n

.meas tran vdout0_171ck1200 FIND v(dout0_171) AT=605.025n

.meas tran vdout0_172ck1200 FIND v(dout0_172) AT=605.025n

.meas tran vdout0_173ck1200 FIND v(dout0_173) AT=605.025n

.meas tran vdout0_174ck1200 FIND v(dout0_174) AT=605.025n

.meas tran vdout0_175ck1200 FIND v(dout0_175) AT=605.025n

.meas tran vdout0_176ck1200 FIND v(dout0_176) AT=605.025n

.meas tran vdout0_177ck1200 FIND v(dout0_177) AT=605.025n

.meas tran vdout0_178ck1200 FIND v(dout0_178) AT=605.025n

.meas tran vdout0_179ck1200 FIND v(dout0_179) AT=605.025n

.meas tran vdout0_180ck1200 FIND v(dout0_180) AT=605.025n

.meas tran vdout0_181ck1200 FIND v(dout0_181) AT=605.025n

.meas tran vdout0_182ck1200 FIND v(dout0_182) AT=605.025n

.meas tran vdout0_183ck1200 FIND v(dout0_183) AT=605.025n

.meas tran vdout0_184ck1200 FIND v(dout0_184) AT=605.025n

.meas tran vdout0_185ck1200 FIND v(dout0_185) AT=605.025n

.meas tran vdout0_186ck1200 FIND v(dout0_186) AT=605.025n

.meas tran vdout0_187ck1200 FIND v(dout0_187) AT=605.025n

.meas tran vdout0_188ck1200 FIND v(dout0_188) AT=605.025n

.meas tran vdout0_189ck1200 FIND v(dout0_189) AT=605.025n

.meas tran vdout0_190ck1200 FIND v(dout0_190) AT=605.025n

.meas tran vdout0_191ck1200 FIND v(dout0_191) AT=605.025n

.meas tran vdout0_192ck1200 FIND v(dout0_192) AT=605.025n

.meas tran vdout0_193ck1200 FIND v(dout0_193) AT=605.025n

.meas tran vdout0_194ck1200 FIND v(dout0_194) AT=605.025n

.meas tran vdout0_195ck1200 FIND v(dout0_195) AT=605.025n

.meas tran vdout0_196ck1200 FIND v(dout0_196) AT=605.025n

.meas tran vdout0_197ck1200 FIND v(dout0_197) AT=605.025n

.meas tran vdout0_198ck1200 FIND v(dout0_198) AT=605.025n

.meas tran vdout0_199ck1200 FIND v(dout0_199) AT=605.025n

.meas tran vdout0_200ck1200 FIND v(dout0_200) AT=605.025n

.meas tran vdout0_201ck1200 FIND v(dout0_201) AT=605.025n

.meas tran vdout0_202ck1200 FIND v(dout0_202) AT=605.025n

.meas tran vdout0_203ck1200 FIND v(dout0_203) AT=605.025n

.meas tran vdout0_204ck1200 FIND v(dout0_204) AT=605.025n

.meas tran vdout0_205ck1200 FIND v(dout0_205) AT=605.025n

.meas tran vdout0_206ck1200 FIND v(dout0_206) AT=605.025n

.meas tran vdout0_207ck1200 FIND v(dout0_207) AT=605.025n

.meas tran vdout0_208ck1200 FIND v(dout0_208) AT=605.025n

.meas tran vdout0_209ck1200 FIND v(dout0_209) AT=605.025n

.meas tran vdout0_210ck1200 FIND v(dout0_210) AT=605.025n

.meas tran vdout0_211ck1200 FIND v(dout0_211) AT=605.025n

.meas tran vdout0_212ck1200 FIND v(dout0_212) AT=605.025n

.meas tran vdout0_213ck1200 FIND v(dout0_213) AT=605.025n

.meas tran vdout0_214ck1200 FIND v(dout0_214) AT=605.025n

.meas tran vdout0_215ck1200 FIND v(dout0_215) AT=605.025n

.meas tran vdout0_216ck1200 FIND v(dout0_216) AT=605.025n

.meas tran vdout0_217ck1200 FIND v(dout0_217) AT=605.025n

.meas tran vdout0_218ck1200 FIND v(dout0_218) AT=605.025n

.meas tran vdout0_219ck1200 FIND v(dout0_219) AT=605.025n

.meas tran vdout0_220ck1200 FIND v(dout0_220) AT=605.025n

.meas tran vdout0_221ck1200 FIND v(dout0_221) AT=605.025n

.meas tran vdout0_222ck1200 FIND v(dout0_222) AT=605.025n

.meas tran vdout0_223ck1200 FIND v(dout0_223) AT=605.025n

.meas tran vdout0_224ck1200 FIND v(dout0_224) AT=605.025n

.meas tran vdout0_225ck1200 FIND v(dout0_225) AT=605.025n

.meas tran vdout0_226ck1200 FIND v(dout0_226) AT=605.025n

.meas tran vdout0_227ck1200 FIND v(dout0_227) AT=605.025n

.meas tran vdout0_228ck1200 FIND v(dout0_228) AT=605.025n

.meas tran vdout0_229ck1200 FIND v(dout0_229) AT=605.025n

.meas tran vdout0_230ck1200 FIND v(dout0_230) AT=605.025n

.meas tran vdout0_231ck1200 FIND v(dout0_231) AT=605.025n

.meas tran vdout0_232ck1200 FIND v(dout0_232) AT=605.025n

.meas tran vdout0_233ck1200 FIND v(dout0_233) AT=605.025n

.meas tran vdout0_234ck1200 FIND v(dout0_234) AT=605.025n

.meas tran vdout0_235ck1200 FIND v(dout0_235) AT=605.025n

.meas tran vdout0_236ck1200 FIND v(dout0_236) AT=605.025n

.meas tran vdout0_237ck1200 FIND v(dout0_237) AT=605.025n

.meas tran vdout0_238ck1200 FIND v(dout0_238) AT=605.025n

.meas tran vdout0_239ck1200 FIND v(dout0_239) AT=605.025n

.meas tran vdout0_240ck1200 FIND v(dout0_240) AT=605.025n

.meas tran vdout0_241ck1200 FIND v(dout0_241) AT=605.025n

.meas tran vdout0_242ck1200 FIND v(dout0_242) AT=605.025n

.meas tran vdout0_243ck1200 FIND v(dout0_243) AT=605.025n

.meas tran vdout0_244ck1200 FIND v(dout0_244) AT=605.025n

.meas tran vdout0_245ck1200 FIND v(dout0_245) AT=605.025n

.meas tran vdout0_246ck1200 FIND v(dout0_246) AT=605.025n

.meas tran vdout0_247ck1200 FIND v(dout0_247) AT=605.025n

.meas tran vdout0_248ck1200 FIND v(dout0_248) AT=605.025n

.meas tran vdout0_249ck1200 FIND v(dout0_249) AT=605.025n

.meas tran vdout0_250ck1200 FIND v(dout0_250) AT=605.025n

.meas tran vdout0_251ck1200 FIND v(dout0_251) AT=605.025n

.meas tran vdout0_252ck1200 FIND v(dout0_252) AT=605.025n

.meas tran vdout0_253ck1200 FIND v(dout0_253) AT=605.025n

.meas tran vdout0_254ck1200 FIND v(dout0_254) AT=605.025n

.meas tran vdout0_255ck1200 FIND v(dout0_255) AT=605.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_128ck1210 FIND v(dout0_128) AT=610.025n

.meas tran vdout0_129ck1210 FIND v(dout0_129) AT=610.025n

.meas tran vdout0_130ck1210 FIND v(dout0_130) AT=610.025n

.meas tran vdout0_131ck1210 FIND v(dout0_131) AT=610.025n

.meas tran vdout0_132ck1210 FIND v(dout0_132) AT=610.025n

.meas tran vdout0_133ck1210 FIND v(dout0_133) AT=610.025n

.meas tran vdout0_134ck1210 FIND v(dout0_134) AT=610.025n

.meas tran vdout0_135ck1210 FIND v(dout0_135) AT=610.025n

.meas tran vdout0_136ck1210 FIND v(dout0_136) AT=610.025n

.meas tran vdout0_137ck1210 FIND v(dout0_137) AT=610.025n

.meas tran vdout0_138ck1210 FIND v(dout0_138) AT=610.025n

.meas tran vdout0_139ck1210 FIND v(dout0_139) AT=610.025n

.meas tran vdout0_140ck1210 FIND v(dout0_140) AT=610.025n

.meas tran vdout0_141ck1210 FIND v(dout0_141) AT=610.025n

.meas tran vdout0_142ck1210 FIND v(dout0_142) AT=610.025n

.meas tran vdout0_143ck1210 FIND v(dout0_143) AT=610.025n

.meas tran vdout0_144ck1210 FIND v(dout0_144) AT=610.025n

.meas tran vdout0_145ck1210 FIND v(dout0_145) AT=610.025n

.meas tran vdout0_146ck1210 FIND v(dout0_146) AT=610.025n

.meas tran vdout0_147ck1210 FIND v(dout0_147) AT=610.025n

.meas tran vdout0_148ck1210 FIND v(dout0_148) AT=610.025n

.meas tran vdout0_149ck1210 FIND v(dout0_149) AT=610.025n

.meas tran vdout0_150ck1210 FIND v(dout0_150) AT=610.025n

.meas tran vdout0_151ck1210 FIND v(dout0_151) AT=610.025n

.meas tran vdout0_152ck1210 FIND v(dout0_152) AT=610.025n

.meas tran vdout0_153ck1210 FIND v(dout0_153) AT=610.025n

.meas tran vdout0_154ck1210 FIND v(dout0_154) AT=610.025n

.meas tran vdout0_155ck1210 FIND v(dout0_155) AT=610.025n

.meas tran vdout0_156ck1210 FIND v(dout0_156) AT=610.025n

.meas tran vdout0_157ck1210 FIND v(dout0_157) AT=610.025n

.meas tran vdout0_158ck1210 FIND v(dout0_158) AT=610.025n

.meas tran vdout0_159ck1210 FIND v(dout0_159) AT=610.025n

.meas tran vdout0_160ck1210 FIND v(dout0_160) AT=610.025n

.meas tran vdout0_161ck1210 FIND v(dout0_161) AT=610.025n

.meas tran vdout0_162ck1210 FIND v(dout0_162) AT=610.025n

.meas tran vdout0_163ck1210 FIND v(dout0_163) AT=610.025n

.meas tran vdout0_164ck1210 FIND v(dout0_164) AT=610.025n

.meas tran vdout0_165ck1210 FIND v(dout0_165) AT=610.025n

.meas tran vdout0_166ck1210 FIND v(dout0_166) AT=610.025n

.meas tran vdout0_167ck1210 FIND v(dout0_167) AT=610.025n

.meas tran vdout0_168ck1210 FIND v(dout0_168) AT=610.025n

.meas tran vdout0_169ck1210 FIND v(dout0_169) AT=610.025n

.meas tran vdout0_170ck1210 FIND v(dout0_170) AT=610.025n

.meas tran vdout0_171ck1210 FIND v(dout0_171) AT=610.025n

.meas tran vdout0_172ck1210 FIND v(dout0_172) AT=610.025n

.meas tran vdout0_173ck1210 FIND v(dout0_173) AT=610.025n

.meas tran vdout0_174ck1210 FIND v(dout0_174) AT=610.025n

.meas tran vdout0_175ck1210 FIND v(dout0_175) AT=610.025n

.meas tran vdout0_176ck1210 FIND v(dout0_176) AT=610.025n

.meas tran vdout0_177ck1210 FIND v(dout0_177) AT=610.025n

.meas tran vdout0_178ck1210 FIND v(dout0_178) AT=610.025n

.meas tran vdout0_179ck1210 FIND v(dout0_179) AT=610.025n

.meas tran vdout0_180ck1210 FIND v(dout0_180) AT=610.025n

.meas tran vdout0_181ck1210 FIND v(dout0_181) AT=610.025n

.meas tran vdout0_182ck1210 FIND v(dout0_182) AT=610.025n

.meas tran vdout0_183ck1210 FIND v(dout0_183) AT=610.025n

.meas tran vdout0_184ck1210 FIND v(dout0_184) AT=610.025n

.meas tran vdout0_185ck1210 FIND v(dout0_185) AT=610.025n

.meas tran vdout0_186ck1210 FIND v(dout0_186) AT=610.025n

.meas tran vdout0_187ck1210 FIND v(dout0_187) AT=610.025n

.meas tran vdout0_188ck1210 FIND v(dout0_188) AT=610.025n

.meas tran vdout0_189ck1210 FIND v(dout0_189) AT=610.025n

.meas tran vdout0_190ck1210 FIND v(dout0_190) AT=610.025n

.meas tran vdout0_191ck1210 FIND v(dout0_191) AT=610.025n

.meas tran vdout0_192ck1210 FIND v(dout0_192) AT=610.025n

.meas tran vdout0_193ck1210 FIND v(dout0_193) AT=610.025n

.meas tran vdout0_194ck1210 FIND v(dout0_194) AT=610.025n

.meas tran vdout0_195ck1210 FIND v(dout0_195) AT=610.025n

.meas tran vdout0_196ck1210 FIND v(dout0_196) AT=610.025n

.meas tran vdout0_197ck1210 FIND v(dout0_197) AT=610.025n

.meas tran vdout0_198ck1210 FIND v(dout0_198) AT=610.025n

.meas tran vdout0_199ck1210 FIND v(dout0_199) AT=610.025n

.meas tran vdout0_200ck1210 FIND v(dout0_200) AT=610.025n

.meas tran vdout0_201ck1210 FIND v(dout0_201) AT=610.025n

.meas tran vdout0_202ck1210 FIND v(dout0_202) AT=610.025n

.meas tran vdout0_203ck1210 FIND v(dout0_203) AT=610.025n

.meas tran vdout0_204ck1210 FIND v(dout0_204) AT=610.025n

.meas tran vdout0_205ck1210 FIND v(dout0_205) AT=610.025n

.meas tran vdout0_206ck1210 FIND v(dout0_206) AT=610.025n

.meas tran vdout0_207ck1210 FIND v(dout0_207) AT=610.025n

.meas tran vdout0_208ck1210 FIND v(dout0_208) AT=610.025n

.meas tran vdout0_209ck1210 FIND v(dout0_209) AT=610.025n

.meas tran vdout0_210ck1210 FIND v(dout0_210) AT=610.025n

.meas tran vdout0_211ck1210 FIND v(dout0_211) AT=610.025n

.meas tran vdout0_212ck1210 FIND v(dout0_212) AT=610.025n

.meas tran vdout0_213ck1210 FIND v(dout0_213) AT=610.025n

.meas tran vdout0_214ck1210 FIND v(dout0_214) AT=610.025n

.meas tran vdout0_215ck1210 FIND v(dout0_215) AT=610.025n

.meas tran vdout0_216ck1210 FIND v(dout0_216) AT=610.025n

.meas tran vdout0_217ck1210 FIND v(dout0_217) AT=610.025n

.meas tran vdout0_218ck1210 FIND v(dout0_218) AT=610.025n

.meas tran vdout0_219ck1210 FIND v(dout0_219) AT=610.025n

.meas tran vdout0_220ck1210 FIND v(dout0_220) AT=610.025n

.meas tran vdout0_221ck1210 FIND v(dout0_221) AT=610.025n

.meas tran vdout0_222ck1210 FIND v(dout0_222) AT=610.025n

.meas tran vdout0_223ck1210 FIND v(dout0_223) AT=610.025n

.meas tran vdout0_224ck1210 FIND v(dout0_224) AT=610.025n

.meas tran vdout0_225ck1210 FIND v(dout0_225) AT=610.025n

.meas tran vdout0_226ck1210 FIND v(dout0_226) AT=610.025n

.meas tran vdout0_227ck1210 FIND v(dout0_227) AT=610.025n

.meas tran vdout0_228ck1210 FIND v(dout0_228) AT=610.025n

.meas tran vdout0_229ck1210 FIND v(dout0_229) AT=610.025n

.meas tran vdout0_230ck1210 FIND v(dout0_230) AT=610.025n

.meas tran vdout0_231ck1210 FIND v(dout0_231) AT=610.025n

.meas tran vdout0_232ck1210 FIND v(dout0_232) AT=610.025n

.meas tran vdout0_233ck1210 FIND v(dout0_233) AT=610.025n

.meas tran vdout0_234ck1210 FIND v(dout0_234) AT=610.025n

.meas tran vdout0_235ck1210 FIND v(dout0_235) AT=610.025n

.meas tran vdout0_236ck1210 FIND v(dout0_236) AT=610.025n

.meas tran vdout0_237ck1210 FIND v(dout0_237) AT=610.025n

.meas tran vdout0_238ck1210 FIND v(dout0_238) AT=610.025n

.meas tran vdout0_239ck1210 FIND v(dout0_239) AT=610.025n

.meas tran vdout0_240ck1210 FIND v(dout0_240) AT=610.025n

.meas tran vdout0_241ck1210 FIND v(dout0_241) AT=610.025n

.meas tran vdout0_242ck1210 FIND v(dout0_242) AT=610.025n

.meas tran vdout0_243ck1210 FIND v(dout0_243) AT=610.025n

.meas tran vdout0_244ck1210 FIND v(dout0_244) AT=610.025n

.meas tran vdout0_245ck1210 FIND v(dout0_245) AT=610.025n

.meas tran vdout0_246ck1210 FIND v(dout0_246) AT=610.025n

.meas tran vdout0_247ck1210 FIND v(dout0_247) AT=610.025n

.meas tran vdout0_248ck1210 FIND v(dout0_248) AT=610.025n

.meas tran vdout0_249ck1210 FIND v(dout0_249) AT=610.025n

.meas tran vdout0_250ck1210 FIND v(dout0_250) AT=610.025n

.meas tran vdout0_251ck1210 FIND v(dout0_251) AT=610.025n

.meas tran vdout0_252ck1210 FIND v(dout0_252) AT=610.025n

.meas tran vdout0_253ck1210 FIND v(dout0_253) AT=610.025n

.meas tran vdout0_254ck1210 FIND v(dout0_254) AT=610.025n

.meas tran vdout0_255ck1210 FIND v(dout0_255) AT=610.025n

.meas tran vdout0_0ck1220 FIND v(dout0_0) AT=615.025n

.meas tran vdout0_1ck1220 FIND v(dout0_1) AT=615.025n

.meas tran vdout0_2ck1220 FIND v(dout0_2) AT=615.025n

.meas tran vdout0_3ck1220 FIND v(dout0_3) AT=615.025n

.meas tran vdout0_4ck1220 FIND v(dout0_4) AT=615.025n

.meas tran vdout0_5ck1220 FIND v(dout0_5) AT=615.025n

.meas tran vdout0_6ck1220 FIND v(dout0_6) AT=615.025n

.meas tran vdout0_7ck1220 FIND v(dout0_7) AT=615.025n

.meas tran vdout0_8ck1220 FIND v(dout0_8) AT=615.025n

.meas tran vdout0_9ck1220 FIND v(dout0_9) AT=615.025n

.meas tran vdout0_10ck1220 FIND v(dout0_10) AT=615.025n

.meas tran vdout0_11ck1220 FIND v(dout0_11) AT=615.025n

.meas tran vdout0_12ck1220 FIND v(dout0_12) AT=615.025n

.meas tran vdout0_13ck1220 FIND v(dout0_13) AT=615.025n

.meas tran vdout0_14ck1220 FIND v(dout0_14) AT=615.025n

.meas tran vdout0_15ck1220 FIND v(dout0_15) AT=615.025n

.meas tran vdout0_16ck1220 FIND v(dout0_16) AT=615.025n

.meas tran vdout0_17ck1220 FIND v(dout0_17) AT=615.025n

.meas tran vdout0_18ck1220 FIND v(dout0_18) AT=615.025n

.meas tran vdout0_19ck1220 FIND v(dout0_19) AT=615.025n

.meas tran vdout0_20ck1220 FIND v(dout0_20) AT=615.025n

.meas tran vdout0_21ck1220 FIND v(dout0_21) AT=615.025n

.meas tran vdout0_22ck1220 FIND v(dout0_22) AT=615.025n

.meas tran vdout0_23ck1220 FIND v(dout0_23) AT=615.025n

.meas tran vdout0_24ck1220 FIND v(dout0_24) AT=615.025n

.meas tran vdout0_25ck1220 FIND v(dout0_25) AT=615.025n

.meas tran vdout0_26ck1220 FIND v(dout0_26) AT=615.025n

.meas tran vdout0_27ck1220 FIND v(dout0_27) AT=615.025n

.meas tran vdout0_28ck1220 FIND v(dout0_28) AT=615.025n

.meas tran vdout0_29ck1220 FIND v(dout0_29) AT=615.025n

.meas tran vdout0_30ck1220 FIND v(dout0_30) AT=615.025n

.meas tran vdout0_31ck1220 FIND v(dout0_31) AT=615.025n

.meas tran vdout0_32ck1220 FIND v(dout0_32) AT=615.025n

.meas tran vdout0_33ck1220 FIND v(dout0_33) AT=615.025n

.meas tran vdout0_34ck1220 FIND v(dout0_34) AT=615.025n

.meas tran vdout0_35ck1220 FIND v(dout0_35) AT=615.025n

.meas tran vdout0_36ck1220 FIND v(dout0_36) AT=615.025n

.meas tran vdout0_37ck1220 FIND v(dout0_37) AT=615.025n

.meas tran vdout0_38ck1220 FIND v(dout0_38) AT=615.025n

.meas tran vdout0_39ck1220 FIND v(dout0_39) AT=615.025n

.meas tran vdout0_40ck1220 FIND v(dout0_40) AT=615.025n

.meas tran vdout0_41ck1220 FIND v(dout0_41) AT=615.025n

.meas tran vdout0_42ck1220 FIND v(dout0_42) AT=615.025n

.meas tran vdout0_43ck1220 FIND v(dout0_43) AT=615.025n

.meas tran vdout0_44ck1220 FIND v(dout0_44) AT=615.025n

.meas tran vdout0_45ck1220 FIND v(dout0_45) AT=615.025n

.meas tran vdout0_46ck1220 FIND v(dout0_46) AT=615.025n

.meas tran vdout0_47ck1220 FIND v(dout0_47) AT=615.025n

.meas tran vdout0_48ck1220 FIND v(dout0_48) AT=615.025n

.meas tran vdout0_49ck1220 FIND v(dout0_49) AT=615.025n

.meas tran vdout0_50ck1220 FIND v(dout0_50) AT=615.025n

.meas tran vdout0_51ck1220 FIND v(dout0_51) AT=615.025n

.meas tran vdout0_52ck1220 FIND v(dout0_52) AT=615.025n

.meas tran vdout0_53ck1220 FIND v(dout0_53) AT=615.025n

.meas tran vdout0_54ck1220 FIND v(dout0_54) AT=615.025n

.meas tran vdout0_55ck1220 FIND v(dout0_55) AT=615.025n

.meas tran vdout0_56ck1220 FIND v(dout0_56) AT=615.025n

.meas tran vdout0_57ck1220 FIND v(dout0_57) AT=615.025n

.meas tran vdout0_58ck1220 FIND v(dout0_58) AT=615.025n

.meas tran vdout0_59ck1220 FIND v(dout0_59) AT=615.025n

.meas tran vdout0_60ck1220 FIND v(dout0_60) AT=615.025n

.meas tran vdout0_61ck1220 FIND v(dout0_61) AT=615.025n

.meas tran vdout0_62ck1220 FIND v(dout0_62) AT=615.025n

.meas tran vdout0_63ck1220 FIND v(dout0_63) AT=615.025n

.meas tran vdout0_64ck1220 FIND v(dout0_64) AT=615.025n

.meas tran vdout0_65ck1220 FIND v(dout0_65) AT=615.025n

.meas tran vdout0_66ck1220 FIND v(dout0_66) AT=615.025n

.meas tran vdout0_67ck1220 FIND v(dout0_67) AT=615.025n

.meas tran vdout0_68ck1220 FIND v(dout0_68) AT=615.025n

.meas tran vdout0_69ck1220 FIND v(dout0_69) AT=615.025n

.meas tran vdout0_70ck1220 FIND v(dout0_70) AT=615.025n

.meas tran vdout0_71ck1220 FIND v(dout0_71) AT=615.025n

.meas tran vdout0_72ck1220 FIND v(dout0_72) AT=615.025n

.meas tran vdout0_73ck1220 FIND v(dout0_73) AT=615.025n

.meas tran vdout0_74ck1220 FIND v(dout0_74) AT=615.025n

.meas tran vdout0_75ck1220 FIND v(dout0_75) AT=615.025n

.meas tran vdout0_76ck1220 FIND v(dout0_76) AT=615.025n

.meas tran vdout0_77ck1220 FIND v(dout0_77) AT=615.025n

.meas tran vdout0_78ck1220 FIND v(dout0_78) AT=615.025n

.meas tran vdout0_79ck1220 FIND v(dout0_79) AT=615.025n

.meas tran vdout0_80ck1220 FIND v(dout0_80) AT=615.025n

.meas tran vdout0_81ck1220 FIND v(dout0_81) AT=615.025n

.meas tran vdout0_82ck1220 FIND v(dout0_82) AT=615.025n

.meas tran vdout0_83ck1220 FIND v(dout0_83) AT=615.025n

.meas tran vdout0_84ck1220 FIND v(dout0_84) AT=615.025n

.meas tran vdout0_85ck1220 FIND v(dout0_85) AT=615.025n

.meas tran vdout0_86ck1220 FIND v(dout0_86) AT=615.025n

.meas tran vdout0_87ck1220 FIND v(dout0_87) AT=615.025n

.meas tran vdout0_88ck1220 FIND v(dout0_88) AT=615.025n

.meas tran vdout0_89ck1220 FIND v(dout0_89) AT=615.025n

.meas tran vdout0_90ck1220 FIND v(dout0_90) AT=615.025n

.meas tran vdout0_91ck1220 FIND v(dout0_91) AT=615.025n

.meas tran vdout0_92ck1220 FIND v(dout0_92) AT=615.025n

.meas tran vdout0_93ck1220 FIND v(dout0_93) AT=615.025n

.meas tran vdout0_94ck1220 FIND v(dout0_94) AT=615.025n

.meas tran vdout0_95ck1220 FIND v(dout0_95) AT=615.025n

.meas tran vdout0_96ck1220 FIND v(dout0_96) AT=615.025n

.meas tran vdout0_97ck1220 FIND v(dout0_97) AT=615.025n

.meas tran vdout0_98ck1220 FIND v(dout0_98) AT=615.025n

.meas tran vdout0_99ck1220 FIND v(dout0_99) AT=615.025n

.meas tran vdout0_100ck1220 FIND v(dout0_100) AT=615.025n

.meas tran vdout0_101ck1220 FIND v(dout0_101) AT=615.025n

.meas tran vdout0_102ck1220 FIND v(dout0_102) AT=615.025n

.meas tran vdout0_103ck1220 FIND v(dout0_103) AT=615.025n

.meas tran vdout0_104ck1220 FIND v(dout0_104) AT=615.025n

.meas tran vdout0_105ck1220 FIND v(dout0_105) AT=615.025n

.meas tran vdout0_106ck1220 FIND v(dout0_106) AT=615.025n

.meas tran vdout0_107ck1220 FIND v(dout0_107) AT=615.025n

.meas tran vdout0_108ck1220 FIND v(dout0_108) AT=615.025n

.meas tran vdout0_109ck1220 FIND v(dout0_109) AT=615.025n

.meas tran vdout0_110ck1220 FIND v(dout0_110) AT=615.025n

.meas tran vdout0_111ck1220 FIND v(dout0_111) AT=615.025n

.meas tran vdout0_112ck1220 FIND v(dout0_112) AT=615.025n

.meas tran vdout0_113ck1220 FIND v(dout0_113) AT=615.025n

.meas tran vdout0_114ck1220 FIND v(dout0_114) AT=615.025n

.meas tran vdout0_115ck1220 FIND v(dout0_115) AT=615.025n

.meas tran vdout0_116ck1220 FIND v(dout0_116) AT=615.025n

.meas tran vdout0_117ck1220 FIND v(dout0_117) AT=615.025n

.meas tran vdout0_118ck1220 FIND v(dout0_118) AT=615.025n

.meas tran vdout0_119ck1220 FIND v(dout0_119) AT=615.025n

.meas tran vdout0_120ck1220 FIND v(dout0_120) AT=615.025n

.meas tran vdout0_121ck1220 FIND v(dout0_121) AT=615.025n

.meas tran vdout0_122ck1220 FIND v(dout0_122) AT=615.025n

.meas tran vdout0_123ck1220 FIND v(dout0_123) AT=615.025n

.meas tran vdout0_124ck1220 FIND v(dout0_124) AT=615.025n

.meas tran vdout0_125ck1220 FIND v(dout0_125) AT=615.025n

.meas tran vdout0_126ck1220 FIND v(dout0_126) AT=615.025n

.meas tran vdout0_127ck1220 FIND v(dout0_127) AT=615.025n

.meas tran vdout0_128ck1220 FIND v(dout0_128) AT=615.025n

.meas tran vdout0_129ck1220 FIND v(dout0_129) AT=615.025n

.meas tran vdout0_130ck1220 FIND v(dout0_130) AT=615.025n

.meas tran vdout0_131ck1220 FIND v(dout0_131) AT=615.025n

.meas tran vdout0_132ck1220 FIND v(dout0_132) AT=615.025n

.meas tran vdout0_133ck1220 FIND v(dout0_133) AT=615.025n

.meas tran vdout0_134ck1220 FIND v(dout0_134) AT=615.025n

.meas tran vdout0_135ck1220 FIND v(dout0_135) AT=615.025n

.meas tran vdout0_136ck1220 FIND v(dout0_136) AT=615.025n

.meas tran vdout0_137ck1220 FIND v(dout0_137) AT=615.025n

.meas tran vdout0_138ck1220 FIND v(dout0_138) AT=615.025n

.meas tran vdout0_139ck1220 FIND v(dout0_139) AT=615.025n

.meas tran vdout0_140ck1220 FIND v(dout0_140) AT=615.025n

.meas tran vdout0_141ck1220 FIND v(dout0_141) AT=615.025n

.meas tran vdout0_142ck1220 FIND v(dout0_142) AT=615.025n

.meas tran vdout0_143ck1220 FIND v(dout0_143) AT=615.025n

.meas tran vdout0_144ck1220 FIND v(dout0_144) AT=615.025n

.meas tran vdout0_145ck1220 FIND v(dout0_145) AT=615.025n

.meas tran vdout0_146ck1220 FIND v(dout0_146) AT=615.025n

.meas tran vdout0_147ck1220 FIND v(dout0_147) AT=615.025n

.meas tran vdout0_148ck1220 FIND v(dout0_148) AT=615.025n

.meas tran vdout0_149ck1220 FIND v(dout0_149) AT=615.025n

.meas tran vdout0_150ck1220 FIND v(dout0_150) AT=615.025n

.meas tran vdout0_151ck1220 FIND v(dout0_151) AT=615.025n

.meas tran vdout0_152ck1220 FIND v(dout0_152) AT=615.025n

.meas tran vdout0_153ck1220 FIND v(dout0_153) AT=615.025n

.meas tran vdout0_154ck1220 FIND v(dout0_154) AT=615.025n

.meas tran vdout0_155ck1220 FIND v(dout0_155) AT=615.025n

.meas tran vdout0_156ck1220 FIND v(dout0_156) AT=615.025n

.meas tran vdout0_157ck1220 FIND v(dout0_157) AT=615.025n

.meas tran vdout0_158ck1220 FIND v(dout0_158) AT=615.025n

.meas tran vdout0_159ck1220 FIND v(dout0_159) AT=615.025n

.meas tran vdout0_160ck1220 FIND v(dout0_160) AT=615.025n

.meas tran vdout0_161ck1220 FIND v(dout0_161) AT=615.025n

.meas tran vdout0_162ck1220 FIND v(dout0_162) AT=615.025n

.meas tran vdout0_163ck1220 FIND v(dout0_163) AT=615.025n

.meas tran vdout0_164ck1220 FIND v(dout0_164) AT=615.025n

.meas tran vdout0_165ck1220 FIND v(dout0_165) AT=615.025n

.meas tran vdout0_166ck1220 FIND v(dout0_166) AT=615.025n

.meas tran vdout0_167ck1220 FIND v(dout0_167) AT=615.025n

.meas tran vdout0_168ck1220 FIND v(dout0_168) AT=615.025n

.meas tran vdout0_169ck1220 FIND v(dout0_169) AT=615.025n

.meas tran vdout0_170ck1220 FIND v(dout0_170) AT=615.025n

.meas tran vdout0_171ck1220 FIND v(dout0_171) AT=615.025n

.meas tran vdout0_172ck1220 FIND v(dout0_172) AT=615.025n

.meas tran vdout0_173ck1220 FIND v(dout0_173) AT=615.025n

.meas tran vdout0_174ck1220 FIND v(dout0_174) AT=615.025n

.meas tran vdout0_175ck1220 FIND v(dout0_175) AT=615.025n

.meas tran vdout0_176ck1220 FIND v(dout0_176) AT=615.025n

.meas tran vdout0_177ck1220 FIND v(dout0_177) AT=615.025n

.meas tran vdout0_178ck1220 FIND v(dout0_178) AT=615.025n

.meas tran vdout0_179ck1220 FIND v(dout0_179) AT=615.025n

.meas tran vdout0_180ck1220 FIND v(dout0_180) AT=615.025n

.meas tran vdout0_181ck1220 FIND v(dout0_181) AT=615.025n

.meas tran vdout0_182ck1220 FIND v(dout0_182) AT=615.025n

.meas tran vdout0_183ck1220 FIND v(dout0_183) AT=615.025n

.meas tran vdout0_184ck1220 FIND v(dout0_184) AT=615.025n

.meas tran vdout0_185ck1220 FIND v(dout0_185) AT=615.025n

.meas tran vdout0_186ck1220 FIND v(dout0_186) AT=615.025n

.meas tran vdout0_187ck1220 FIND v(dout0_187) AT=615.025n

.meas tran vdout0_188ck1220 FIND v(dout0_188) AT=615.025n

.meas tran vdout0_189ck1220 FIND v(dout0_189) AT=615.025n

.meas tran vdout0_190ck1220 FIND v(dout0_190) AT=615.025n

.meas tran vdout0_191ck1220 FIND v(dout0_191) AT=615.025n

.meas tran vdout0_192ck1220 FIND v(dout0_192) AT=615.025n

.meas tran vdout0_193ck1220 FIND v(dout0_193) AT=615.025n

.meas tran vdout0_194ck1220 FIND v(dout0_194) AT=615.025n

.meas tran vdout0_195ck1220 FIND v(dout0_195) AT=615.025n

.meas tran vdout0_196ck1220 FIND v(dout0_196) AT=615.025n

.meas tran vdout0_197ck1220 FIND v(dout0_197) AT=615.025n

.meas tran vdout0_198ck1220 FIND v(dout0_198) AT=615.025n

.meas tran vdout0_199ck1220 FIND v(dout0_199) AT=615.025n

.meas tran vdout0_200ck1220 FIND v(dout0_200) AT=615.025n

.meas tran vdout0_201ck1220 FIND v(dout0_201) AT=615.025n

.meas tran vdout0_202ck1220 FIND v(dout0_202) AT=615.025n

.meas tran vdout0_203ck1220 FIND v(dout0_203) AT=615.025n

.meas tran vdout0_204ck1220 FIND v(dout0_204) AT=615.025n

.meas tran vdout0_205ck1220 FIND v(dout0_205) AT=615.025n

.meas tran vdout0_206ck1220 FIND v(dout0_206) AT=615.025n

.meas tran vdout0_207ck1220 FIND v(dout0_207) AT=615.025n

.meas tran vdout0_208ck1220 FIND v(dout0_208) AT=615.025n

.meas tran vdout0_209ck1220 FIND v(dout0_209) AT=615.025n

.meas tran vdout0_210ck1220 FIND v(dout0_210) AT=615.025n

.meas tran vdout0_211ck1220 FIND v(dout0_211) AT=615.025n

.meas tran vdout0_212ck1220 FIND v(dout0_212) AT=615.025n

.meas tran vdout0_213ck1220 FIND v(dout0_213) AT=615.025n

.meas tran vdout0_214ck1220 FIND v(dout0_214) AT=615.025n

.meas tran vdout0_215ck1220 FIND v(dout0_215) AT=615.025n

.meas tran vdout0_216ck1220 FIND v(dout0_216) AT=615.025n

.meas tran vdout0_217ck1220 FIND v(dout0_217) AT=615.025n

.meas tran vdout0_218ck1220 FIND v(dout0_218) AT=615.025n

.meas tran vdout0_219ck1220 FIND v(dout0_219) AT=615.025n

.meas tran vdout0_220ck1220 FIND v(dout0_220) AT=615.025n

.meas tran vdout0_221ck1220 FIND v(dout0_221) AT=615.025n

.meas tran vdout0_222ck1220 FIND v(dout0_222) AT=615.025n

.meas tran vdout0_223ck1220 FIND v(dout0_223) AT=615.025n

.meas tran vdout0_224ck1220 FIND v(dout0_224) AT=615.025n

.meas tran vdout0_225ck1220 FIND v(dout0_225) AT=615.025n

.meas tran vdout0_226ck1220 FIND v(dout0_226) AT=615.025n

.meas tran vdout0_227ck1220 FIND v(dout0_227) AT=615.025n

.meas tran vdout0_228ck1220 FIND v(dout0_228) AT=615.025n

.meas tran vdout0_229ck1220 FIND v(dout0_229) AT=615.025n

.meas tran vdout0_230ck1220 FIND v(dout0_230) AT=615.025n

.meas tran vdout0_231ck1220 FIND v(dout0_231) AT=615.025n

.meas tran vdout0_232ck1220 FIND v(dout0_232) AT=615.025n

.meas tran vdout0_233ck1220 FIND v(dout0_233) AT=615.025n

.meas tran vdout0_234ck1220 FIND v(dout0_234) AT=615.025n

.meas tran vdout0_235ck1220 FIND v(dout0_235) AT=615.025n

.meas tran vdout0_236ck1220 FIND v(dout0_236) AT=615.025n

.meas tran vdout0_237ck1220 FIND v(dout0_237) AT=615.025n

.meas tran vdout0_238ck1220 FIND v(dout0_238) AT=615.025n

.meas tran vdout0_239ck1220 FIND v(dout0_239) AT=615.025n

.meas tran vdout0_240ck1220 FIND v(dout0_240) AT=615.025n

.meas tran vdout0_241ck1220 FIND v(dout0_241) AT=615.025n

.meas tran vdout0_242ck1220 FIND v(dout0_242) AT=615.025n

.meas tran vdout0_243ck1220 FIND v(dout0_243) AT=615.025n

.meas tran vdout0_244ck1220 FIND v(dout0_244) AT=615.025n

.meas tran vdout0_245ck1220 FIND v(dout0_245) AT=615.025n

.meas tran vdout0_246ck1220 FIND v(dout0_246) AT=615.025n

.meas tran vdout0_247ck1220 FIND v(dout0_247) AT=615.025n

.meas tran vdout0_248ck1220 FIND v(dout0_248) AT=615.025n

.meas tran vdout0_249ck1220 FIND v(dout0_249) AT=615.025n

.meas tran vdout0_250ck1220 FIND v(dout0_250) AT=615.025n

.meas tran vdout0_251ck1220 FIND v(dout0_251) AT=615.025n

.meas tran vdout0_252ck1220 FIND v(dout0_252) AT=615.025n

.meas tran vdout0_253ck1220 FIND v(dout0_253) AT=615.025n

.meas tran vdout0_254ck1220 FIND v(dout0_254) AT=615.025n

.meas tran vdout0_255ck1220 FIND v(dout0_255) AT=615.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_128ck1280 FIND v(dout0_128) AT=645.025n

.meas tran vdout0_129ck1280 FIND v(dout0_129) AT=645.025n

.meas tran vdout0_130ck1280 FIND v(dout0_130) AT=645.025n

.meas tran vdout0_131ck1280 FIND v(dout0_131) AT=645.025n

.meas tran vdout0_132ck1280 FIND v(dout0_132) AT=645.025n

.meas tran vdout0_133ck1280 FIND v(dout0_133) AT=645.025n

.meas tran vdout0_134ck1280 FIND v(dout0_134) AT=645.025n

.meas tran vdout0_135ck1280 FIND v(dout0_135) AT=645.025n

.meas tran vdout0_136ck1280 FIND v(dout0_136) AT=645.025n

.meas tran vdout0_137ck1280 FIND v(dout0_137) AT=645.025n

.meas tran vdout0_138ck1280 FIND v(dout0_138) AT=645.025n

.meas tran vdout0_139ck1280 FIND v(dout0_139) AT=645.025n

.meas tran vdout0_140ck1280 FIND v(dout0_140) AT=645.025n

.meas tran vdout0_141ck1280 FIND v(dout0_141) AT=645.025n

.meas tran vdout0_142ck1280 FIND v(dout0_142) AT=645.025n

.meas tran vdout0_143ck1280 FIND v(dout0_143) AT=645.025n

.meas tran vdout0_144ck1280 FIND v(dout0_144) AT=645.025n

.meas tran vdout0_145ck1280 FIND v(dout0_145) AT=645.025n

.meas tran vdout0_146ck1280 FIND v(dout0_146) AT=645.025n

.meas tran vdout0_147ck1280 FIND v(dout0_147) AT=645.025n

.meas tran vdout0_148ck1280 FIND v(dout0_148) AT=645.025n

.meas tran vdout0_149ck1280 FIND v(dout0_149) AT=645.025n

.meas tran vdout0_150ck1280 FIND v(dout0_150) AT=645.025n

.meas tran vdout0_151ck1280 FIND v(dout0_151) AT=645.025n

.meas tran vdout0_152ck1280 FIND v(dout0_152) AT=645.025n

.meas tran vdout0_153ck1280 FIND v(dout0_153) AT=645.025n

.meas tran vdout0_154ck1280 FIND v(dout0_154) AT=645.025n

.meas tran vdout0_155ck1280 FIND v(dout0_155) AT=645.025n

.meas tran vdout0_156ck1280 FIND v(dout0_156) AT=645.025n

.meas tran vdout0_157ck1280 FIND v(dout0_157) AT=645.025n

.meas tran vdout0_158ck1280 FIND v(dout0_158) AT=645.025n

.meas tran vdout0_159ck1280 FIND v(dout0_159) AT=645.025n

.meas tran vdout0_160ck1280 FIND v(dout0_160) AT=645.025n

.meas tran vdout0_161ck1280 FIND v(dout0_161) AT=645.025n

.meas tran vdout0_162ck1280 FIND v(dout0_162) AT=645.025n

.meas tran vdout0_163ck1280 FIND v(dout0_163) AT=645.025n

.meas tran vdout0_164ck1280 FIND v(dout0_164) AT=645.025n

.meas tran vdout0_165ck1280 FIND v(dout0_165) AT=645.025n

.meas tran vdout0_166ck1280 FIND v(dout0_166) AT=645.025n

.meas tran vdout0_167ck1280 FIND v(dout0_167) AT=645.025n

.meas tran vdout0_168ck1280 FIND v(dout0_168) AT=645.025n

.meas tran vdout0_169ck1280 FIND v(dout0_169) AT=645.025n

.meas tran vdout0_170ck1280 FIND v(dout0_170) AT=645.025n

.meas tran vdout0_171ck1280 FIND v(dout0_171) AT=645.025n

.meas tran vdout0_172ck1280 FIND v(dout0_172) AT=645.025n

.meas tran vdout0_173ck1280 FIND v(dout0_173) AT=645.025n

.meas tran vdout0_174ck1280 FIND v(dout0_174) AT=645.025n

.meas tran vdout0_175ck1280 FIND v(dout0_175) AT=645.025n

.meas tran vdout0_176ck1280 FIND v(dout0_176) AT=645.025n

.meas tran vdout0_177ck1280 FIND v(dout0_177) AT=645.025n

.meas tran vdout0_178ck1280 FIND v(dout0_178) AT=645.025n

.meas tran vdout0_179ck1280 FIND v(dout0_179) AT=645.025n

.meas tran vdout0_180ck1280 FIND v(dout0_180) AT=645.025n

.meas tran vdout0_181ck1280 FIND v(dout0_181) AT=645.025n

.meas tran vdout0_182ck1280 FIND v(dout0_182) AT=645.025n

.meas tran vdout0_183ck1280 FIND v(dout0_183) AT=645.025n

.meas tran vdout0_184ck1280 FIND v(dout0_184) AT=645.025n

.meas tran vdout0_185ck1280 FIND v(dout0_185) AT=645.025n

.meas tran vdout0_186ck1280 FIND v(dout0_186) AT=645.025n

.meas tran vdout0_187ck1280 FIND v(dout0_187) AT=645.025n

.meas tran vdout0_188ck1280 FIND v(dout0_188) AT=645.025n

.meas tran vdout0_189ck1280 FIND v(dout0_189) AT=645.025n

.meas tran vdout0_190ck1280 FIND v(dout0_190) AT=645.025n

.meas tran vdout0_191ck1280 FIND v(dout0_191) AT=645.025n

.meas tran vdout0_192ck1280 FIND v(dout0_192) AT=645.025n

.meas tran vdout0_193ck1280 FIND v(dout0_193) AT=645.025n

.meas tran vdout0_194ck1280 FIND v(dout0_194) AT=645.025n

.meas tran vdout0_195ck1280 FIND v(dout0_195) AT=645.025n

.meas tran vdout0_196ck1280 FIND v(dout0_196) AT=645.025n

.meas tran vdout0_197ck1280 FIND v(dout0_197) AT=645.025n

.meas tran vdout0_198ck1280 FIND v(dout0_198) AT=645.025n

.meas tran vdout0_199ck1280 FIND v(dout0_199) AT=645.025n

.meas tran vdout0_200ck1280 FIND v(dout0_200) AT=645.025n

.meas tran vdout0_201ck1280 FIND v(dout0_201) AT=645.025n

.meas tran vdout0_202ck1280 FIND v(dout0_202) AT=645.025n

.meas tran vdout0_203ck1280 FIND v(dout0_203) AT=645.025n

.meas tran vdout0_204ck1280 FIND v(dout0_204) AT=645.025n

.meas tran vdout0_205ck1280 FIND v(dout0_205) AT=645.025n

.meas tran vdout0_206ck1280 FIND v(dout0_206) AT=645.025n

.meas tran vdout0_207ck1280 FIND v(dout0_207) AT=645.025n

.meas tran vdout0_208ck1280 FIND v(dout0_208) AT=645.025n

.meas tran vdout0_209ck1280 FIND v(dout0_209) AT=645.025n

.meas tran vdout0_210ck1280 FIND v(dout0_210) AT=645.025n

.meas tran vdout0_211ck1280 FIND v(dout0_211) AT=645.025n

.meas tran vdout0_212ck1280 FIND v(dout0_212) AT=645.025n

.meas tran vdout0_213ck1280 FIND v(dout0_213) AT=645.025n

.meas tran vdout0_214ck1280 FIND v(dout0_214) AT=645.025n

.meas tran vdout0_215ck1280 FIND v(dout0_215) AT=645.025n

.meas tran vdout0_216ck1280 FIND v(dout0_216) AT=645.025n

.meas tran vdout0_217ck1280 FIND v(dout0_217) AT=645.025n

.meas tran vdout0_218ck1280 FIND v(dout0_218) AT=645.025n

.meas tran vdout0_219ck1280 FIND v(dout0_219) AT=645.025n

.meas tran vdout0_220ck1280 FIND v(dout0_220) AT=645.025n

.meas tran vdout0_221ck1280 FIND v(dout0_221) AT=645.025n

.meas tran vdout0_222ck1280 FIND v(dout0_222) AT=645.025n

.meas tran vdout0_223ck1280 FIND v(dout0_223) AT=645.025n

.meas tran vdout0_224ck1280 FIND v(dout0_224) AT=645.025n

.meas tran vdout0_225ck1280 FIND v(dout0_225) AT=645.025n

.meas tran vdout0_226ck1280 FIND v(dout0_226) AT=645.025n

.meas tran vdout0_227ck1280 FIND v(dout0_227) AT=645.025n

.meas tran vdout0_228ck1280 FIND v(dout0_228) AT=645.025n

.meas tran vdout0_229ck1280 FIND v(dout0_229) AT=645.025n

.meas tran vdout0_230ck1280 FIND v(dout0_230) AT=645.025n

.meas tran vdout0_231ck1280 FIND v(dout0_231) AT=645.025n

.meas tran vdout0_232ck1280 FIND v(dout0_232) AT=645.025n

.meas tran vdout0_233ck1280 FIND v(dout0_233) AT=645.025n

.meas tran vdout0_234ck1280 FIND v(dout0_234) AT=645.025n

.meas tran vdout0_235ck1280 FIND v(dout0_235) AT=645.025n

.meas tran vdout0_236ck1280 FIND v(dout0_236) AT=645.025n

.meas tran vdout0_237ck1280 FIND v(dout0_237) AT=645.025n

.meas tran vdout0_238ck1280 FIND v(dout0_238) AT=645.025n

.meas tran vdout0_239ck1280 FIND v(dout0_239) AT=645.025n

.meas tran vdout0_240ck1280 FIND v(dout0_240) AT=645.025n

.meas tran vdout0_241ck1280 FIND v(dout0_241) AT=645.025n

.meas tran vdout0_242ck1280 FIND v(dout0_242) AT=645.025n

.meas tran vdout0_243ck1280 FIND v(dout0_243) AT=645.025n

.meas tran vdout0_244ck1280 FIND v(dout0_244) AT=645.025n

.meas tran vdout0_245ck1280 FIND v(dout0_245) AT=645.025n

.meas tran vdout0_246ck1280 FIND v(dout0_246) AT=645.025n

.meas tran vdout0_247ck1280 FIND v(dout0_247) AT=645.025n

.meas tran vdout0_248ck1280 FIND v(dout0_248) AT=645.025n

.meas tran vdout0_249ck1280 FIND v(dout0_249) AT=645.025n

.meas tran vdout0_250ck1280 FIND v(dout0_250) AT=645.025n

.meas tran vdout0_251ck1280 FIND v(dout0_251) AT=645.025n

.meas tran vdout0_252ck1280 FIND v(dout0_252) AT=645.025n

.meas tran vdout0_253ck1280 FIND v(dout0_253) AT=645.025n

.meas tran vdout0_254ck1280 FIND v(dout0_254) AT=645.025n

.meas tran vdout0_255ck1280 FIND v(dout0_255) AT=645.025n

.meas tran vdout0_0ck1290 FIND v(dout0_0) AT=650.025n

.meas tran vdout0_1ck1290 FIND v(dout0_1) AT=650.025n

.meas tran vdout0_2ck1290 FIND v(dout0_2) AT=650.025n

.meas tran vdout0_3ck1290 FIND v(dout0_3) AT=650.025n

.meas tran vdout0_4ck1290 FIND v(dout0_4) AT=650.025n

.meas tran vdout0_5ck1290 FIND v(dout0_5) AT=650.025n

.meas tran vdout0_6ck1290 FIND v(dout0_6) AT=650.025n

.meas tran vdout0_7ck1290 FIND v(dout0_7) AT=650.025n

.meas tran vdout0_8ck1290 FIND v(dout0_8) AT=650.025n

.meas tran vdout0_9ck1290 FIND v(dout0_9) AT=650.025n

.meas tran vdout0_10ck1290 FIND v(dout0_10) AT=650.025n

.meas tran vdout0_11ck1290 FIND v(dout0_11) AT=650.025n

.meas tran vdout0_12ck1290 FIND v(dout0_12) AT=650.025n

.meas tran vdout0_13ck1290 FIND v(dout0_13) AT=650.025n

.meas tran vdout0_14ck1290 FIND v(dout0_14) AT=650.025n

.meas tran vdout0_15ck1290 FIND v(dout0_15) AT=650.025n

.meas tran vdout0_16ck1290 FIND v(dout0_16) AT=650.025n

.meas tran vdout0_17ck1290 FIND v(dout0_17) AT=650.025n

.meas tran vdout0_18ck1290 FIND v(dout0_18) AT=650.025n

.meas tran vdout0_19ck1290 FIND v(dout0_19) AT=650.025n

.meas tran vdout0_20ck1290 FIND v(dout0_20) AT=650.025n

.meas tran vdout0_21ck1290 FIND v(dout0_21) AT=650.025n

.meas tran vdout0_22ck1290 FIND v(dout0_22) AT=650.025n

.meas tran vdout0_23ck1290 FIND v(dout0_23) AT=650.025n

.meas tran vdout0_24ck1290 FIND v(dout0_24) AT=650.025n

.meas tran vdout0_25ck1290 FIND v(dout0_25) AT=650.025n

.meas tran vdout0_26ck1290 FIND v(dout0_26) AT=650.025n

.meas tran vdout0_27ck1290 FIND v(dout0_27) AT=650.025n

.meas tran vdout0_28ck1290 FIND v(dout0_28) AT=650.025n

.meas tran vdout0_29ck1290 FIND v(dout0_29) AT=650.025n

.meas tran vdout0_30ck1290 FIND v(dout0_30) AT=650.025n

.meas tran vdout0_31ck1290 FIND v(dout0_31) AT=650.025n

.meas tran vdout0_32ck1290 FIND v(dout0_32) AT=650.025n

.meas tran vdout0_33ck1290 FIND v(dout0_33) AT=650.025n

.meas tran vdout0_34ck1290 FIND v(dout0_34) AT=650.025n

.meas tran vdout0_35ck1290 FIND v(dout0_35) AT=650.025n

.meas tran vdout0_36ck1290 FIND v(dout0_36) AT=650.025n

.meas tran vdout0_37ck1290 FIND v(dout0_37) AT=650.025n

.meas tran vdout0_38ck1290 FIND v(dout0_38) AT=650.025n

.meas tran vdout0_39ck1290 FIND v(dout0_39) AT=650.025n

.meas tran vdout0_40ck1290 FIND v(dout0_40) AT=650.025n

.meas tran vdout0_41ck1290 FIND v(dout0_41) AT=650.025n

.meas tran vdout0_42ck1290 FIND v(dout0_42) AT=650.025n

.meas tran vdout0_43ck1290 FIND v(dout0_43) AT=650.025n

.meas tran vdout0_44ck1290 FIND v(dout0_44) AT=650.025n

.meas tran vdout0_45ck1290 FIND v(dout0_45) AT=650.025n

.meas tran vdout0_46ck1290 FIND v(dout0_46) AT=650.025n

.meas tran vdout0_47ck1290 FIND v(dout0_47) AT=650.025n

.meas tran vdout0_48ck1290 FIND v(dout0_48) AT=650.025n

.meas tran vdout0_49ck1290 FIND v(dout0_49) AT=650.025n

.meas tran vdout0_50ck1290 FIND v(dout0_50) AT=650.025n

.meas tran vdout0_51ck1290 FIND v(dout0_51) AT=650.025n

.meas tran vdout0_52ck1290 FIND v(dout0_52) AT=650.025n

.meas tran vdout0_53ck1290 FIND v(dout0_53) AT=650.025n

.meas tran vdout0_54ck1290 FIND v(dout0_54) AT=650.025n

.meas tran vdout0_55ck1290 FIND v(dout0_55) AT=650.025n

.meas tran vdout0_56ck1290 FIND v(dout0_56) AT=650.025n

.meas tran vdout0_57ck1290 FIND v(dout0_57) AT=650.025n

.meas tran vdout0_58ck1290 FIND v(dout0_58) AT=650.025n

.meas tran vdout0_59ck1290 FIND v(dout0_59) AT=650.025n

.meas tran vdout0_60ck1290 FIND v(dout0_60) AT=650.025n

.meas tran vdout0_61ck1290 FIND v(dout0_61) AT=650.025n

.meas tran vdout0_62ck1290 FIND v(dout0_62) AT=650.025n

.meas tran vdout0_63ck1290 FIND v(dout0_63) AT=650.025n

.meas tran vdout0_64ck1290 FIND v(dout0_64) AT=650.025n

.meas tran vdout0_65ck1290 FIND v(dout0_65) AT=650.025n

.meas tran vdout0_66ck1290 FIND v(dout0_66) AT=650.025n

.meas tran vdout0_67ck1290 FIND v(dout0_67) AT=650.025n

.meas tran vdout0_68ck1290 FIND v(dout0_68) AT=650.025n

.meas tran vdout0_69ck1290 FIND v(dout0_69) AT=650.025n

.meas tran vdout0_70ck1290 FIND v(dout0_70) AT=650.025n

.meas tran vdout0_71ck1290 FIND v(dout0_71) AT=650.025n

.meas tran vdout0_72ck1290 FIND v(dout0_72) AT=650.025n

.meas tran vdout0_73ck1290 FIND v(dout0_73) AT=650.025n

.meas tran vdout0_74ck1290 FIND v(dout0_74) AT=650.025n

.meas tran vdout0_75ck1290 FIND v(dout0_75) AT=650.025n

.meas tran vdout0_76ck1290 FIND v(dout0_76) AT=650.025n

.meas tran vdout0_77ck1290 FIND v(dout0_77) AT=650.025n

.meas tran vdout0_78ck1290 FIND v(dout0_78) AT=650.025n

.meas tran vdout0_79ck1290 FIND v(dout0_79) AT=650.025n

.meas tran vdout0_80ck1290 FIND v(dout0_80) AT=650.025n

.meas tran vdout0_81ck1290 FIND v(dout0_81) AT=650.025n

.meas tran vdout0_82ck1290 FIND v(dout0_82) AT=650.025n

.meas tran vdout0_83ck1290 FIND v(dout0_83) AT=650.025n

.meas tran vdout0_84ck1290 FIND v(dout0_84) AT=650.025n

.meas tran vdout0_85ck1290 FIND v(dout0_85) AT=650.025n

.meas tran vdout0_86ck1290 FIND v(dout0_86) AT=650.025n

.meas tran vdout0_87ck1290 FIND v(dout0_87) AT=650.025n

.meas tran vdout0_88ck1290 FIND v(dout0_88) AT=650.025n

.meas tran vdout0_89ck1290 FIND v(dout0_89) AT=650.025n

.meas tran vdout0_90ck1290 FIND v(dout0_90) AT=650.025n

.meas tran vdout0_91ck1290 FIND v(dout0_91) AT=650.025n

.meas tran vdout0_92ck1290 FIND v(dout0_92) AT=650.025n

.meas tran vdout0_93ck1290 FIND v(dout0_93) AT=650.025n

.meas tran vdout0_94ck1290 FIND v(dout0_94) AT=650.025n

.meas tran vdout0_95ck1290 FIND v(dout0_95) AT=650.025n

.meas tran vdout0_96ck1290 FIND v(dout0_96) AT=650.025n

.meas tran vdout0_97ck1290 FIND v(dout0_97) AT=650.025n

.meas tran vdout0_98ck1290 FIND v(dout0_98) AT=650.025n

.meas tran vdout0_99ck1290 FIND v(dout0_99) AT=650.025n

.meas tran vdout0_100ck1290 FIND v(dout0_100) AT=650.025n

.meas tran vdout0_101ck1290 FIND v(dout0_101) AT=650.025n

.meas tran vdout0_102ck1290 FIND v(dout0_102) AT=650.025n

.meas tran vdout0_103ck1290 FIND v(dout0_103) AT=650.025n

.meas tran vdout0_104ck1290 FIND v(dout0_104) AT=650.025n

.meas tran vdout0_105ck1290 FIND v(dout0_105) AT=650.025n

.meas tran vdout0_106ck1290 FIND v(dout0_106) AT=650.025n

.meas tran vdout0_107ck1290 FIND v(dout0_107) AT=650.025n

.meas tran vdout0_108ck1290 FIND v(dout0_108) AT=650.025n

.meas tran vdout0_109ck1290 FIND v(dout0_109) AT=650.025n

.meas tran vdout0_110ck1290 FIND v(dout0_110) AT=650.025n

.meas tran vdout0_111ck1290 FIND v(dout0_111) AT=650.025n

.meas tran vdout0_112ck1290 FIND v(dout0_112) AT=650.025n

.meas tran vdout0_113ck1290 FIND v(dout0_113) AT=650.025n

.meas tran vdout0_114ck1290 FIND v(dout0_114) AT=650.025n

.meas tran vdout0_115ck1290 FIND v(dout0_115) AT=650.025n

.meas tran vdout0_116ck1290 FIND v(dout0_116) AT=650.025n

.meas tran vdout0_117ck1290 FIND v(dout0_117) AT=650.025n

.meas tran vdout0_118ck1290 FIND v(dout0_118) AT=650.025n

.meas tran vdout0_119ck1290 FIND v(dout0_119) AT=650.025n

.meas tran vdout0_120ck1290 FIND v(dout0_120) AT=650.025n

.meas tran vdout0_121ck1290 FIND v(dout0_121) AT=650.025n

.meas tran vdout0_122ck1290 FIND v(dout0_122) AT=650.025n

.meas tran vdout0_123ck1290 FIND v(dout0_123) AT=650.025n

.meas tran vdout0_124ck1290 FIND v(dout0_124) AT=650.025n

.meas tran vdout0_125ck1290 FIND v(dout0_125) AT=650.025n

.meas tran vdout0_126ck1290 FIND v(dout0_126) AT=650.025n

.meas tran vdout0_127ck1290 FIND v(dout0_127) AT=650.025n

.meas tran vdout0_128ck1290 FIND v(dout0_128) AT=650.025n

.meas tran vdout0_129ck1290 FIND v(dout0_129) AT=650.025n

.meas tran vdout0_130ck1290 FIND v(dout0_130) AT=650.025n

.meas tran vdout0_131ck1290 FIND v(dout0_131) AT=650.025n

.meas tran vdout0_132ck1290 FIND v(dout0_132) AT=650.025n

.meas tran vdout0_133ck1290 FIND v(dout0_133) AT=650.025n

.meas tran vdout0_134ck1290 FIND v(dout0_134) AT=650.025n

.meas tran vdout0_135ck1290 FIND v(dout0_135) AT=650.025n

.meas tran vdout0_136ck1290 FIND v(dout0_136) AT=650.025n

.meas tran vdout0_137ck1290 FIND v(dout0_137) AT=650.025n

.meas tran vdout0_138ck1290 FIND v(dout0_138) AT=650.025n

.meas tran vdout0_139ck1290 FIND v(dout0_139) AT=650.025n

.meas tran vdout0_140ck1290 FIND v(dout0_140) AT=650.025n

.meas tran vdout0_141ck1290 FIND v(dout0_141) AT=650.025n

.meas tran vdout0_142ck1290 FIND v(dout0_142) AT=650.025n

.meas tran vdout0_143ck1290 FIND v(dout0_143) AT=650.025n

.meas tran vdout0_144ck1290 FIND v(dout0_144) AT=650.025n

.meas tran vdout0_145ck1290 FIND v(dout0_145) AT=650.025n

.meas tran vdout0_146ck1290 FIND v(dout0_146) AT=650.025n

.meas tran vdout0_147ck1290 FIND v(dout0_147) AT=650.025n

.meas tran vdout0_148ck1290 FIND v(dout0_148) AT=650.025n

.meas tran vdout0_149ck1290 FIND v(dout0_149) AT=650.025n

.meas tran vdout0_150ck1290 FIND v(dout0_150) AT=650.025n

.meas tran vdout0_151ck1290 FIND v(dout0_151) AT=650.025n

.meas tran vdout0_152ck1290 FIND v(dout0_152) AT=650.025n

.meas tran vdout0_153ck1290 FIND v(dout0_153) AT=650.025n

.meas tran vdout0_154ck1290 FIND v(dout0_154) AT=650.025n

.meas tran vdout0_155ck1290 FIND v(dout0_155) AT=650.025n

.meas tran vdout0_156ck1290 FIND v(dout0_156) AT=650.025n

.meas tran vdout0_157ck1290 FIND v(dout0_157) AT=650.025n

.meas tran vdout0_158ck1290 FIND v(dout0_158) AT=650.025n

.meas tran vdout0_159ck1290 FIND v(dout0_159) AT=650.025n

.meas tran vdout0_160ck1290 FIND v(dout0_160) AT=650.025n

.meas tran vdout0_161ck1290 FIND v(dout0_161) AT=650.025n

.meas tran vdout0_162ck1290 FIND v(dout0_162) AT=650.025n

.meas tran vdout0_163ck1290 FIND v(dout0_163) AT=650.025n

.meas tran vdout0_164ck1290 FIND v(dout0_164) AT=650.025n

.meas tran vdout0_165ck1290 FIND v(dout0_165) AT=650.025n

.meas tran vdout0_166ck1290 FIND v(dout0_166) AT=650.025n

.meas tran vdout0_167ck1290 FIND v(dout0_167) AT=650.025n

.meas tran vdout0_168ck1290 FIND v(dout0_168) AT=650.025n

.meas tran vdout0_169ck1290 FIND v(dout0_169) AT=650.025n

.meas tran vdout0_170ck1290 FIND v(dout0_170) AT=650.025n

.meas tran vdout0_171ck1290 FIND v(dout0_171) AT=650.025n

.meas tran vdout0_172ck1290 FIND v(dout0_172) AT=650.025n

.meas tran vdout0_173ck1290 FIND v(dout0_173) AT=650.025n

.meas tran vdout0_174ck1290 FIND v(dout0_174) AT=650.025n

.meas tran vdout0_175ck1290 FIND v(dout0_175) AT=650.025n

.meas tran vdout0_176ck1290 FIND v(dout0_176) AT=650.025n

.meas tran vdout0_177ck1290 FIND v(dout0_177) AT=650.025n

.meas tran vdout0_178ck1290 FIND v(dout0_178) AT=650.025n

.meas tran vdout0_179ck1290 FIND v(dout0_179) AT=650.025n

.meas tran vdout0_180ck1290 FIND v(dout0_180) AT=650.025n

.meas tran vdout0_181ck1290 FIND v(dout0_181) AT=650.025n

.meas tran vdout0_182ck1290 FIND v(dout0_182) AT=650.025n

.meas tran vdout0_183ck1290 FIND v(dout0_183) AT=650.025n

.meas tran vdout0_184ck1290 FIND v(dout0_184) AT=650.025n

.meas tran vdout0_185ck1290 FIND v(dout0_185) AT=650.025n

.meas tran vdout0_186ck1290 FIND v(dout0_186) AT=650.025n

.meas tran vdout0_187ck1290 FIND v(dout0_187) AT=650.025n

.meas tran vdout0_188ck1290 FIND v(dout0_188) AT=650.025n

.meas tran vdout0_189ck1290 FIND v(dout0_189) AT=650.025n

.meas tran vdout0_190ck1290 FIND v(dout0_190) AT=650.025n

.meas tran vdout0_191ck1290 FIND v(dout0_191) AT=650.025n

.meas tran vdout0_192ck1290 FIND v(dout0_192) AT=650.025n

.meas tran vdout0_193ck1290 FIND v(dout0_193) AT=650.025n

.meas tran vdout0_194ck1290 FIND v(dout0_194) AT=650.025n

.meas tran vdout0_195ck1290 FIND v(dout0_195) AT=650.025n

.meas tran vdout0_196ck1290 FIND v(dout0_196) AT=650.025n

.meas tran vdout0_197ck1290 FIND v(dout0_197) AT=650.025n

.meas tran vdout0_198ck1290 FIND v(dout0_198) AT=650.025n

.meas tran vdout0_199ck1290 FIND v(dout0_199) AT=650.025n

.meas tran vdout0_200ck1290 FIND v(dout0_200) AT=650.025n

.meas tran vdout0_201ck1290 FIND v(dout0_201) AT=650.025n

.meas tran vdout0_202ck1290 FIND v(dout0_202) AT=650.025n

.meas tran vdout0_203ck1290 FIND v(dout0_203) AT=650.025n

.meas tran vdout0_204ck1290 FIND v(dout0_204) AT=650.025n

.meas tran vdout0_205ck1290 FIND v(dout0_205) AT=650.025n

.meas tran vdout0_206ck1290 FIND v(dout0_206) AT=650.025n

.meas tran vdout0_207ck1290 FIND v(dout0_207) AT=650.025n

.meas tran vdout0_208ck1290 FIND v(dout0_208) AT=650.025n

.meas tran vdout0_209ck1290 FIND v(dout0_209) AT=650.025n

.meas tran vdout0_210ck1290 FIND v(dout0_210) AT=650.025n

.meas tran vdout0_211ck1290 FIND v(dout0_211) AT=650.025n

.meas tran vdout0_212ck1290 FIND v(dout0_212) AT=650.025n

.meas tran vdout0_213ck1290 FIND v(dout0_213) AT=650.025n

.meas tran vdout0_214ck1290 FIND v(dout0_214) AT=650.025n

.meas tran vdout0_215ck1290 FIND v(dout0_215) AT=650.025n

.meas tran vdout0_216ck1290 FIND v(dout0_216) AT=650.025n

.meas tran vdout0_217ck1290 FIND v(dout0_217) AT=650.025n

.meas tran vdout0_218ck1290 FIND v(dout0_218) AT=650.025n

.meas tran vdout0_219ck1290 FIND v(dout0_219) AT=650.025n

.meas tran vdout0_220ck1290 FIND v(dout0_220) AT=650.025n

.meas tran vdout0_221ck1290 FIND v(dout0_221) AT=650.025n

.meas tran vdout0_222ck1290 FIND v(dout0_222) AT=650.025n

.meas tran vdout0_223ck1290 FIND v(dout0_223) AT=650.025n

.meas tran vdout0_224ck1290 FIND v(dout0_224) AT=650.025n

.meas tran vdout0_225ck1290 FIND v(dout0_225) AT=650.025n

.meas tran vdout0_226ck1290 FIND v(dout0_226) AT=650.025n

.meas tran vdout0_227ck1290 FIND v(dout0_227) AT=650.025n

.meas tran vdout0_228ck1290 FIND v(dout0_228) AT=650.025n

.meas tran vdout0_229ck1290 FIND v(dout0_229) AT=650.025n

.meas tran vdout0_230ck1290 FIND v(dout0_230) AT=650.025n

.meas tran vdout0_231ck1290 FIND v(dout0_231) AT=650.025n

.meas tran vdout0_232ck1290 FIND v(dout0_232) AT=650.025n

.meas tran vdout0_233ck1290 FIND v(dout0_233) AT=650.025n

.meas tran vdout0_234ck1290 FIND v(dout0_234) AT=650.025n

.meas tran vdout0_235ck1290 FIND v(dout0_235) AT=650.025n

.meas tran vdout0_236ck1290 FIND v(dout0_236) AT=650.025n

.meas tran vdout0_237ck1290 FIND v(dout0_237) AT=650.025n

.meas tran vdout0_238ck1290 FIND v(dout0_238) AT=650.025n

.meas tran vdout0_239ck1290 FIND v(dout0_239) AT=650.025n

.meas tran vdout0_240ck1290 FIND v(dout0_240) AT=650.025n

.meas tran vdout0_241ck1290 FIND v(dout0_241) AT=650.025n

.meas tran vdout0_242ck1290 FIND v(dout0_242) AT=650.025n

.meas tran vdout0_243ck1290 FIND v(dout0_243) AT=650.025n

.meas tran vdout0_244ck1290 FIND v(dout0_244) AT=650.025n

.meas tran vdout0_245ck1290 FIND v(dout0_245) AT=650.025n

.meas tran vdout0_246ck1290 FIND v(dout0_246) AT=650.025n

.meas tran vdout0_247ck1290 FIND v(dout0_247) AT=650.025n

.meas tran vdout0_248ck1290 FIND v(dout0_248) AT=650.025n

.meas tran vdout0_249ck1290 FIND v(dout0_249) AT=650.025n

.meas tran vdout0_250ck1290 FIND v(dout0_250) AT=650.025n

.meas tran vdout0_251ck1290 FIND v(dout0_251) AT=650.025n

.meas tran vdout0_252ck1290 FIND v(dout0_252) AT=650.025n

.meas tran vdout0_253ck1290 FIND v(dout0_253) AT=650.025n

.meas tran vdout0_254ck1290 FIND v(dout0_254) AT=650.025n

.meas tran vdout0_255ck1290 FIND v(dout0_255) AT=650.025n

.meas tran vdout0_0ck1300 FIND v(dout0_0) AT=655.025n

.meas tran vdout0_1ck1300 FIND v(dout0_1) AT=655.025n

.meas tran vdout0_2ck1300 FIND v(dout0_2) AT=655.025n

.meas tran vdout0_3ck1300 FIND v(dout0_3) AT=655.025n

.meas tran vdout0_4ck1300 FIND v(dout0_4) AT=655.025n

.meas tran vdout0_5ck1300 FIND v(dout0_5) AT=655.025n

.meas tran vdout0_6ck1300 FIND v(dout0_6) AT=655.025n

.meas tran vdout0_7ck1300 FIND v(dout0_7) AT=655.025n

.meas tran vdout0_8ck1300 FIND v(dout0_8) AT=655.025n

.meas tran vdout0_9ck1300 FIND v(dout0_9) AT=655.025n

.meas tran vdout0_10ck1300 FIND v(dout0_10) AT=655.025n

.meas tran vdout0_11ck1300 FIND v(dout0_11) AT=655.025n

.meas tran vdout0_12ck1300 FIND v(dout0_12) AT=655.025n

.meas tran vdout0_13ck1300 FIND v(dout0_13) AT=655.025n

.meas tran vdout0_14ck1300 FIND v(dout0_14) AT=655.025n

.meas tran vdout0_15ck1300 FIND v(dout0_15) AT=655.025n

.meas tran vdout0_16ck1300 FIND v(dout0_16) AT=655.025n

.meas tran vdout0_17ck1300 FIND v(dout0_17) AT=655.025n

.meas tran vdout0_18ck1300 FIND v(dout0_18) AT=655.025n

.meas tran vdout0_19ck1300 FIND v(dout0_19) AT=655.025n

.meas tran vdout0_20ck1300 FIND v(dout0_20) AT=655.025n

.meas tran vdout0_21ck1300 FIND v(dout0_21) AT=655.025n

.meas tran vdout0_22ck1300 FIND v(dout0_22) AT=655.025n

.meas tran vdout0_23ck1300 FIND v(dout0_23) AT=655.025n

.meas tran vdout0_24ck1300 FIND v(dout0_24) AT=655.025n

.meas tran vdout0_25ck1300 FIND v(dout0_25) AT=655.025n

.meas tran vdout0_26ck1300 FIND v(dout0_26) AT=655.025n

.meas tran vdout0_27ck1300 FIND v(dout0_27) AT=655.025n

.meas tran vdout0_28ck1300 FIND v(dout0_28) AT=655.025n

.meas tran vdout0_29ck1300 FIND v(dout0_29) AT=655.025n

.meas tran vdout0_30ck1300 FIND v(dout0_30) AT=655.025n

.meas tran vdout0_31ck1300 FIND v(dout0_31) AT=655.025n

.meas tran vdout0_32ck1300 FIND v(dout0_32) AT=655.025n

.meas tran vdout0_33ck1300 FIND v(dout0_33) AT=655.025n

.meas tran vdout0_34ck1300 FIND v(dout0_34) AT=655.025n

.meas tran vdout0_35ck1300 FIND v(dout0_35) AT=655.025n

.meas tran vdout0_36ck1300 FIND v(dout0_36) AT=655.025n

.meas tran vdout0_37ck1300 FIND v(dout0_37) AT=655.025n

.meas tran vdout0_38ck1300 FIND v(dout0_38) AT=655.025n

.meas tran vdout0_39ck1300 FIND v(dout0_39) AT=655.025n

.meas tran vdout0_40ck1300 FIND v(dout0_40) AT=655.025n

.meas tran vdout0_41ck1300 FIND v(dout0_41) AT=655.025n

.meas tran vdout0_42ck1300 FIND v(dout0_42) AT=655.025n

.meas tran vdout0_43ck1300 FIND v(dout0_43) AT=655.025n

.meas tran vdout0_44ck1300 FIND v(dout0_44) AT=655.025n

.meas tran vdout0_45ck1300 FIND v(dout0_45) AT=655.025n

.meas tran vdout0_46ck1300 FIND v(dout0_46) AT=655.025n

.meas tran vdout0_47ck1300 FIND v(dout0_47) AT=655.025n

.meas tran vdout0_48ck1300 FIND v(dout0_48) AT=655.025n

.meas tran vdout0_49ck1300 FIND v(dout0_49) AT=655.025n

.meas tran vdout0_50ck1300 FIND v(dout0_50) AT=655.025n

.meas tran vdout0_51ck1300 FIND v(dout0_51) AT=655.025n

.meas tran vdout0_52ck1300 FIND v(dout0_52) AT=655.025n

.meas tran vdout0_53ck1300 FIND v(dout0_53) AT=655.025n

.meas tran vdout0_54ck1300 FIND v(dout0_54) AT=655.025n

.meas tran vdout0_55ck1300 FIND v(dout0_55) AT=655.025n

.meas tran vdout0_56ck1300 FIND v(dout0_56) AT=655.025n

.meas tran vdout0_57ck1300 FIND v(dout0_57) AT=655.025n

.meas tran vdout0_58ck1300 FIND v(dout0_58) AT=655.025n

.meas tran vdout0_59ck1300 FIND v(dout0_59) AT=655.025n

.meas tran vdout0_60ck1300 FIND v(dout0_60) AT=655.025n

.meas tran vdout0_61ck1300 FIND v(dout0_61) AT=655.025n

.meas tran vdout0_62ck1300 FIND v(dout0_62) AT=655.025n

.meas tran vdout0_63ck1300 FIND v(dout0_63) AT=655.025n

.meas tran vdout0_64ck1300 FIND v(dout0_64) AT=655.025n

.meas tran vdout0_65ck1300 FIND v(dout0_65) AT=655.025n

.meas tran vdout0_66ck1300 FIND v(dout0_66) AT=655.025n

.meas tran vdout0_67ck1300 FIND v(dout0_67) AT=655.025n

.meas tran vdout0_68ck1300 FIND v(dout0_68) AT=655.025n

.meas tran vdout0_69ck1300 FIND v(dout0_69) AT=655.025n

.meas tran vdout0_70ck1300 FIND v(dout0_70) AT=655.025n

.meas tran vdout0_71ck1300 FIND v(dout0_71) AT=655.025n

.meas tran vdout0_72ck1300 FIND v(dout0_72) AT=655.025n

.meas tran vdout0_73ck1300 FIND v(dout0_73) AT=655.025n

.meas tran vdout0_74ck1300 FIND v(dout0_74) AT=655.025n

.meas tran vdout0_75ck1300 FIND v(dout0_75) AT=655.025n

.meas tran vdout0_76ck1300 FIND v(dout0_76) AT=655.025n

.meas tran vdout0_77ck1300 FIND v(dout0_77) AT=655.025n

.meas tran vdout0_78ck1300 FIND v(dout0_78) AT=655.025n

.meas tran vdout0_79ck1300 FIND v(dout0_79) AT=655.025n

.meas tran vdout0_80ck1300 FIND v(dout0_80) AT=655.025n

.meas tran vdout0_81ck1300 FIND v(dout0_81) AT=655.025n

.meas tran vdout0_82ck1300 FIND v(dout0_82) AT=655.025n

.meas tran vdout0_83ck1300 FIND v(dout0_83) AT=655.025n

.meas tran vdout0_84ck1300 FIND v(dout0_84) AT=655.025n

.meas tran vdout0_85ck1300 FIND v(dout0_85) AT=655.025n

.meas tran vdout0_86ck1300 FIND v(dout0_86) AT=655.025n

.meas tran vdout0_87ck1300 FIND v(dout0_87) AT=655.025n

.meas tran vdout0_88ck1300 FIND v(dout0_88) AT=655.025n

.meas tran vdout0_89ck1300 FIND v(dout0_89) AT=655.025n

.meas tran vdout0_90ck1300 FIND v(dout0_90) AT=655.025n

.meas tran vdout0_91ck1300 FIND v(dout0_91) AT=655.025n

.meas tran vdout0_92ck1300 FIND v(dout0_92) AT=655.025n

.meas tran vdout0_93ck1300 FIND v(dout0_93) AT=655.025n

.meas tran vdout0_94ck1300 FIND v(dout0_94) AT=655.025n

.meas tran vdout0_95ck1300 FIND v(dout0_95) AT=655.025n

.meas tran vdout0_96ck1300 FIND v(dout0_96) AT=655.025n

.meas tran vdout0_97ck1300 FIND v(dout0_97) AT=655.025n

.meas tran vdout0_98ck1300 FIND v(dout0_98) AT=655.025n

.meas tran vdout0_99ck1300 FIND v(dout0_99) AT=655.025n

.meas tran vdout0_100ck1300 FIND v(dout0_100) AT=655.025n

.meas tran vdout0_101ck1300 FIND v(dout0_101) AT=655.025n

.meas tran vdout0_102ck1300 FIND v(dout0_102) AT=655.025n

.meas tran vdout0_103ck1300 FIND v(dout0_103) AT=655.025n

.meas tran vdout0_104ck1300 FIND v(dout0_104) AT=655.025n

.meas tran vdout0_105ck1300 FIND v(dout0_105) AT=655.025n

.meas tran vdout0_106ck1300 FIND v(dout0_106) AT=655.025n

.meas tran vdout0_107ck1300 FIND v(dout0_107) AT=655.025n

.meas tran vdout0_108ck1300 FIND v(dout0_108) AT=655.025n

.meas tran vdout0_109ck1300 FIND v(dout0_109) AT=655.025n

.meas tran vdout0_110ck1300 FIND v(dout0_110) AT=655.025n

.meas tran vdout0_111ck1300 FIND v(dout0_111) AT=655.025n

.meas tran vdout0_112ck1300 FIND v(dout0_112) AT=655.025n

.meas tran vdout0_113ck1300 FIND v(dout0_113) AT=655.025n

.meas tran vdout0_114ck1300 FIND v(dout0_114) AT=655.025n

.meas tran vdout0_115ck1300 FIND v(dout0_115) AT=655.025n

.meas tran vdout0_116ck1300 FIND v(dout0_116) AT=655.025n

.meas tran vdout0_117ck1300 FIND v(dout0_117) AT=655.025n

.meas tran vdout0_118ck1300 FIND v(dout0_118) AT=655.025n

.meas tran vdout0_119ck1300 FIND v(dout0_119) AT=655.025n

.meas tran vdout0_120ck1300 FIND v(dout0_120) AT=655.025n

.meas tran vdout0_121ck1300 FIND v(dout0_121) AT=655.025n

.meas tran vdout0_122ck1300 FIND v(dout0_122) AT=655.025n

.meas tran vdout0_123ck1300 FIND v(dout0_123) AT=655.025n

.meas tran vdout0_124ck1300 FIND v(dout0_124) AT=655.025n

.meas tran vdout0_125ck1300 FIND v(dout0_125) AT=655.025n

.meas tran vdout0_126ck1300 FIND v(dout0_126) AT=655.025n

.meas tran vdout0_127ck1300 FIND v(dout0_127) AT=655.025n

.meas tran vdout0_128ck1300 FIND v(dout0_128) AT=655.025n

.meas tran vdout0_129ck1300 FIND v(dout0_129) AT=655.025n

.meas tran vdout0_130ck1300 FIND v(dout0_130) AT=655.025n

.meas tran vdout0_131ck1300 FIND v(dout0_131) AT=655.025n

.meas tran vdout0_132ck1300 FIND v(dout0_132) AT=655.025n

.meas tran vdout0_133ck1300 FIND v(dout0_133) AT=655.025n

.meas tran vdout0_134ck1300 FIND v(dout0_134) AT=655.025n

.meas tran vdout0_135ck1300 FIND v(dout0_135) AT=655.025n

.meas tran vdout0_136ck1300 FIND v(dout0_136) AT=655.025n

.meas tran vdout0_137ck1300 FIND v(dout0_137) AT=655.025n

.meas tran vdout0_138ck1300 FIND v(dout0_138) AT=655.025n

.meas tran vdout0_139ck1300 FIND v(dout0_139) AT=655.025n

.meas tran vdout0_140ck1300 FIND v(dout0_140) AT=655.025n

.meas tran vdout0_141ck1300 FIND v(dout0_141) AT=655.025n

.meas tran vdout0_142ck1300 FIND v(dout0_142) AT=655.025n

.meas tran vdout0_143ck1300 FIND v(dout0_143) AT=655.025n

.meas tran vdout0_144ck1300 FIND v(dout0_144) AT=655.025n

.meas tran vdout0_145ck1300 FIND v(dout0_145) AT=655.025n

.meas tran vdout0_146ck1300 FIND v(dout0_146) AT=655.025n

.meas tran vdout0_147ck1300 FIND v(dout0_147) AT=655.025n

.meas tran vdout0_148ck1300 FIND v(dout0_148) AT=655.025n

.meas tran vdout0_149ck1300 FIND v(dout0_149) AT=655.025n

.meas tran vdout0_150ck1300 FIND v(dout0_150) AT=655.025n

.meas tran vdout0_151ck1300 FIND v(dout0_151) AT=655.025n

.meas tran vdout0_152ck1300 FIND v(dout0_152) AT=655.025n

.meas tran vdout0_153ck1300 FIND v(dout0_153) AT=655.025n

.meas tran vdout0_154ck1300 FIND v(dout0_154) AT=655.025n

.meas tran vdout0_155ck1300 FIND v(dout0_155) AT=655.025n

.meas tran vdout0_156ck1300 FIND v(dout0_156) AT=655.025n

.meas tran vdout0_157ck1300 FIND v(dout0_157) AT=655.025n

.meas tran vdout0_158ck1300 FIND v(dout0_158) AT=655.025n

.meas tran vdout0_159ck1300 FIND v(dout0_159) AT=655.025n

.meas tran vdout0_160ck1300 FIND v(dout0_160) AT=655.025n

.meas tran vdout0_161ck1300 FIND v(dout0_161) AT=655.025n

.meas tran vdout0_162ck1300 FIND v(dout0_162) AT=655.025n

.meas tran vdout0_163ck1300 FIND v(dout0_163) AT=655.025n

.meas tran vdout0_164ck1300 FIND v(dout0_164) AT=655.025n

.meas tran vdout0_165ck1300 FIND v(dout0_165) AT=655.025n

.meas tran vdout0_166ck1300 FIND v(dout0_166) AT=655.025n

.meas tran vdout0_167ck1300 FIND v(dout0_167) AT=655.025n

.meas tran vdout0_168ck1300 FIND v(dout0_168) AT=655.025n

.meas tran vdout0_169ck1300 FIND v(dout0_169) AT=655.025n

.meas tran vdout0_170ck1300 FIND v(dout0_170) AT=655.025n

.meas tran vdout0_171ck1300 FIND v(dout0_171) AT=655.025n

.meas tran vdout0_172ck1300 FIND v(dout0_172) AT=655.025n

.meas tran vdout0_173ck1300 FIND v(dout0_173) AT=655.025n

.meas tran vdout0_174ck1300 FIND v(dout0_174) AT=655.025n

.meas tran vdout0_175ck1300 FIND v(dout0_175) AT=655.025n

.meas tran vdout0_176ck1300 FIND v(dout0_176) AT=655.025n

.meas tran vdout0_177ck1300 FIND v(dout0_177) AT=655.025n

.meas tran vdout0_178ck1300 FIND v(dout0_178) AT=655.025n

.meas tran vdout0_179ck1300 FIND v(dout0_179) AT=655.025n

.meas tran vdout0_180ck1300 FIND v(dout0_180) AT=655.025n

.meas tran vdout0_181ck1300 FIND v(dout0_181) AT=655.025n

.meas tran vdout0_182ck1300 FIND v(dout0_182) AT=655.025n

.meas tran vdout0_183ck1300 FIND v(dout0_183) AT=655.025n

.meas tran vdout0_184ck1300 FIND v(dout0_184) AT=655.025n

.meas tran vdout0_185ck1300 FIND v(dout0_185) AT=655.025n

.meas tran vdout0_186ck1300 FIND v(dout0_186) AT=655.025n

.meas tran vdout0_187ck1300 FIND v(dout0_187) AT=655.025n

.meas tran vdout0_188ck1300 FIND v(dout0_188) AT=655.025n

.meas tran vdout0_189ck1300 FIND v(dout0_189) AT=655.025n

.meas tran vdout0_190ck1300 FIND v(dout0_190) AT=655.025n

.meas tran vdout0_191ck1300 FIND v(dout0_191) AT=655.025n

.meas tran vdout0_192ck1300 FIND v(dout0_192) AT=655.025n

.meas tran vdout0_193ck1300 FIND v(dout0_193) AT=655.025n

.meas tran vdout0_194ck1300 FIND v(dout0_194) AT=655.025n

.meas tran vdout0_195ck1300 FIND v(dout0_195) AT=655.025n

.meas tran vdout0_196ck1300 FIND v(dout0_196) AT=655.025n

.meas tran vdout0_197ck1300 FIND v(dout0_197) AT=655.025n

.meas tran vdout0_198ck1300 FIND v(dout0_198) AT=655.025n

.meas tran vdout0_199ck1300 FIND v(dout0_199) AT=655.025n

.meas tran vdout0_200ck1300 FIND v(dout0_200) AT=655.025n

.meas tran vdout0_201ck1300 FIND v(dout0_201) AT=655.025n

.meas tran vdout0_202ck1300 FIND v(dout0_202) AT=655.025n

.meas tran vdout0_203ck1300 FIND v(dout0_203) AT=655.025n

.meas tran vdout0_204ck1300 FIND v(dout0_204) AT=655.025n

.meas tran vdout0_205ck1300 FIND v(dout0_205) AT=655.025n

.meas tran vdout0_206ck1300 FIND v(dout0_206) AT=655.025n

.meas tran vdout0_207ck1300 FIND v(dout0_207) AT=655.025n

.meas tran vdout0_208ck1300 FIND v(dout0_208) AT=655.025n

.meas tran vdout0_209ck1300 FIND v(dout0_209) AT=655.025n

.meas tran vdout0_210ck1300 FIND v(dout0_210) AT=655.025n

.meas tran vdout0_211ck1300 FIND v(dout0_211) AT=655.025n

.meas tran vdout0_212ck1300 FIND v(dout0_212) AT=655.025n

.meas tran vdout0_213ck1300 FIND v(dout0_213) AT=655.025n

.meas tran vdout0_214ck1300 FIND v(dout0_214) AT=655.025n

.meas tran vdout0_215ck1300 FIND v(dout0_215) AT=655.025n

.meas tran vdout0_216ck1300 FIND v(dout0_216) AT=655.025n

.meas tran vdout0_217ck1300 FIND v(dout0_217) AT=655.025n

.meas tran vdout0_218ck1300 FIND v(dout0_218) AT=655.025n

.meas tran vdout0_219ck1300 FIND v(dout0_219) AT=655.025n

.meas tran vdout0_220ck1300 FIND v(dout0_220) AT=655.025n

.meas tran vdout0_221ck1300 FIND v(dout0_221) AT=655.025n

.meas tran vdout0_222ck1300 FIND v(dout0_222) AT=655.025n

.meas tran vdout0_223ck1300 FIND v(dout0_223) AT=655.025n

.meas tran vdout0_224ck1300 FIND v(dout0_224) AT=655.025n

.meas tran vdout0_225ck1300 FIND v(dout0_225) AT=655.025n

.meas tran vdout0_226ck1300 FIND v(dout0_226) AT=655.025n

.meas tran vdout0_227ck1300 FIND v(dout0_227) AT=655.025n

.meas tran vdout0_228ck1300 FIND v(dout0_228) AT=655.025n

.meas tran vdout0_229ck1300 FIND v(dout0_229) AT=655.025n

.meas tran vdout0_230ck1300 FIND v(dout0_230) AT=655.025n

.meas tran vdout0_231ck1300 FIND v(dout0_231) AT=655.025n

.meas tran vdout0_232ck1300 FIND v(dout0_232) AT=655.025n

.meas tran vdout0_233ck1300 FIND v(dout0_233) AT=655.025n

.meas tran vdout0_234ck1300 FIND v(dout0_234) AT=655.025n

.meas tran vdout0_235ck1300 FIND v(dout0_235) AT=655.025n

.meas tran vdout0_236ck1300 FIND v(dout0_236) AT=655.025n

.meas tran vdout0_237ck1300 FIND v(dout0_237) AT=655.025n

.meas tran vdout0_238ck1300 FIND v(dout0_238) AT=655.025n

.meas tran vdout0_239ck1300 FIND v(dout0_239) AT=655.025n

.meas tran vdout0_240ck1300 FIND v(dout0_240) AT=655.025n

.meas tran vdout0_241ck1300 FIND v(dout0_241) AT=655.025n

.meas tran vdout0_242ck1300 FIND v(dout0_242) AT=655.025n

.meas tran vdout0_243ck1300 FIND v(dout0_243) AT=655.025n

.meas tran vdout0_244ck1300 FIND v(dout0_244) AT=655.025n

.meas tran vdout0_245ck1300 FIND v(dout0_245) AT=655.025n

.meas tran vdout0_246ck1300 FIND v(dout0_246) AT=655.025n

.meas tran vdout0_247ck1300 FIND v(dout0_247) AT=655.025n

.meas tran vdout0_248ck1300 FIND v(dout0_248) AT=655.025n

.meas tran vdout0_249ck1300 FIND v(dout0_249) AT=655.025n

.meas tran vdout0_250ck1300 FIND v(dout0_250) AT=655.025n

.meas tran vdout0_251ck1300 FIND v(dout0_251) AT=655.025n

.meas tran vdout0_252ck1300 FIND v(dout0_252) AT=655.025n

.meas tran vdout0_253ck1300 FIND v(dout0_253) AT=655.025n

.meas tran vdout0_254ck1300 FIND v(dout0_254) AT=655.025n

.meas tran vdout0_255ck1300 FIND v(dout0_255) AT=655.025n

.meas tran vdout0_0ck1310 FIND v(dout0_0) AT=660.025n

.meas tran vdout0_1ck1310 FIND v(dout0_1) AT=660.025n

.meas tran vdout0_2ck1310 FIND v(dout0_2) AT=660.025n

.meas tran vdout0_3ck1310 FIND v(dout0_3) AT=660.025n

.meas tran vdout0_4ck1310 FIND v(dout0_4) AT=660.025n

.meas tran vdout0_5ck1310 FIND v(dout0_5) AT=660.025n

.meas tran vdout0_6ck1310 FIND v(dout0_6) AT=660.025n

.meas tran vdout0_7ck1310 FIND v(dout0_7) AT=660.025n

.meas tran vdout0_8ck1310 FIND v(dout0_8) AT=660.025n

.meas tran vdout0_9ck1310 FIND v(dout0_9) AT=660.025n

.meas tran vdout0_10ck1310 FIND v(dout0_10) AT=660.025n

.meas tran vdout0_11ck1310 FIND v(dout0_11) AT=660.025n

.meas tran vdout0_12ck1310 FIND v(dout0_12) AT=660.025n

.meas tran vdout0_13ck1310 FIND v(dout0_13) AT=660.025n

.meas tran vdout0_14ck1310 FIND v(dout0_14) AT=660.025n

.meas tran vdout0_15ck1310 FIND v(dout0_15) AT=660.025n

.meas tran vdout0_16ck1310 FIND v(dout0_16) AT=660.025n

.meas tran vdout0_17ck1310 FIND v(dout0_17) AT=660.025n

.meas tran vdout0_18ck1310 FIND v(dout0_18) AT=660.025n

.meas tran vdout0_19ck1310 FIND v(dout0_19) AT=660.025n

.meas tran vdout0_20ck1310 FIND v(dout0_20) AT=660.025n

.meas tran vdout0_21ck1310 FIND v(dout0_21) AT=660.025n

.meas tran vdout0_22ck1310 FIND v(dout0_22) AT=660.025n

.meas tran vdout0_23ck1310 FIND v(dout0_23) AT=660.025n

.meas tran vdout0_24ck1310 FIND v(dout0_24) AT=660.025n

.meas tran vdout0_25ck1310 FIND v(dout0_25) AT=660.025n

.meas tran vdout0_26ck1310 FIND v(dout0_26) AT=660.025n

.meas tran vdout0_27ck1310 FIND v(dout0_27) AT=660.025n

.meas tran vdout0_28ck1310 FIND v(dout0_28) AT=660.025n

.meas tran vdout0_29ck1310 FIND v(dout0_29) AT=660.025n

.meas tran vdout0_30ck1310 FIND v(dout0_30) AT=660.025n

.meas tran vdout0_31ck1310 FIND v(dout0_31) AT=660.025n

.meas tran vdout0_32ck1310 FIND v(dout0_32) AT=660.025n

.meas tran vdout0_33ck1310 FIND v(dout0_33) AT=660.025n

.meas tran vdout0_34ck1310 FIND v(dout0_34) AT=660.025n

.meas tran vdout0_35ck1310 FIND v(dout0_35) AT=660.025n

.meas tran vdout0_36ck1310 FIND v(dout0_36) AT=660.025n

.meas tran vdout0_37ck1310 FIND v(dout0_37) AT=660.025n

.meas tran vdout0_38ck1310 FIND v(dout0_38) AT=660.025n

.meas tran vdout0_39ck1310 FIND v(dout0_39) AT=660.025n

.meas tran vdout0_40ck1310 FIND v(dout0_40) AT=660.025n

.meas tran vdout0_41ck1310 FIND v(dout0_41) AT=660.025n

.meas tran vdout0_42ck1310 FIND v(dout0_42) AT=660.025n

.meas tran vdout0_43ck1310 FIND v(dout0_43) AT=660.025n

.meas tran vdout0_44ck1310 FIND v(dout0_44) AT=660.025n

.meas tran vdout0_45ck1310 FIND v(dout0_45) AT=660.025n

.meas tran vdout0_46ck1310 FIND v(dout0_46) AT=660.025n

.meas tran vdout0_47ck1310 FIND v(dout0_47) AT=660.025n

.meas tran vdout0_48ck1310 FIND v(dout0_48) AT=660.025n

.meas tran vdout0_49ck1310 FIND v(dout0_49) AT=660.025n

.meas tran vdout0_50ck1310 FIND v(dout0_50) AT=660.025n

.meas tran vdout0_51ck1310 FIND v(dout0_51) AT=660.025n

.meas tran vdout0_52ck1310 FIND v(dout0_52) AT=660.025n

.meas tran vdout0_53ck1310 FIND v(dout0_53) AT=660.025n

.meas tran vdout0_54ck1310 FIND v(dout0_54) AT=660.025n

.meas tran vdout0_55ck1310 FIND v(dout0_55) AT=660.025n

.meas tran vdout0_56ck1310 FIND v(dout0_56) AT=660.025n

.meas tran vdout0_57ck1310 FIND v(dout0_57) AT=660.025n

.meas tran vdout0_58ck1310 FIND v(dout0_58) AT=660.025n

.meas tran vdout0_59ck1310 FIND v(dout0_59) AT=660.025n

.meas tran vdout0_60ck1310 FIND v(dout0_60) AT=660.025n

.meas tran vdout0_61ck1310 FIND v(dout0_61) AT=660.025n

.meas tran vdout0_62ck1310 FIND v(dout0_62) AT=660.025n

.meas tran vdout0_63ck1310 FIND v(dout0_63) AT=660.025n

.meas tran vdout0_64ck1310 FIND v(dout0_64) AT=660.025n

.meas tran vdout0_65ck1310 FIND v(dout0_65) AT=660.025n

.meas tran vdout0_66ck1310 FIND v(dout0_66) AT=660.025n

.meas tran vdout0_67ck1310 FIND v(dout0_67) AT=660.025n

.meas tran vdout0_68ck1310 FIND v(dout0_68) AT=660.025n

.meas tran vdout0_69ck1310 FIND v(dout0_69) AT=660.025n

.meas tran vdout0_70ck1310 FIND v(dout0_70) AT=660.025n

.meas tran vdout0_71ck1310 FIND v(dout0_71) AT=660.025n

.meas tran vdout0_72ck1310 FIND v(dout0_72) AT=660.025n

.meas tran vdout0_73ck1310 FIND v(dout0_73) AT=660.025n

.meas tran vdout0_74ck1310 FIND v(dout0_74) AT=660.025n

.meas tran vdout0_75ck1310 FIND v(dout0_75) AT=660.025n

.meas tran vdout0_76ck1310 FIND v(dout0_76) AT=660.025n

.meas tran vdout0_77ck1310 FIND v(dout0_77) AT=660.025n

.meas tran vdout0_78ck1310 FIND v(dout0_78) AT=660.025n

.meas tran vdout0_79ck1310 FIND v(dout0_79) AT=660.025n

.meas tran vdout0_80ck1310 FIND v(dout0_80) AT=660.025n

.meas tran vdout0_81ck1310 FIND v(dout0_81) AT=660.025n

.meas tran vdout0_82ck1310 FIND v(dout0_82) AT=660.025n

.meas tran vdout0_83ck1310 FIND v(dout0_83) AT=660.025n

.meas tran vdout0_84ck1310 FIND v(dout0_84) AT=660.025n

.meas tran vdout0_85ck1310 FIND v(dout0_85) AT=660.025n

.meas tran vdout0_86ck1310 FIND v(dout0_86) AT=660.025n

.meas tran vdout0_87ck1310 FIND v(dout0_87) AT=660.025n

.meas tran vdout0_88ck1310 FIND v(dout0_88) AT=660.025n

.meas tran vdout0_89ck1310 FIND v(dout0_89) AT=660.025n

.meas tran vdout0_90ck1310 FIND v(dout0_90) AT=660.025n

.meas tran vdout0_91ck1310 FIND v(dout0_91) AT=660.025n

.meas tran vdout0_92ck1310 FIND v(dout0_92) AT=660.025n

.meas tran vdout0_93ck1310 FIND v(dout0_93) AT=660.025n

.meas tran vdout0_94ck1310 FIND v(dout0_94) AT=660.025n

.meas tran vdout0_95ck1310 FIND v(dout0_95) AT=660.025n

.meas tran vdout0_96ck1310 FIND v(dout0_96) AT=660.025n

.meas tran vdout0_97ck1310 FIND v(dout0_97) AT=660.025n

.meas tran vdout0_98ck1310 FIND v(dout0_98) AT=660.025n

.meas tran vdout0_99ck1310 FIND v(dout0_99) AT=660.025n

.meas tran vdout0_100ck1310 FIND v(dout0_100) AT=660.025n

.meas tran vdout0_101ck1310 FIND v(dout0_101) AT=660.025n

.meas tran vdout0_102ck1310 FIND v(dout0_102) AT=660.025n

.meas tran vdout0_103ck1310 FIND v(dout0_103) AT=660.025n

.meas tran vdout0_104ck1310 FIND v(dout0_104) AT=660.025n

.meas tran vdout0_105ck1310 FIND v(dout0_105) AT=660.025n

.meas tran vdout0_106ck1310 FIND v(dout0_106) AT=660.025n

.meas tran vdout0_107ck1310 FIND v(dout0_107) AT=660.025n

.meas tran vdout0_108ck1310 FIND v(dout0_108) AT=660.025n

.meas tran vdout0_109ck1310 FIND v(dout0_109) AT=660.025n

.meas tran vdout0_110ck1310 FIND v(dout0_110) AT=660.025n

.meas tran vdout0_111ck1310 FIND v(dout0_111) AT=660.025n

.meas tran vdout0_112ck1310 FIND v(dout0_112) AT=660.025n

.meas tran vdout0_113ck1310 FIND v(dout0_113) AT=660.025n

.meas tran vdout0_114ck1310 FIND v(dout0_114) AT=660.025n

.meas tran vdout0_115ck1310 FIND v(dout0_115) AT=660.025n

.meas tran vdout0_116ck1310 FIND v(dout0_116) AT=660.025n

.meas tran vdout0_117ck1310 FIND v(dout0_117) AT=660.025n

.meas tran vdout0_118ck1310 FIND v(dout0_118) AT=660.025n

.meas tran vdout0_119ck1310 FIND v(dout0_119) AT=660.025n

.meas tran vdout0_120ck1310 FIND v(dout0_120) AT=660.025n

.meas tran vdout0_121ck1310 FIND v(dout0_121) AT=660.025n

.meas tran vdout0_122ck1310 FIND v(dout0_122) AT=660.025n

.meas tran vdout0_123ck1310 FIND v(dout0_123) AT=660.025n

.meas tran vdout0_124ck1310 FIND v(dout0_124) AT=660.025n

.meas tran vdout0_125ck1310 FIND v(dout0_125) AT=660.025n

.meas tran vdout0_126ck1310 FIND v(dout0_126) AT=660.025n

.meas tran vdout0_127ck1310 FIND v(dout0_127) AT=660.025n

.meas tran vdout0_128ck1310 FIND v(dout0_128) AT=660.025n

.meas tran vdout0_129ck1310 FIND v(dout0_129) AT=660.025n

.meas tran vdout0_130ck1310 FIND v(dout0_130) AT=660.025n

.meas tran vdout0_131ck1310 FIND v(dout0_131) AT=660.025n

.meas tran vdout0_132ck1310 FIND v(dout0_132) AT=660.025n

.meas tran vdout0_133ck1310 FIND v(dout0_133) AT=660.025n

.meas tran vdout0_134ck1310 FIND v(dout0_134) AT=660.025n

.meas tran vdout0_135ck1310 FIND v(dout0_135) AT=660.025n

.meas tran vdout0_136ck1310 FIND v(dout0_136) AT=660.025n

.meas tran vdout0_137ck1310 FIND v(dout0_137) AT=660.025n

.meas tran vdout0_138ck1310 FIND v(dout0_138) AT=660.025n

.meas tran vdout0_139ck1310 FIND v(dout0_139) AT=660.025n

.meas tran vdout0_140ck1310 FIND v(dout0_140) AT=660.025n

.meas tran vdout0_141ck1310 FIND v(dout0_141) AT=660.025n

.meas tran vdout0_142ck1310 FIND v(dout0_142) AT=660.025n

.meas tran vdout0_143ck1310 FIND v(dout0_143) AT=660.025n

.meas tran vdout0_144ck1310 FIND v(dout0_144) AT=660.025n

.meas tran vdout0_145ck1310 FIND v(dout0_145) AT=660.025n

.meas tran vdout0_146ck1310 FIND v(dout0_146) AT=660.025n

.meas tran vdout0_147ck1310 FIND v(dout0_147) AT=660.025n

.meas tran vdout0_148ck1310 FIND v(dout0_148) AT=660.025n

.meas tran vdout0_149ck1310 FIND v(dout0_149) AT=660.025n

.meas tran vdout0_150ck1310 FIND v(dout0_150) AT=660.025n

.meas tran vdout0_151ck1310 FIND v(dout0_151) AT=660.025n

.meas tran vdout0_152ck1310 FIND v(dout0_152) AT=660.025n

.meas tran vdout0_153ck1310 FIND v(dout0_153) AT=660.025n

.meas tran vdout0_154ck1310 FIND v(dout0_154) AT=660.025n

.meas tran vdout0_155ck1310 FIND v(dout0_155) AT=660.025n

.meas tran vdout0_156ck1310 FIND v(dout0_156) AT=660.025n

.meas tran vdout0_157ck1310 FIND v(dout0_157) AT=660.025n

.meas tran vdout0_158ck1310 FIND v(dout0_158) AT=660.025n

.meas tran vdout0_159ck1310 FIND v(dout0_159) AT=660.025n

.meas tran vdout0_160ck1310 FIND v(dout0_160) AT=660.025n

.meas tran vdout0_161ck1310 FIND v(dout0_161) AT=660.025n

.meas tran vdout0_162ck1310 FIND v(dout0_162) AT=660.025n

.meas tran vdout0_163ck1310 FIND v(dout0_163) AT=660.025n

.meas tran vdout0_164ck1310 FIND v(dout0_164) AT=660.025n

.meas tran vdout0_165ck1310 FIND v(dout0_165) AT=660.025n

.meas tran vdout0_166ck1310 FIND v(dout0_166) AT=660.025n

.meas tran vdout0_167ck1310 FIND v(dout0_167) AT=660.025n

.meas tran vdout0_168ck1310 FIND v(dout0_168) AT=660.025n

.meas tran vdout0_169ck1310 FIND v(dout0_169) AT=660.025n

.meas tran vdout0_170ck1310 FIND v(dout0_170) AT=660.025n

.meas tran vdout0_171ck1310 FIND v(dout0_171) AT=660.025n

.meas tran vdout0_172ck1310 FIND v(dout0_172) AT=660.025n

.meas tran vdout0_173ck1310 FIND v(dout0_173) AT=660.025n

.meas tran vdout0_174ck1310 FIND v(dout0_174) AT=660.025n

.meas tran vdout0_175ck1310 FIND v(dout0_175) AT=660.025n

.meas tran vdout0_176ck1310 FIND v(dout0_176) AT=660.025n

.meas tran vdout0_177ck1310 FIND v(dout0_177) AT=660.025n

.meas tran vdout0_178ck1310 FIND v(dout0_178) AT=660.025n

.meas tran vdout0_179ck1310 FIND v(dout0_179) AT=660.025n

.meas tran vdout0_180ck1310 FIND v(dout0_180) AT=660.025n

.meas tran vdout0_181ck1310 FIND v(dout0_181) AT=660.025n

.meas tran vdout0_182ck1310 FIND v(dout0_182) AT=660.025n

.meas tran vdout0_183ck1310 FIND v(dout0_183) AT=660.025n

.meas tran vdout0_184ck1310 FIND v(dout0_184) AT=660.025n

.meas tran vdout0_185ck1310 FIND v(dout0_185) AT=660.025n

.meas tran vdout0_186ck1310 FIND v(dout0_186) AT=660.025n

.meas tran vdout0_187ck1310 FIND v(dout0_187) AT=660.025n

.meas tran vdout0_188ck1310 FIND v(dout0_188) AT=660.025n

.meas tran vdout0_189ck1310 FIND v(dout0_189) AT=660.025n

.meas tran vdout0_190ck1310 FIND v(dout0_190) AT=660.025n

.meas tran vdout0_191ck1310 FIND v(dout0_191) AT=660.025n

.meas tran vdout0_192ck1310 FIND v(dout0_192) AT=660.025n

.meas tran vdout0_193ck1310 FIND v(dout0_193) AT=660.025n

.meas tran vdout0_194ck1310 FIND v(dout0_194) AT=660.025n

.meas tran vdout0_195ck1310 FIND v(dout0_195) AT=660.025n

.meas tran vdout0_196ck1310 FIND v(dout0_196) AT=660.025n

.meas tran vdout0_197ck1310 FIND v(dout0_197) AT=660.025n

.meas tran vdout0_198ck1310 FIND v(dout0_198) AT=660.025n

.meas tran vdout0_199ck1310 FIND v(dout0_199) AT=660.025n

.meas tran vdout0_200ck1310 FIND v(dout0_200) AT=660.025n

.meas tran vdout0_201ck1310 FIND v(dout0_201) AT=660.025n

.meas tran vdout0_202ck1310 FIND v(dout0_202) AT=660.025n

.meas tran vdout0_203ck1310 FIND v(dout0_203) AT=660.025n

.meas tran vdout0_204ck1310 FIND v(dout0_204) AT=660.025n

.meas tran vdout0_205ck1310 FIND v(dout0_205) AT=660.025n

.meas tran vdout0_206ck1310 FIND v(dout0_206) AT=660.025n

.meas tran vdout0_207ck1310 FIND v(dout0_207) AT=660.025n

.meas tran vdout0_208ck1310 FIND v(dout0_208) AT=660.025n

.meas tran vdout0_209ck1310 FIND v(dout0_209) AT=660.025n

.meas tran vdout0_210ck1310 FIND v(dout0_210) AT=660.025n

.meas tran vdout0_211ck1310 FIND v(dout0_211) AT=660.025n

.meas tran vdout0_212ck1310 FIND v(dout0_212) AT=660.025n

.meas tran vdout0_213ck1310 FIND v(dout0_213) AT=660.025n

.meas tran vdout0_214ck1310 FIND v(dout0_214) AT=660.025n

.meas tran vdout0_215ck1310 FIND v(dout0_215) AT=660.025n

.meas tran vdout0_216ck1310 FIND v(dout0_216) AT=660.025n

.meas tran vdout0_217ck1310 FIND v(dout0_217) AT=660.025n

.meas tran vdout0_218ck1310 FIND v(dout0_218) AT=660.025n

.meas tran vdout0_219ck1310 FIND v(dout0_219) AT=660.025n

.meas tran vdout0_220ck1310 FIND v(dout0_220) AT=660.025n

.meas tran vdout0_221ck1310 FIND v(dout0_221) AT=660.025n

.meas tran vdout0_222ck1310 FIND v(dout0_222) AT=660.025n

.meas tran vdout0_223ck1310 FIND v(dout0_223) AT=660.025n

.meas tran vdout0_224ck1310 FIND v(dout0_224) AT=660.025n

.meas tran vdout0_225ck1310 FIND v(dout0_225) AT=660.025n

.meas tran vdout0_226ck1310 FIND v(dout0_226) AT=660.025n

.meas tran vdout0_227ck1310 FIND v(dout0_227) AT=660.025n

.meas tran vdout0_228ck1310 FIND v(dout0_228) AT=660.025n

.meas tran vdout0_229ck1310 FIND v(dout0_229) AT=660.025n

.meas tran vdout0_230ck1310 FIND v(dout0_230) AT=660.025n

.meas tran vdout0_231ck1310 FIND v(dout0_231) AT=660.025n

.meas tran vdout0_232ck1310 FIND v(dout0_232) AT=660.025n

.meas tran vdout0_233ck1310 FIND v(dout0_233) AT=660.025n

.meas tran vdout0_234ck1310 FIND v(dout0_234) AT=660.025n

.meas tran vdout0_235ck1310 FIND v(dout0_235) AT=660.025n

.meas tran vdout0_236ck1310 FIND v(dout0_236) AT=660.025n

.meas tran vdout0_237ck1310 FIND v(dout0_237) AT=660.025n

.meas tran vdout0_238ck1310 FIND v(dout0_238) AT=660.025n

.meas tran vdout0_239ck1310 FIND v(dout0_239) AT=660.025n

.meas tran vdout0_240ck1310 FIND v(dout0_240) AT=660.025n

.meas tran vdout0_241ck1310 FIND v(dout0_241) AT=660.025n

.meas tran vdout0_242ck1310 FIND v(dout0_242) AT=660.025n

.meas tran vdout0_243ck1310 FIND v(dout0_243) AT=660.025n

.meas tran vdout0_244ck1310 FIND v(dout0_244) AT=660.025n

.meas tran vdout0_245ck1310 FIND v(dout0_245) AT=660.025n

.meas tran vdout0_246ck1310 FIND v(dout0_246) AT=660.025n

.meas tran vdout0_247ck1310 FIND v(dout0_247) AT=660.025n

.meas tran vdout0_248ck1310 FIND v(dout0_248) AT=660.025n

.meas tran vdout0_249ck1310 FIND v(dout0_249) AT=660.025n

.meas tran vdout0_250ck1310 FIND v(dout0_250) AT=660.025n

.meas tran vdout0_251ck1310 FIND v(dout0_251) AT=660.025n

.meas tran vdout0_252ck1310 FIND v(dout0_252) AT=660.025n

.meas tran vdout0_253ck1310 FIND v(dout0_253) AT=660.025n

.meas tran vdout0_254ck1310 FIND v(dout0_254) AT=660.025n

.meas tran vdout0_255ck1310 FIND v(dout0_255) AT=660.025n

.meas tran vdout0_0ck1330 FIND v(dout0_0) AT=670.025n

.meas tran vdout0_1ck1330 FIND v(dout0_1) AT=670.025n

.meas tran vdout0_2ck1330 FIND v(dout0_2) AT=670.025n

.meas tran vdout0_3ck1330 FIND v(dout0_3) AT=670.025n

.meas tran vdout0_4ck1330 FIND v(dout0_4) AT=670.025n

.meas tran vdout0_5ck1330 FIND v(dout0_5) AT=670.025n

.meas tran vdout0_6ck1330 FIND v(dout0_6) AT=670.025n

.meas tran vdout0_7ck1330 FIND v(dout0_7) AT=670.025n

.meas tran vdout0_8ck1330 FIND v(dout0_8) AT=670.025n

.meas tran vdout0_9ck1330 FIND v(dout0_9) AT=670.025n

.meas tran vdout0_10ck1330 FIND v(dout0_10) AT=670.025n

.meas tran vdout0_11ck1330 FIND v(dout0_11) AT=670.025n

.meas tran vdout0_12ck1330 FIND v(dout0_12) AT=670.025n

.meas tran vdout0_13ck1330 FIND v(dout0_13) AT=670.025n

.meas tran vdout0_14ck1330 FIND v(dout0_14) AT=670.025n

.meas tran vdout0_15ck1330 FIND v(dout0_15) AT=670.025n

.meas tran vdout0_16ck1330 FIND v(dout0_16) AT=670.025n

.meas tran vdout0_17ck1330 FIND v(dout0_17) AT=670.025n

.meas tran vdout0_18ck1330 FIND v(dout0_18) AT=670.025n

.meas tran vdout0_19ck1330 FIND v(dout0_19) AT=670.025n

.meas tran vdout0_20ck1330 FIND v(dout0_20) AT=670.025n

.meas tran vdout0_21ck1330 FIND v(dout0_21) AT=670.025n

.meas tran vdout0_22ck1330 FIND v(dout0_22) AT=670.025n

.meas tran vdout0_23ck1330 FIND v(dout0_23) AT=670.025n

.meas tran vdout0_24ck1330 FIND v(dout0_24) AT=670.025n

.meas tran vdout0_25ck1330 FIND v(dout0_25) AT=670.025n

.meas tran vdout0_26ck1330 FIND v(dout0_26) AT=670.025n

.meas tran vdout0_27ck1330 FIND v(dout0_27) AT=670.025n

.meas tran vdout0_28ck1330 FIND v(dout0_28) AT=670.025n

.meas tran vdout0_29ck1330 FIND v(dout0_29) AT=670.025n

.meas tran vdout0_30ck1330 FIND v(dout0_30) AT=670.025n

.meas tran vdout0_31ck1330 FIND v(dout0_31) AT=670.025n

.meas tran vdout0_32ck1330 FIND v(dout0_32) AT=670.025n

.meas tran vdout0_33ck1330 FIND v(dout0_33) AT=670.025n

.meas tran vdout0_34ck1330 FIND v(dout0_34) AT=670.025n

.meas tran vdout0_35ck1330 FIND v(dout0_35) AT=670.025n

.meas tran vdout0_36ck1330 FIND v(dout0_36) AT=670.025n

.meas tran vdout0_37ck1330 FIND v(dout0_37) AT=670.025n

.meas tran vdout0_38ck1330 FIND v(dout0_38) AT=670.025n

.meas tran vdout0_39ck1330 FIND v(dout0_39) AT=670.025n

.meas tran vdout0_40ck1330 FIND v(dout0_40) AT=670.025n

.meas tran vdout0_41ck1330 FIND v(dout0_41) AT=670.025n

.meas tran vdout0_42ck1330 FIND v(dout0_42) AT=670.025n

.meas tran vdout0_43ck1330 FIND v(dout0_43) AT=670.025n

.meas tran vdout0_44ck1330 FIND v(dout0_44) AT=670.025n

.meas tran vdout0_45ck1330 FIND v(dout0_45) AT=670.025n

.meas tran vdout0_46ck1330 FIND v(dout0_46) AT=670.025n

.meas tran vdout0_47ck1330 FIND v(dout0_47) AT=670.025n

.meas tran vdout0_48ck1330 FIND v(dout0_48) AT=670.025n

.meas tran vdout0_49ck1330 FIND v(dout0_49) AT=670.025n

.meas tran vdout0_50ck1330 FIND v(dout0_50) AT=670.025n

.meas tran vdout0_51ck1330 FIND v(dout0_51) AT=670.025n

.meas tran vdout0_52ck1330 FIND v(dout0_52) AT=670.025n

.meas tran vdout0_53ck1330 FIND v(dout0_53) AT=670.025n

.meas tran vdout0_54ck1330 FIND v(dout0_54) AT=670.025n

.meas tran vdout0_55ck1330 FIND v(dout0_55) AT=670.025n

.meas tran vdout0_56ck1330 FIND v(dout0_56) AT=670.025n

.meas tran vdout0_57ck1330 FIND v(dout0_57) AT=670.025n

.meas tran vdout0_58ck1330 FIND v(dout0_58) AT=670.025n

.meas tran vdout0_59ck1330 FIND v(dout0_59) AT=670.025n

.meas tran vdout0_60ck1330 FIND v(dout0_60) AT=670.025n

.meas tran vdout0_61ck1330 FIND v(dout0_61) AT=670.025n

.meas tran vdout0_62ck1330 FIND v(dout0_62) AT=670.025n

.meas tran vdout0_63ck1330 FIND v(dout0_63) AT=670.025n

.meas tran vdout0_64ck1330 FIND v(dout0_64) AT=670.025n

.meas tran vdout0_65ck1330 FIND v(dout0_65) AT=670.025n

.meas tran vdout0_66ck1330 FIND v(dout0_66) AT=670.025n

.meas tran vdout0_67ck1330 FIND v(dout0_67) AT=670.025n

.meas tran vdout0_68ck1330 FIND v(dout0_68) AT=670.025n

.meas tran vdout0_69ck1330 FIND v(dout0_69) AT=670.025n

.meas tran vdout0_70ck1330 FIND v(dout0_70) AT=670.025n

.meas tran vdout0_71ck1330 FIND v(dout0_71) AT=670.025n

.meas tran vdout0_72ck1330 FIND v(dout0_72) AT=670.025n

.meas tran vdout0_73ck1330 FIND v(dout0_73) AT=670.025n

.meas tran vdout0_74ck1330 FIND v(dout0_74) AT=670.025n

.meas tran vdout0_75ck1330 FIND v(dout0_75) AT=670.025n

.meas tran vdout0_76ck1330 FIND v(dout0_76) AT=670.025n

.meas tran vdout0_77ck1330 FIND v(dout0_77) AT=670.025n

.meas tran vdout0_78ck1330 FIND v(dout0_78) AT=670.025n

.meas tran vdout0_79ck1330 FIND v(dout0_79) AT=670.025n

.meas tran vdout0_80ck1330 FIND v(dout0_80) AT=670.025n

.meas tran vdout0_81ck1330 FIND v(dout0_81) AT=670.025n

.meas tran vdout0_82ck1330 FIND v(dout0_82) AT=670.025n

.meas tran vdout0_83ck1330 FIND v(dout0_83) AT=670.025n

.meas tran vdout0_84ck1330 FIND v(dout0_84) AT=670.025n

.meas tran vdout0_85ck1330 FIND v(dout0_85) AT=670.025n

.meas tran vdout0_86ck1330 FIND v(dout0_86) AT=670.025n

.meas tran vdout0_87ck1330 FIND v(dout0_87) AT=670.025n

.meas tran vdout0_88ck1330 FIND v(dout0_88) AT=670.025n

.meas tran vdout0_89ck1330 FIND v(dout0_89) AT=670.025n

.meas tran vdout0_90ck1330 FIND v(dout0_90) AT=670.025n

.meas tran vdout0_91ck1330 FIND v(dout0_91) AT=670.025n

.meas tran vdout0_92ck1330 FIND v(dout0_92) AT=670.025n

.meas tran vdout0_93ck1330 FIND v(dout0_93) AT=670.025n

.meas tran vdout0_94ck1330 FIND v(dout0_94) AT=670.025n

.meas tran vdout0_95ck1330 FIND v(dout0_95) AT=670.025n

.meas tran vdout0_96ck1330 FIND v(dout0_96) AT=670.025n

.meas tran vdout0_97ck1330 FIND v(dout0_97) AT=670.025n

.meas tran vdout0_98ck1330 FIND v(dout0_98) AT=670.025n

.meas tran vdout0_99ck1330 FIND v(dout0_99) AT=670.025n

.meas tran vdout0_100ck1330 FIND v(dout0_100) AT=670.025n

.meas tran vdout0_101ck1330 FIND v(dout0_101) AT=670.025n

.meas tran vdout0_102ck1330 FIND v(dout0_102) AT=670.025n

.meas tran vdout0_103ck1330 FIND v(dout0_103) AT=670.025n

.meas tran vdout0_104ck1330 FIND v(dout0_104) AT=670.025n

.meas tran vdout0_105ck1330 FIND v(dout0_105) AT=670.025n

.meas tran vdout0_106ck1330 FIND v(dout0_106) AT=670.025n

.meas tran vdout0_107ck1330 FIND v(dout0_107) AT=670.025n

.meas tran vdout0_108ck1330 FIND v(dout0_108) AT=670.025n

.meas tran vdout0_109ck1330 FIND v(dout0_109) AT=670.025n

.meas tran vdout0_110ck1330 FIND v(dout0_110) AT=670.025n

.meas tran vdout0_111ck1330 FIND v(dout0_111) AT=670.025n

.meas tran vdout0_112ck1330 FIND v(dout0_112) AT=670.025n

.meas tran vdout0_113ck1330 FIND v(dout0_113) AT=670.025n

.meas tran vdout0_114ck1330 FIND v(dout0_114) AT=670.025n

.meas tran vdout0_115ck1330 FIND v(dout0_115) AT=670.025n

.meas tran vdout0_116ck1330 FIND v(dout0_116) AT=670.025n

.meas tran vdout0_117ck1330 FIND v(dout0_117) AT=670.025n

.meas tran vdout0_118ck1330 FIND v(dout0_118) AT=670.025n

.meas tran vdout0_119ck1330 FIND v(dout0_119) AT=670.025n

.meas tran vdout0_120ck1330 FIND v(dout0_120) AT=670.025n

.meas tran vdout0_121ck1330 FIND v(dout0_121) AT=670.025n

.meas tran vdout0_122ck1330 FIND v(dout0_122) AT=670.025n

.meas tran vdout0_123ck1330 FIND v(dout0_123) AT=670.025n

.meas tran vdout0_124ck1330 FIND v(dout0_124) AT=670.025n

.meas tran vdout0_125ck1330 FIND v(dout0_125) AT=670.025n

.meas tran vdout0_126ck1330 FIND v(dout0_126) AT=670.025n

.meas tran vdout0_127ck1330 FIND v(dout0_127) AT=670.025n

.meas tran vdout0_128ck1330 FIND v(dout0_128) AT=670.025n

.meas tran vdout0_129ck1330 FIND v(dout0_129) AT=670.025n

.meas tran vdout0_130ck1330 FIND v(dout0_130) AT=670.025n

.meas tran vdout0_131ck1330 FIND v(dout0_131) AT=670.025n

.meas tran vdout0_132ck1330 FIND v(dout0_132) AT=670.025n

.meas tran vdout0_133ck1330 FIND v(dout0_133) AT=670.025n

.meas tran vdout0_134ck1330 FIND v(dout0_134) AT=670.025n

.meas tran vdout0_135ck1330 FIND v(dout0_135) AT=670.025n

.meas tran vdout0_136ck1330 FIND v(dout0_136) AT=670.025n

.meas tran vdout0_137ck1330 FIND v(dout0_137) AT=670.025n

.meas tran vdout0_138ck1330 FIND v(dout0_138) AT=670.025n

.meas tran vdout0_139ck1330 FIND v(dout0_139) AT=670.025n

.meas tran vdout0_140ck1330 FIND v(dout0_140) AT=670.025n

.meas tran vdout0_141ck1330 FIND v(dout0_141) AT=670.025n

.meas tran vdout0_142ck1330 FIND v(dout0_142) AT=670.025n

.meas tran vdout0_143ck1330 FIND v(dout0_143) AT=670.025n

.meas tran vdout0_144ck1330 FIND v(dout0_144) AT=670.025n

.meas tran vdout0_145ck1330 FIND v(dout0_145) AT=670.025n

.meas tran vdout0_146ck1330 FIND v(dout0_146) AT=670.025n

.meas tran vdout0_147ck1330 FIND v(dout0_147) AT=670.025n

.meas tran vdout0_148ck1330 FIND v(dout0_148) AT=670.025n

.meas tran vdout0_149ck1330 FIND v(dout0_149) AT=670.025n

.meas tran vdout0_150ck1330 FIND v(dout0_150) AT=670.025n

.meas tran vdout0_151ck1330 FIND v(dout0_151) AT=670.025n

.meas tran vdout0_152ck1330 FIND v(dout0_152) AT=670.025n

.meas tran vdout0_153ck1330 FIND v(dout0_153) AT=670.025n

.meas tran vdout0_154ck1330 FIND v(dout0_154) AT=670.025n

.meas tran vdout0_155ck1330 FIND v(dout0_155) AT=670.025n

.meas tran vdout0_156ck1330 FIND v(dout0_156) AT=670.025n

.meas tran vdout0_157ck1330 FIND v(dout0_157) AT=670.025n

.meas tran vdout0_158ck1330 FIND v(dout0_158) AT=670.025n

.meas tran vdout0_159ck1330 FIND v(dout0_159) AT=670.025n

.meas tran vdout0_160ck1330 FIND v(dout0_160) AT=670.025n

.meas tran vdout0_161ck1330 FIND v(dout0_161) AT=670.025n

.meas tran vdout0_162ck1330 FIND v(dout0_162) AT=670.025n

.meas tran vdout0_163ck1330 FIND v(dout0_163) AT=670.025n

.meas tran vdout0_164ck1330 FIND v(dout0_164) AT=670.025n

.meas tran vdout0_165ck1330 FIND v(dout0_165) AT=670.025n

.meas tran vdout0_166ck1330 FIND v(dout0_166) AT=670.025n

.meas tran vdout0_167ck1330 FIND v(dout0_167) AT=670.025n

.meas tran vdout0_168ck1330 FIND v(dout0_168) AT=670.025n

.meas tran vdout0_169ck1330 FIND v(dout0_169) AT=670.025n

.meas tran vdout0_170ck1330 FIND v(dout0_170) AT=670.025n

.meas tran vdout0_171ck1330 FIND v(dout0_171) AT=670.025n

.meas tran vdout0_172ck1330 FIND v(dout0_172) AT=670.025n

.meas tran vdout0_173ck1330 FIND v(dout0_173) AT=670.025n

.meas tran vdout0_174ck1330 FIND v(dout0_174) AT=670.025n

.meas tran vdout0_175ck1330 FIND v(dout0_175) AT=670.025n

.meas tran vdout0_176ck1330 FIND v(dout0_176) AT=670.025n

.meas tran vdout0_177ck1330 FIND v(dout0_177) AT=670.025n

.meas tran vdout0_178ck1330 FIND v(dout0_178) AT=670.025n

.meas tran vdout0_179ck1330 FIND v(dout0_179) AT=670.025n

.meas tran vdout0_180ck1330 FIND v(dout0_180) AT=670.025n

.meas tran vdout0_181ck1330 FIND v(dout0_181) AT=670.025n

.meas tran vdout0_182ck1330 FIND v(dout0_182) AT=670.025n

.meas tran vdout0_183ck1330 FIND v(dout0_183) AT=670.025n

.meas tran vdout0_184ck1330 FIND v(dout0_184) AT=670.025n

.meas tran vdout0_185ck1330 FIND v(dout0_185) AT=670.025n

.meas tran vdout0_186ck1330 FIND v(dout0_186) AT=670.025n

.meas tran vdout0_187ck1330 FIND v(dout0_187) AT=670.025n

.meas tran vdout0_188ck1330 FIND v(dout0_188) AT=670.025n

.meas tran vdout0_189ck1330 FIND v(dout0_189) AT=670.025n

.meas tran vdout0_190ck1330 FIND v(dout0_190) AT=670.025n

.meas tran vdout0_191ck1330 FIND v(dout0_191) AT=670.025n

.meas tran vdout0_192ck1330 FIND v(dout0_192) AT=670.025n

.meas tran vdout0_193ck1330 FIND v(dout0_193) AT=670.025n

.meas tran vdout0_194ck1330 FIND v(dout0_194) AT=670.025n

.meas tran vdout0_195ck1330 FIND v(dout0_195) AT=670.025n

.meas tran vdout0_196ck1330 FIND v(dout0_196) AT=670.025n

.meas tran vdout0_197ck1330 FIND v(dout0_197) AT=670.025n

.meas tran vdout0_198ck1330 FIND v(dout0_198) AT=670.025n

.meas tran vdout0_199ck1330 FIND v(dout0_199) AT=670.025n

.meas tran vdout0_200ck1330 FIND v(dout0_200) AT=670.025n

.meas tran vdout0_201ck1330 FIND v(dout0_201) AT=670.025n

.meas tran vdout0_202ck1330 FIND v(dout0_202) AT=670.025n

.meas tran vdout0_203ck1330 FIND v(dout0_203) AT=670.025n

.meas tran vdout0_204ck1330 FIND v(dout0_204) AT=670.025n

.meas tran vdout0_205ck1330 FIND v(dout0_205) AT=670.025n

.meas tran vdout0_206ck1330 FIND v(dout0_206) AT=670.025n

.meas tran vdout0_207ck1330 FIND v(dout0_207) AT=670.025n

.meas tran vdout0_208ck1330 FIND v(dout0_208) AT=670.025n

.meas tran vdout0_209ck1330 FIND v(dout0_209) AT=670.025n

.meas tran vdout0_210ck1330 FIND v(dout0_210) AT=670.025n

.meas tran vdout0_211ck1330 FIND v(dout0_211) AT=670.025n

.meas tran vdout0_212ck1330 FIND v(dout0_212) AT=670.025n

.meas tran vdout0_213ck1330 FIND v(dout0_213) AT=670.025n

.meas tran vdout0_214ck1330 FIND v(dout0_214) AT=670.025n

.meas tran vdout0_215ck1330 FIND v(dout0_215) AT=670.025n

.meas tran vdout0_216ck1330 FIND v(dout0_216) AT=670.025n

.meas tran vdout0_217ck1330 FIND v(dout0_217) AT=670.025n

.meas tran vdout0_218ck1330 FIND v(dout0_218) AT=670.025n

.meas tran vdout0_219ck1330 FIND v(dout0_219) AT=670.025n

.meas tran vdout0_220ck1330 FIND v(dout0_220) AT=670.025n

.meas tran vdout0_221ck1330 FIND v(dout0_221) AT=670.025n

.meas tran vdout0_222ck1330 FIND v(dout0_222) AT=670.025n

.meas tran vdout0_223ck1330 FIND v(dout0_223) AT=670.025n

.meas tran vdout0_224ck1330 FIND v(dout0_224) AT=670.025n

.meas tran vdout0_225ck1330 FIND v(dout0_225) AT=670.025n

.meas tran vdout0_226ck1330 FIND v(dout0_226) AT=670.025n

.meas tran vdout0_227ck1330 FIND v(dout0_227) AT=670.025n

.meas tran vdout0_228ck1330 FIND v(dout0_228) AT=670.025n

.meas tran vdout0_229ck1330 FIND v(dout0_229) AT=670.025n

.meas tran vdout0_230ck1330 FIND v(dout0_230) AT=670.025n

.meas tran vdout0_231ck1330 FIND v(dout0_231) AT=670.025n

.meas tran vdout0_232ck1330 FIND v(dout0_232) AT=670.025n

.meas tran vdout0_233ck1330 FIND v(dout0_233) AT=670.025n

.meas tran vdout0_234ck1330 FIND v(dout0_234) AT=670.025n

.meas tran vdout0_235ck1330 FIND v(dout0_235) AT=670.025n

.meas tran vdout0_236ck1330 FIND v(dout0_236) AT=670.025n

.meas tran vdout0_237ck1330 FIND v(dout0_237) AT=670.025n

.meas tran vdout0_238ck1330 FIND v(dout0_238) AT=670.025n

.meas tran vdout0_239ck1330 FIND v(dout0_239) AT=670.025n

.meas tran vdout0_240ck1330 FIND v(dout0_240) AT=670.025n

.meas tran vdout0_241ck1330 FIND v(dout0_241) AT=670.025n

.meas tran vdout0_242ck1330 FIND v(dout0_242) AT=670.025n

.meas tran vdout0_243ck1330 FIND v(dout0_243) AT=670.025n

.meas tran vdout0_244ck1330 FIND v(dout0_244) AT=670.025n

.meas tran vdout0_245ck1330 FIND v(dout0_245) AT=670.025n

.meas tran vdout0_246ck1330 FIND v(dout0_246) AT=670.025n

.meas tran vdout0_247ck1330 FIND v(dout0_247) AT=670.025n

.meas tran vdout0_248ck1330 FIND v(dout0_248) AT=670.025n

.meas tran vdout0_249ck1330 FIND v(dout0_249) AT=670.025n

.meas tran vdout0_250ck1330 FIND v(dout0_250) AT=670.025n

.meas tran vdout0_251ck1330 FIND v(dout0_251) AT=670.025n

.meas tran vdout0_252ck1330 FIND v(dout0_252) AT=670.025n

.meas tran vdout0_253ck1330 FIND v(dout0_253) AT=670.025n

.meas tran vdout0_254ck1330 FIND v(dout0_254) AT=670.025n

.meas tran vdout0_255ck1330 FIND v(dout0_255) AT=670.025n

.meas tran vdout0_0ck1350 FIND v(dout0_0) AT=680.025n

.meas tran vdout0_1ck1350 FIND v(dout0_1) AT=680.025n

.meas tran vdout0_2ck1350 FIND v(dout0_2) AT=680.025n

.meas tran vdout0_3ck1350 FIND v(dout0_3) AT=680.025n

.meas tran vdout0_4ck1350 FIND v(dout0_4) AT=680.025n

.meas tran vdout0_5ck1350 FIND v(dout0_5) AT=680.025n

.meas tran vdout0_6ck1350 FIND v(dout0_6) AT=680.025n

.meas tran vdout0_7ck1350 FIND v(dout0_7) AT=680.025n

.meas tran vdout0_8ck1350 FIND v(dout0_8) AT=680.025n

.meas tran vdout0_9ck1350 FIND v(dout0_9) AT=680.025n

.meas tran vdout0_10ck1350 FIND v(dout0_10) AT=680.025n

.meas tran vdout0_11ck1350 FIND v(dout0_11) AT=680.025n

.meas tran vdout0_12ck1350 FIND v(dout0_12) AT=680.025n

.meas tran vdout0_13ck1350 FIND v(dout0_13) AT=680.025n

.meas tran vdout0_14ck1350 FIND v(dout0_14) AT=680.025n

.meas tran vdout0_15ck1350 FIND v(dout0_15) AT=680.025n

.meas tran vdout0_16ck1350 FIND v(dout0_16) AT=680.025n

.meas tran vdout0_17ck1350 FIND v(dout0_17) AT=680.025n

.meas tran vdout0_18ck1350 FIND v(dout0_18) AT=680.025n

.meas tran vdout0_19ck1350 FIND v(dout0_19) AT=680.025n

.meas tran vdout0_20ck1350 FIND v(dout0_20) AT=680.025n

.meas tran vdout0_21ck1350 FIND v(dout0_21) AT=680.025n

.meas tran vdout0_22ck1350 FIND v(dout0_22) AT=680.025n

.meas tran vdout0_23ck1350 FIND v(dout0_23) AT=680.025n

.meas tran vdout0_24ck1350 FIND v(dout0_24) AT=680.025n

.meas tran vdout0_25ck1350 FIND v(dout0_25) AT=680.025n

.meas tran vdout0_26ck1350 FIND v(dout0_26) AT=680.025n

.meas tran vdout0_27ck1350 FIND v(dout0_27) AT=680.025n

.meas tran vdout0_28ck1350 FIND v(dout0_28) AT=680.025n

.meas tran vdout0_29ck1350 FIND v(dout0_29) AT=680.025n

.meas tran vdout0_30ck1350 FIND v(dout0_30) AT=680.025n

.meas tran vdout0_31ck1350 FIND v(dout0_31) AT=680.025n

.meas tran vdout0_32ck1350 FIND v(dout0_32) AT=680.025n

.meas tran vdout0_33ck1350 FIND v(dout0_33) AT=680.025n

.meas tran vdout0_34ck1350 FIND v(dout0_34) AT=680.025n

.meas tran vdout0_35ck1350 FIND v(dout0_35) AT=680.025n

.meas tran vdout0_36ck1350 FIND v(dout0_36) AT=680.025n

.meas tran vdout0_37ck1350 FIND v(dout0_37) AT=680.025n

.meas tran vdout0_38ck1350 FIND v(dout0_38) AT=680.025n

.meas tran vdout0_39ck1350 FIND v(dout0_39) AT=680.025n

.meas tran vdout0_40ck1350 FIND v(dout0_40) AT=680.025n

.meas tran vdout0_41ck1350 FIND v(dout0_41) AT=680.025n

.meas tran vdout0_42ck1350 FIND v(dout0_42) AT=680.025n

.meas tran vdout0_43ck1350 FIND v(dout0_43) AT=680.025n

.meas tran vdout0_44ck1350 FIND v(dout0_44) AT=680.025n

.meas tran vdout0_45ck1350 FIND v(dout0_45) AT=680.025n

.meas tran vdout0_46ck1350 FIND v(dout0_46) AT=680.025n

.meas tran vdout0_47ck1350 FIND v(dout0_47) AT=680.025n

.meas tran vdout0_48ck1350 FIND v(dout0_48) AT=680.025n

.meas tran vdout0_49ck1350 FIND v(dout0_49) AT=680.025n

.meas tran vdout0_50ck1350 FIND v(dout0_50) AT=680.025n

.meas tran vdout0_51ck1350 FIND v(dout0_51) AT=680.025n

.meas tran vdout0_52ck1350 FIND v(dout0_52) AT=680.025n

.meas tran vdout0_53ck1350 FIND v(dout0_53) AT=680.025n

.meas tran vdout0_54ck1350 FIND v(dout0_54) AT=680.025n

.meas tran vdout0_55ck1350 FIND v(dout0_55) AT=680.025n

.meas tran vdout0_56ck1350 FIND v(dout0_56) AT=680.025n

.meas tran vdout0_57ck1350 FIND v(dout0_57) AT=680.025n

.meas tran vdout0_58ck1350 FIND v(dout0_58) AT=680.025n

.meas tran vdout0_59ck1350 FIND v(dout0_59) AT=680.025n

.meas tran vdout0_60ck1350 FIND v(dout0_60) AT=680.025n

.meas tran vdout0_61ck1350 FIND v(dout0_61) AT=680.025n

.meas tran vdout0_62ck1350 FIND v(dout0_62) AT=680.025n

.meas tran vdout0_63ck1350 FIND v(dout0_63) AT=680.025n

.meas tran vdout0_64ck1350 FIND v(dout0_64) AT=680.025n

.meas tran vdout0_65ck1350 FIND v(dout0_65) AT=680.025n

.meas tran vdout0_66ck1350 FIND v(dout0_66) AT=680.025n

.meas tran vdout0_67ck1350 FIND v(dout0_67) AT=680.025n

.meas tran vdout0_68ck1350 FIND v(dout0_68) AT=680.025n

.meas tran vdout0_69ck1350 FIND v(dout0_69) AT=680.025n

.meas tran vdout0_70ck1350 FIND v(dout0_70) AT=680.025n

.meas tran vdout0_71ck1350 FIND v(dout0_71) AT=680.025n

.meas tran vdout0_72ck1350 FIND v(dout0_72) AT=680.025n

.meas tran vdout0_73ck1350 FIND v(dout0_73) AT=680.025n

.meas tran vdout0_74ck1350 FIND v(dout0_74) AT=680.025n

.meas tran vdout0_75ck1350 FIND v(dout0_75) AT=680.025n

.meas tran vdout0_76ck1350 FIND v(dout0_76) AT=680.025n

.meas tran vdout0_77ck1350 FIND v(dout0_77) AT=680.025n

.meas tran vdout0_78ck1350 FIND v(dout0_78) AT=680.025n

.meas tran vdout0_79ck1350 FIND v(dout0_79) AT=680.025n

.meas tran vdout0_80ck1350 FIND v(dout0_80) AT=680.025n

.meas tran vdout0_81ck1350 FIND v(dout0_81) AT=680.025n

.meas tran vdout0_82ck1350 FIND v(dout0_82) AT=680.025n

.meas tran vdout0_83ck1350 FIND v(dout0_83) AT=680.025n

.meas tran vdout0_84ck1350 FIND v(dout0_84) AT=680.025n

.meas tran vdout0_85ck1350 FIND v(dout0_85) AT=680.025n

.meas tran vdout0_86ck1350 FIND v(dout0_86) AT=680.025n

.meas tran vdout0_87ck1350 FIND v(dout0_87) AT=680.025n

.meas tran vdout0_88ck1350 FIND v(dout0_88) AT=680.025n

.meas tran vdout0_89ck1350 FIND v(dout0_89) AT=680.025n

.meas tran vdout0_90ck1350 FIND v(dout0_90) AT=680.025n

.meas tran vdout0_91ck1350 FIND v(dout0_91) AT=680.025n

.meas tran vdout0_92ck1350 FIND v(dout0_92) AT=680.025n

.meas tran vdout0_93ck1350 FIND v(dout0_93) AT=680.025n

.meas tran vdout0_94ck1350 FIND v(dout0_94) AT=680.025n

.meas tran vdout0_95ck1350 FIND v(dout0_95) AT=680.025n

.meas tran vdout0_96ck1350 FIND v(dout0_96) AT=680.025n

.meas tran vdout0_97ck1350 FIND v(dout0_97) AT=680.025n

.meas tran vdout0_98ck1350 FIND v(dout0_98) AT=680.025n

.meas tran vdout0_99ck1350 FIND v(dout0_99) AT=680.025n

.meas tran vdout0_100ck1350 FIND v(dout0_100) AT=680.025n

.meas tran vdout0_101ck1350 FIND v(dout0_101) AT=680.025n

.meas tran vdout0_102ck1350 FIND v(dout0_102) AT=680.025n

.meas tran vdout0_103ck1350 FIND v(dout0_103) AT=680.025n

.meas tran vdout0_104ck1350 FIND v(dout0_104) AT=680.025n

.meas tran vdout0_105ck1350 FIND v(dout0_105) AT=680.025n

.meas tran vdout0_106ck1350 FIND v(dout0_106) AT=680.025n

.meas tran vdout0_107ck1350 FIND v(dout0_107) AT=680.025n

.meas tran vdout0_108ck1350 FIND v(dout0_108) AT=680.025n

.meas tran vdout0_109ck1350 FIND v(dout0_109) AT=680.025n

.meas tran vdout0_110ck1350 FIND v(dout0_110) AT=680.025n

.meas tran vdout0_111ck1350 FIND v(dout0_111) AT=680.025n

.meas tran vdout0_112ck1350 FIND v(dout0_112) AT=680.025n

.meas tran vdout0_113ck1350 FIND v(dout0_113) AT=680.025n

.meas tran vdout0_114ck1350 FIND v(dout0_114) AT=680.025n

.meas tran vdout0_115ck1350 FIND v(dout0_115) AT=680.025n

.meas tran vdout0_116ck1350 FIND v(dout0_116) AT=680.025n

.meas tran vdout0_117ck1350 FIND v(dout0_117) AT=680.025n

.meas tran vdout0_118ck1350 FIND v(dout0_118) AT=680.025n

.meas tran vdout0_119ck1350 FIND v(dout0_119) AT=680.025n

.meas tran vdout0_120ck1350 FIND v(dout0_120) AT=680.025n

.meas tran vdout0_121ck1350 FIND v(dout0_121) AT=680.025n

.meas tran vdout0_122ck1350 FIND v(dout0_122) AT=680.025n

.meas tran vdout0_123ck1350 FIND v(dout0_123) AT=680.025n

.meas tran vdout0_124ck1350 FIND v(dout0_124) AT=680.025n

.meas tran vdout0_125ck1350 FIND v(dout0_125) AT=680.025n

.meas tran vdout0_126ck1350 FIND v(dout0_126) AT=680.025n

.meas tran vdout0_127ck1350 FIND v(dout0_127) AT=680.025n

.meas tran vdout0_128ck1350 FIND v(dout0_128) AT=680.025n

.meas tran vdout0_129ck1350 FIND v(dout0_129) AT=680.025n

.meas tran vdout0_130ck1350 FIND v(dout0_130) AT=680.025n

.meas tran vdout0_131ck1350 FIND v(dout0_131) AT=680.025n

.meas tran vdout0_132ck1350 FIND v(dout0_132) AT=680.025n

.meas tran vdout0_133ck1350 FIND v(dout0_133) AT=680.025n

.meas tran vdout0_134ck1350 FIND v(dout0_134) AT=680.025n

.meas tran vdout0_135ck1350 FIND v(dout0_135) AT=680.025n

.meas tran vdout0_136ck1350 FIND v(dout0_136) AT=680.025n

.meas tran vdout0_137ck1350 FIND v(dout0_137) AT=680.025n

.meas tran vdout0_138ck1350 FIND v(dout0_138) AT=680.025n

.meas tran vdout0_139ck1350 FIND v(dout0_139) AT=680.025n

.meas tran vdout0_140ck1350 FIND v(dout0_140) AT=680.025n

.meas tran vdout0_141ck1350 FIND v(dout0_141) AT=680.025n

.meas tran vdout0_142ck1350 FIND v(dout0_142) AT=680.025n

.meas tran vdout0_143ck1350 FIND v(dout0_143) AT=680.025n

.meas tran vdout0_144ck1350 FIND v(dout0_144) AT=680.025n

.meas tran vdout0_145ck1350 FIND v(dout0_145) AT=680.025n

.meas tran vdout0_146ck1350 FIND v(dout0_146) AT=680.025n

.meas tran vdout0_147ck1350 FIND v(dout0_147) AT=680.025n

.meas tran vdout0_148ck1350 FIND v(dout0_148) AT=680.025n

.meas tran vdout0_149ck1350 FIND v(dout0_149) AT=680.025n

.meas tran vdout0_150ck1350 FIND v(dout0_150) AT=680.025n

.meas tran vdout0_151ck1350 FIND v(dout0_151) AT=680.025n

.meas tran vdout0_152ck1350 FIND v(dout0_152) AT=680.025n

.meas tran vdout0_153ck1350 FIND v(dout0_153) AT=680.025n

.meas tran vdout0_154ck1350 FIND v(dout0_154) AT=680.025n

.meas tran vdout0_155ck1350 FIND v(dout0_155) AT=680.025n

.meas tran vdout0_156ck1350 FIND v(dout0_156) AT=680.025n

.meas tran vdout0_157ck1350 FIND v(dout0_157) AT=680.025n

.meas tran vdout0_158ck1350 FIND v(dout0_158) AT=680.025n

.meas tran vdout0_159ck1350 FIND v(dout0_159) AT=680.025n

.meas tran vdout0_160ck1350 FIND v(dout0_160) AT=680.025n

.meas tran vdout0_161ck1350 FIND v(dout0_161) AT=680.025n

.meas tran vdout0_162ck1350 FIND v(dout0_162) AT=680.025n

.meas tran vdout0_163ck1350 FIND v(dout0_163) AT=680.025n

.meas tran vdout0_164ck1350 FIND v(dout0_164) AT=680.025n

.meas tran vdout0_165ck1350 FIND v(dout0_165) AT=680.025n

.meas tran vdout0_166ck1350 FIND v(dout0_166) AT=680.025n

.meas tran vdout0_167ck1350 FIND v(dout0_167) AT=680.025n

.meas tran vdout0_168ck1350 FIND v(dout0_168) AT=680.025n

.meas tran vdout0_169ck1350 FIND v(dout0_169) AT=680.025n

.meas tran vdout0_170ck1350 FIND v(dout0_170) AT=680.025n

.meas tran vdout0_171ck1350 FIND v(dout0_171) AT=680.025n

.meas tran vdout0_172ck1350 FIND v(dout0_172) AT=680.025n

.meas tran vdout0_173ck1350 FIND v(dout0_173) AT=680.025n

.meas tran vdout0_174ck1350 FIND v(dout0_174) AT=680.025n

.meas tran vdout0_175ck1350 FIND v(dout0_175) AT=680.025n

.meas tran vdout0_176ck1350 FIND v(dout0_176) AT=680.025n

.meas tran vdout0_177ck1350 FIND v(dout0_177) AT=680.025n

.meas tran vdout0_178ck1350 FIND v(dout0_178) AT=680.025n

.meas tran vdout0_179ck1350 FIND v(dout0_179) AT=680.025n

.meas tran vdout0_180ck1350 FIND v(dout0_180) AT=680.025n

.meas tran vdout0_181ck1350 FIND v(dout0_181) AT=680.025n

.meas tran vdout0_182ck1350 FIND v(dout0_182) AT=680.025n

.meas tran vdout0_183ck1350 FIND v(dout0_183) AT=680.025n

.meas tran vdout0_184ck1350 FIND v(dout0_184) AT=680.025n

.meas tran vdout0_185ck1350 FIND v(dout0_185) AT=680.025n

.meas tran vdout0_186ck1350 FIND v(dout0_186) AT=680.025n

.meas tran vdout0_187ck1350 FIND v(dout0_187) AT=680.025n

.meas tran vdout0_188ck1350 FIND v(dout0_188) AT=680.025n

.meas tran vdout0_189ck1350 FIND v(dout0_189) AT=680.025n

.meas tran vdout0_190ck1350 FIND v(dout0_190) AT=680.025n

.meas tran vdout0_191ck1350 FIND v(dout0_191) AT=680.025n

.meas tran vdout0_192ck1350 FIND v(dout0_192) AT=680.025n

.meas tran vdout0_193ck1350 FIND v(dout0_193) AT=680.025n

.meas tran vdout0_194ck1350 FIND v(dout0_194) AT=680.025n

.meas tran vdout0_195ck1350 FIND v(dout0_195) AT=680.025n

.meas tran vdout0_196ck1350 FIND v(dout0_196) AT=680.025n

.meas tran vdout0_197ck1350 FIND v(dout0_197) AT=680.025n

.meas tran vdout0_198ck1350 FIND v(dout0_198) AT=680.025n

.meas tran vdout0_199ck1350 FIND v(dout0_199) AT=680.025n

.meas tran vdout0_200ck1350 FIND v(dout0_200) AT=680.025n

.meas tran vdout0_201ck1350 FIND v(dout0_201) AT=680.025n

.meas tran vdout0_202ck1350 FIND v(dout0_202) AT=680.025n

.meas tran vdout0_203ck1350 FIND v(dout0_203) AT=680.025n

.meas tran vdout0_204ck1350 FIND v(dout0_204) AT=680.025n

.meas tran vdout0_205ck1350 FIND v(dout0_205) AT=680.025n

.meas tran vdout0_206ck1350 FIND v(dout0_206) AT=680.025n

.meas tran vdout0_207ck1350 FIND v(dout0_207) AT=680.025n

.meas tran vdout0_208ck1350 FIND v(dout0_208) AT=680.025n

.meas tran vdout0_209ck1350 FIND v(dout0_209) AT=680.025n

.meas tran vdout0_210ck1350 FIND v(dout0_210) AT=680.025n

.meas tran vdout0_211ck1350 FIND v(dout0_211) AT=680.025n

.meas tran vdout0_212ck1350 FIND v(dout0_212) AT=680.025n

.meas tran vdout0_213ck1350 FIND v(dout0_213) AT=680.025n

.meas tran vdout0_214ck1350 FIND v(dout0_214) AT=680.025n

.meas tran vdout0_215ck1350 FIND v(dout0_215) AT=680.025n

.meas tran vdout0_216ck1350 FIND v(dout0_216) AT=680.025n

.meas tran vdout0_217ck1350 FIND v(dout0_217) AT=680.025n

.meas tran vdout0_218ck1350 FIND v(dout0_218) AT=680.025n

.meas tran vdout0_219ck1350 FIND v(dout0_219) AT=680.025n

.meas tran vdout0_220ck1350 FIND v(dout0_220) AT=680.025n

.meas tran vdout0_221ck1350 FIND v(dout0_221) AT=680.025n

.meas tran vdout0_222ck1350 FIND v(dout0_222) AT=680.025n

.meas tran vdout0_223ck1350 FIND v(dout0_223) AT=680.025n

.meas tran vdout0_224ck1350 FIND v(dout0_224) AT=680.025n

.meas tran vdout0_225ck1350 FIND v(dout0_225) AT=680.025n

.meas tran vdout0_226ck1350 FIND v(dout0_226) AT=680.025n

.meas tran vdout0_227ck1350 FIND v(dout0_227) AT=680.025n

.meas tran vdout0_228ck1350 FIND v(dout0_228) AT=680.025n

.meas tran vdout0_229ck1350 FIND v(dout0_229) AT=680.025n

.meas tran vdout0_230ck1350 FIND v(dout0_230) AT=680.025n

.meas tran vdout0_231ck1350 FIND v(dout0_231) AT=680.025n

.meas tran vdout0_232ck1350 FIND v(dout0_232) AT=680.025n

.meas tran vdout0_233ck1350 FIND v(dout0_233) AT=680.025n

.meas tran vdout0_234ck1350 FIND v(dout0_234) AT=680.025n

.meas tran vdout0_235ck1350 FIND v(dout0_235) AT=680.025n

.meas tran vdout0_236ck1350 FIND v(dout0_236) AT=680.025n

.meas tran vdout0_237ck1350 FIND v(dout0_237) AT=680.025n

.meas tran vdout0_238ck1350 FIND v(dout0_238) AT=680.025n

.meas tran vdout0_239ck1350 FIND v(dout0_239) AT=680.025n

.meas tran vdout0_240ck1350 FIND v(dout0_240) AT=680.025n

.meas tran vdout0_241ck1350 FIND v(dout0_241) AT=680.025n

.meas tran vdout0_242ck1350 FIND v(dout0_242) AT=680.025n

.meas tran vdout0_243ck1350 FIND v(dout0_243) AT=680.025n

.meas tran vdout0_244ck1350 FIND v(dout0_244) AT=680.025n

.meas tran vdout0_245ck1350 FIND v(dout0_245) AT=680.025n

.meas tran vdout0_246ck1350 FIND v(dout0_246) AT=680.025n

.meas tran vdout0_247ck1350 FIND v(dout0_247) AT=680.025n

.meas tran vdout0_248ck1350 FIND v(dout0_248) AT=680.025n

.meas tran vdout0_249ck1350 FIND v(dout0_249) AT=680.025n

.meas tran vdout0_250ck1350 FIND v(dout0_250) AT=680.025n

.meas tran vdout0_251ck1350 FIND v(dout0_251) AT=680.025n

.meas tran vdout0_252ck1350 FIND v(dout0_252) AT=680.025n

.meas tran vdout0_253ck1350 FIND v(dout0_253) AT=680.025n

.meas tran vdout0_254ck1350 FIND v(dout0_254) AT=680.025n

.meas tran vdout0_255ck1350 FIND v(dout0_255) AT=680.025n

.meas tran vdout0_0ck1360 FIND v(dout0_0) AT=685.025n

.meas tran vdout0_1ck1360 FIND v(dout0_1) AT=685.025n

.meas tran vdout0_2ck1360 FIND v(dout0_2) AT=685.025n

.meas tran vdout0_3ck1360 FIND v(dout0_3) AT=685.025n

.meas tran vdout0_4ck1360 FIND v(dout0_4) AT=685.025n

.meas tran vdout0_5ck1360 FIND v(dout0_5) AT=685.025n

.meas tran vdout0_6ck1360 FIND v(dout0_6) AT=685.025n

.meas tran vdout0_7ck1360 FIND v(dout0_7) AT=685.025n

.meas tran vdout0_8ck1360 FIND v(dout0_8) AT=685.025n

.meas tran vdout0_9ck1360 FIND v(dout0_9) AT=685.025n

.meas tran vdout0_10ck1360 FIND v(dout0_10) AT=685.025n

.meas tran vdout0_11ck1360 FIND v(dout0_11) AT=685.025n

.meas tran vdout0_12ck1360 FIND v(dout0_12) AT=685.025n

.meas tran vdout0_13ck1360 FIND v(dout0_13) AT=685.025n

.meas tran vdout0_14ck1360 FIND v(dout0_14) AT=685.025n

.meas tran vdout0_15ck1360 FIND v(dout0_15) AT=685.025n

.meas tran vdout0_16ck1360 FIND v(dout0_16) AT=685.025n

.meas tran vdout0_17ck1360 FIND v(dout0_17) AT=685.025n

.meas tran vdout0_18ck1360 FIND v(dout0_18) AT=685.025n

.meas tran vdout0_19ck1360 FIND v(dout0_19) AT=685.025n

.meas tran vdout0_20ck1360 FIND v(dout0_20) AT=685.025n

.meas tran vdout0_21ck1360 FIND v(dout0_21) AT=685.025n

.meas tran vdout0_22ck1360 FIND v(dout0_22) AT=685.025n

.meas tran vdout0_23ck1360 FIND v(dout0_23) AT=685.025n

.meas tran vdout0_24ck1360 FIND v(dout0_24) AT=685.025n

.meas tran vdout0_25ck1360 FIND v(dout0_25) AT=685.025n

.meas tran vdout0_26ck1360 FIND v(dout0_26) AT=685.025n

.meas tran vdout0_27ck1360 FIND v(dout0_27) AT=685.025n

.meas tran vdout0_28ck1360 FIND v(dout0_28) AT=685.025n

.meas tran vdout0_29ck1360 FIND v(dout0_29) AT=685.025n

.meas tran vdout0_30ck1360 FIND v(dout0_30) AT=685.025n

.meas tran vdout0_31ck1360 FIND v(dout0_31) AT=685.025n

.meas tran vdout0_32ck1360 FIND v(dout0_32) AT=685.025n

.meas tran vdout0_33ck1360 FIND v(dout0_33) AT=685.025n

.meas tran vdout0_34ck1360 FIND v(dout0_34) AT=685.025n

.meas tran vdout0_35ck1360 FIND v(dout0_35) AT=685.025n

.meas tran vdout0_36ck1360 FIND v(dout0_36) AT=685.025n

.meas tran vdout0_37ck1360 FIND v(dout0_37) AT=685.025n

.meas tran vdout0_38ck1360 FIND v(dout0_38) AT=685.025n

.meas tran vdout0_39ck1360 FIND v(dout0_39) AT=685.025n

.meas tran vdout0_40ck1360 FIND v(dout0_40) AT=685.025n

.meas tran vdout0_41ck1360 FIND v(dout0_41) AT=685.025n

.meas tran vdout0_42ck1360 FIND v(dout0_42) AT=685.025n

.meas tran vdout0_43ck1360 FIND v(dout0_43) AT=685.025n

.meas tran vdout0_44ck1360 FIND v(dout0_44) AT=685.025n

.meas tran vdout0_45ck1360 FIND v(dout0_45) AT=685.025n

.meas tran vdout0_46ck1360 FIND v(dout0_46) AT=685.025n

.meas tran vdout0_47ck1360 FIND v(dout0_47) AT=685.025n

.meas tran vdout0_48ck1360 FIND v(dout0_48) AT=685.025n

.meas tran vdout0_49ck1360 FIND v(dout0_49) AT=685.025n

.meas tran vdout0_50ck1360 FIND v(dout0_50) AT=685.025n

.meas tran vdout0_51ck1360 FIND v(dout0_51) AT=685.025n

.meas tran vdout0_52ck1360 FIND v(dout0_52) AT=685.025n

.meas tran vdout0_53ck1360 FIND v(dout0_53) AT=685.025n

.meas tran vdout0_54ck1360 FIND v(dout0_54) AT=685.025n

.meas tran vdout0_55ck1360 FIND v(dout0_55) AT=685.025n

.meas tran vdout0_56ck1360 FIND v(dout0_56) AT=685.025n

.meas tran vdout0_57ck1360 FIND v(dout0_57) AT=685.025n

.meas tran vdout0_58ck1360 FIND v(dout0_58) AT=685.025n

.meas tran vdout0_59ck1360 FIND v(dout0_59) AT=685.025n

.meas tran vdout0_60ck1360 FIND v(dout0_60) AT=685.025n

.meas tran vdout0_61ck1360 FIND v(dout0_61) AT=685.025n

.meas tran vdout0_62ck1360 FIND v(dout0_62) AT=685.025n

.meas tran vdout0_63ck1360 FIND v(dout0_63) AT=685.025n

.meas tran vdout0_64ck1360 FIND v(dout0_64) AT=685.025n

.meas tran vdout0_65ck1360 FIND v(dout0_65) AT=685.025n

.meas tran vdout0_66ck1360 FIND v(dout0_66) AT=685.025n

.meas tran vdout0_67ck1360 FIND v(dout0_67) AT=685.025n

.meas tran vdout0_68ck1360 FIND v(dout0_68) AT=685.025n

.meas tran vdout0_69ck1360 FIND v(dout0_69) AT=685.025n

.meas tran vdout0_70ck1360 FIND v(dout0_70) AT=685.025n

.meas tran vdout0_71ck1360 FIND v(dout0_71) AT=685.025n

.meas tran vdout0_72ck1360 FIND v(dout0_72) AT=685.025n

.meas tran vdout0_73ck1360 FIND v(dout0_73) AT=685.025n

.meas tran vdout0_74ck1360 FIND v(dout0_74) AT=685.025n

.meas tran vdout0_75ck1360 FIND v(dout0_75) AT=685.025n

.meas tran vdout0_76ck1360 FIND v(dout0_76) AT=685.025n

.meas tran vdout0_77ck1360 FIND v(dout0_77) AT=685.025n

.meas tran vdout0_78ck1360 FIND v(dout0_78) AT=685.025n

.meas tran vdout0_79ck1360 FIND v(dout0_79) AT=685.025n

.meas tran vdout0_80ck1360 FIND v(dout0_80) AT=685.025n

.meas tran vdout0_81ck1360 FIND v(dout0_81) AT=685.025n

.meas tran vdout0_82ck1360 FIND v(dout0_82) AT=685.025n

.meas tran vdout0_83ck1360 FIND v(dout0_83) AT=685.025n

.meas tran vdout0_84ck1360 FIND v(dout0_84) AT=685.025n

.meas tran vdout0_85ck1360 FIND v(dout0_85) AT=685.025n

.meas tran vdout0_86ck1360 FIND v(dout0_86) AT=685.025n

.meas tran vdout0_87ck1360 FIND v(dout0_87) AT=685.025n

.meas tran vdout0_88ck1360 FIND v(dout0_88) AT=685.025n

.meas tran vdout0_89ck1360 FIND v(dout0_89) AT=685.025n

.meas tran vdout0_90ck1360 FIND v(dout0_90) AT=685.025n

.meas tran vdout0_91ck1360 FIND v(dout0_91) AT=685.025n

.meas tran vdout0_92ck1360 FIND v(dout0_92) AT=685.025n

.meas tran vdout0_93ck1360 FIND v(dout0_93) AT=685.025n

.meas tran vdout0_94ck1360 FIND v(dout0_94) AT=685.025n

.meas tran vdout0_95ck1360 FIND v(dout0_95) AT=685.025n

.meas tran vdout0_96ck1360 FIND v(dout0_96) AT=685.025n

.meas tran vdout0_97ck1360 FIND v(dout0_97) AT=685.025n

.meas tran vdout0_98ck1360 FIND v(dout0_98) AT=685.025n

.meas tran vdout0_99ck1360 FIND v(dout0_99) AT=685.025n

.meas tran vdout0_100ck1360 FIND v(dout0_100) AT=685.025n

.meas tran vdout0_101ck1360 FIND v(dout0_101) AT=685.025n

.meas tran vdout0_102ck1360 FIND v(dout0_102) AT=685.025n

.meas tran vdout0_103ck1360 FIND v(dout0_103) AT=685.025n

.meas tran vdout0_104ck1360 FIND v(dout0_104) AT=685.025n

.meas tran vdout0_105ck1360 FIND v(dout0_105) AT=685.025n

.meas tran vdout0_106ck1360 FIND v(dout0_106) AT=685.025n

.meas tran vdout0_107ck1360 FIND v(dout0_107) AT=685.025n

.meas tran vdout0_108ck1360 FIND v(dout0_108) AT=685.025n

.meas tran vdout0_109ck1360 FIND v(dout0_109) AT=685.025n

.meas tran vdout0_110ck1360 FIND v(dout0_110) AT=685.025n

.meas tran vdout0_111ck1360 FIND v(dout0_111) AT=685.025n

.meas tran vdout0_112ck1360 FIND v(dout0_112) AT=685.025n

.meas tran vdout0_113ck1360 FIND v(dout0_113) AT=685.025n

.meas tran vdout0_114ck1360 FIND v(dout0_114) AT=685.025n

.meas tran vdout0_115ck1360 FIND v(dout0_115) AT=685.025n

.meas tran vdout0_116ck1360 FIND v(dout0_116) AT=685.025n

.meas tran vdout0_117ck1360 FIND v(dout0_117) AT=685.025n

.meas tran vdout0_118ck1360 FIND v(dout0_118) AT=685.025n

.meas tran vdout0_119ck1360 FIND v(dout0_119) AT=685.025n

.meas tran vdout0_120ck1360 FIND v(dout0_120) AT=685.025n

.meas tran vdout0_121ck1360 FIND v(dout0_121) AT=685.025n

.meas tran vdout0_122ck1360 FIND v(dout0_122) AT=685.025n

.meas tran vdout0_123ck1360 FIND v(dout0_123) AT=685.025n

.meas tran vdout0_124ck1360 FIND v(dout0_124) AT=685.025n

.meas tran vdout0_125ck1360 FIND v(dout0_125) AT=685.025n

.meas tran vdout0_126ck1360 FIND v(dout0_126) AT=685.025n

.meas tran vdout0_127ck1360 FIND v(dout0_127) AT=685.025n

.meas tran vdout0_128ck1360 FIND v(dout0_128) AT=685.025n

.meas tran vdout0_129ck1360 FIND v(dout0_129) AT=685.025n

.meas tran vdout0_130ck1360 FIND v(dout0_130) AT=685.025n

.meas tran vdout0_131ck1360 FIND v(dout0_131) AT=685.025n

.meas tran vdout0_132ck1360 FIND v(dout0_132) AT=685.025n

.meas tran vdout0_133ck1360 FIND v(dout0_133) AT=685.025n

.meas tran vdout0_134ck1360 FIND v(dout0_134) AT=685.025n

.meas tran vdout0_135ck1360 FIND v(dout0_135) AT=685.025n

.meas tran vdout0_136ck1360 FIND v(dout0_136) AT=685.025n

.meas tran vdout0_137ck1360 FIND v(dout0_137) AT=685.025n

.meas tran vdout0_138ck1360 FIND v(dout0_138) AT=685.025n

.meas tran vdout0_139ck1360 FIND v(dout0_139) AT=685.025n

.meas tran vdout0_140ck1360 FIND v(dout0_140) AT=685.025n

.meas tran vdout0_141ck1360 FIND v(dout0_141) AT=685.025n

.meas tran vdout0_142ck1360 FIND v(dout0_142) AT=685.025n

.meas tran vdout0_143ck1360 FIND v(dout0_143) AT=685.025n

.meas tran vdout0_144ck1360 FIND v(dout0_144) AT=685.025n

.meas tran vdout0_145ck1360 FIND v(dout0_145) AT=685.025n

.meas tran vdout0_146ck1360 FIND v(dout0_146) AT=685.025n

.meas tran vdout0_147ck1360 FIND v(dout0_147) AT=685.025n

.meas tran vdout0_148ck1360 FIND v(dout0_148) AT=685.025n

.meas tran vdout0_149ck1360 FIND v(dout0_149) AT=685.025n

.meas tran vdout0_150ck1360 FIND v(dout0_150) AT=685.025n

.meas tran vdout0_151ck1360 FIND v(dout0_151) AT=685.025n

.meas tran vdout0_152ck1360 FIND v(dout0_152) AT=685.025n

.meas tran vdout0_153ck1360 FIND v(dout0_153) AT=685.025n

.meas tran vdout0_154ck1360 FIND v(dout0_154) AT=685.025n

.meas tran vdout0_155ck1360 FIND v(dout0_155) AT=685.025n

.meas tran vdout0_156ck1360 FIND v(dout0_156) AT=685.025n

.meas tran vdout0_157ck1360 FIND v(dout0_157) AT=685.025n

.meas tran vdout0_158ck1360 FIND v(dout0_158) AT=685.025n

.meas tran vdout0_159ck1360 FIND v(dout0_159) AT=685.025n

.meas tran vdout0_160ck1360 FIND v(dout0_160) AT=685.025n

.meas tran vdout0_161ck1360 FIND v(dout0_161) AT=685.025n

.meas tran vdout0_162ck1360 FIND v(dout0_162) AT=685.025n

.meas tran vdout0_163ck1360 FIND v(dout0_163) AT=685.025n

.meas tran vdout0_164ck1360 FIND v(dout0_164) AT=685.025n

.meas tran vdout0_165ck1360 FIND v(dout0_165) AT=685.025n

.meas tran vdout0_166ck1360 FIND v(dout0_166) AT=685.025n

.meas tran vdout0_167ck1360 FIND v(dout0_167) AT=685.025n

.meas tran vdout0_168ck1360 FIND v(dout0_168) AT=685.025n

.meas tran vdout0_169ck1360 FIND v(dout0_169) AT=685.025n

.meas tran vdout0_170ck1360 FIND v(dout0_170) AT=685.025n

.meas tran vdout0_171ck1360 FIND v(dout0_171) AT=685.025n

.meas tran vdout0_172ck1360 FIND v(dout0_172) AT=685.025n

.meas tran vdout0_173ck1360 FIND v(dout0_173) AT=685.025n

.meas tran vdout0_174ck1360 FIND v(dout0_174) AT=685.025n

.meas tran vdout0_175ck1360 FIND v(dout0_175) AT=685.025n

.meas tran vdout0_176ck1360 FIND v(dout0_176) AT=685.025n

.meas tran vdout0_177ck1360 FIND v(dout0_177) AT=685.025n

.meas tran vdout0_178ck1360 FIND v(dout0_178) AT=685.025n

.meas tran vdout0_179ck1360 FIND v(dout0_179) AT=685.025n

.meas tran vdout0_180ck1360 FIND v(dout0_180) AT=685.025n

.meas tran vdout0_181ck1360 FIND v(dout0_181) AT=685.025n

.meas tran vdout0_182ck1360 FIND v(dout0_182) AT=685.025n

.meas tran vdout0_183ck1360 FIND v(dout0_183) AT=685.025n

.meas tran vdout0_184ck1360 FIND v(dout0_184) AT=685.025n

.meas tran vdout0_185ck1360 FIND v(dout0_185) AT=685.025n

.meas tran vdout0_186ck1360 FIND v(dout0_186) AT=685.025n

.meas tran vdout0_187ck1360 FIND v(dout0_187) AT=685.025n

.meas tran vdout0_188ck1360 FIND v(dout0_188) AT=685.025n

.meas tran vdout0_189ck1360 FIND v(dout0_189) AT=685.025n

.meas tran vdout0_190ck1360 FIND v(dout0_190) AT=685.025n

.meas tran vdout0_191ck1360 FIND v(dout0_191) AT=685.025n

.meas tran vdout0_192ck1360 FIND v(dout0_192) AT=685.025n

.meas tran vdout0_193ck1360 FIND v(dout0_193) AT=685.025n

.meas tran vdout0_194ck1360 FIND v(dout0_194) AT=685.025n

.meas tran vdout0_195ck1360 FIND v(dout0_195) AT=685.025n

.meas tran vdout0_196ck1360 FIND v(dout0_196) AT=685.025n

.meas tran vdout0_197ck1360 FIND v(dout0_197) AT=685.025n

.meas tran vdout0_198ck1360 FIND v(dout0_198) AT=685.025n

.meas tran vdout0_199ck1360 FIND v(dout0_199) AT=685.025n

.meas tran vdout0_200ck1360 FIND v(dout0_200) AT=685.025n

.meas tran vdout0_201ck1360 FIND v(dout0_201) AT=685.025n

.meas tran vdout0_202ck1360 FIND v(dout0_202) AT=685.025n

.meas tran vdout0_203ck1360 FIND v(dout0_203) AT=685.025n

.meas tran vdout0_204ck1360 FIND v(dout0_204) AT=685.025n

.meas tran vdout0_205ck1360 FIND v(dout0_205) AT=685.025n

.meas tran vdout0_206ck1360 FIND v(dout0_206) AT=685.025n

.meas tran vdout0_207ck1360 FIND v(dout0_207) AT=685.025n

.meas tran vdout0_208ck1360 FIND v(dout0_208) AT=685.025n

.meas tran vdout0_209ck1360 FIND v(dout0_209) AT=685.025n

.meas tran vdout0_210ck1360 FIND v(dout0_210) AT=685.025n

.meas tran vdout0_211ck1360 FIND v(dout0_211) AT=685.025n

.meas tran vdout0_212ck1360 FIND v(dout0_212) AT=685.025n

.meas tran vdout0_213ck1360 FIND v(dout0_213) AT=685.025n

.meas tran vdout0_214ck1360 FIND v(dout0_214) AT=685.025n

.meas tran vdout0_215ck1360 FIND v(dout0_215) AT=685.025n

.meas tran vdout0_216ck1360 FIND v(dout0_216) AT=685.025n

.meas tran vdout0_217ck1360 FIND v(dout0_217) AT=685.025n

.meas tran vdout0_218ck1360 FIND v(dout0_218) AT=685.025n

.meas tran vdout0_219ck1360 FIND v(dout0_219) AT=685.025n

.meas tran vdout0_220ck1360 FIND v(dout0_220) AT=685.025n

.meas tran vdout0_221ck1360 FIND v(dout0_221) AT=685.025n

.meas tran vdout0_222ck1360 FIND v(dout0_222) AT=685.025n

.meas tran vdout0_223ck1360 FIND v(dout0_223) AT=685.025n

.meas tran vdout0_224ck1360 FIND v(dout0_224) AT=685.025n

.meas tran vdout0_225ck1360 FIND v(dout0_225) AT=685.025n

.meas tran vdout0_226ck1360 FIND v(dout0_226) AT=685.025n

.meas tran vdout0_227ck1360 FIND v(dout0_227) AT=685.025n

.meas tran vdout0_228ck1360 FIND v(dout0_228) AT=685.025n

.meas tran vdout0_229ck1360 FIND v(dout0_229) AT=685.025n

.meas tran vdout0_230ck1360 FIND v(dout0_230) AT=685.025n

.meas tran vdout0_231ck1360 FIND v(dout0_231) AT=685.025n

.meas tran vdout0_232ck1360 FIND v(dout0_232) AT=685.025n

.meas tran vdout0_233ck1360 FIND v(dout0_233) AT=685.025n

.meas tran vdout0_234ck1360 FIND v(dout0_234) AT=685.025n

.meas tran vdout0_235ck1360 FIND v(dout0_235) AT=685.025n

.meas tran vdout0_236ck1360 FIND v(dout0_236) AT=685.025n

.meas tran vdout0_237ck1360 FIND v(dout0_237) AT=685.025n

.meas tran vdout0_238ck1360 FIND v(dout0_238) AT=685.025n

.meas tran vdout0_239ck1360 FIND v(dout0_239) AT=685.025n

.meas tran vdout0_240ck1360 FIND v(dout0_240) AT=685.025n

.meas tran vdout0_241ck1360 FIND v(dout0_241) AT=685.025n

.meas tran vdout0_242ck1360 FIND v(dout0_242) AT=685.025n

.meas tran vdout0_243ck1360 FIND v(dout0_243) AT=685.025n

.meas tran vdout0_244ck1360 FIND v(dout0_244) AT=685.025n

.meas tran vdout0_245ck1360 FIND v(dout0_245) AT=685.025n

.meas tran vdout0_246ck1360 FIND v(dout0_246) AT=685.025n

.meas tran vdout0_247ck1360 FIND v(dout0_247) AT=685.025n

.meas tran vdout0_248ck1360 FIND v(dout0_248) AT=685.025n

.meas tran vdout0_249ck1360 FIND v(dout0_249) AT=685.025n

.meas tran vdout0_250ck1360 FIND v(dout0_250) AT=685.025n

.meas tran vdout0_251ck1360 FIND v(dout0_251) AT=685.025n

.meas tran vdout0_252ck1360 FIND v(dout0_252) AT=685.025n

.meas tran vdout0_253ck1360 FIND v(dout0_253) AT=685.025n

.meas tran vdout0_254ck1360 FIND v(dout0_254) AT=685.025n

.meas tran vdout0_255ck1360 FIND v(dout0_255) AT=685.025n

.meas tran vdout0_0ck1370 FIND v(dout0_0) AT=690.025n

.meas tran vdout0_1ck1370 FIND v(dout0_1) AT=690.025n

.meas tran vdout0_2ck1370 FIND v(dout0_2) AT=690.025n

.meas tran vdout0_3ck1370 FIND v(dout0_3) AT=690.025n

.meas tran vdout0_4ck1370 FIND v(dout0_4) AT=690.025n

.meas tran vdout0_5ck1370 FIND v(dout0_5) AT=690.025n

.meas tran vdout0_6ck1370 FIND v(dout0_6) AT=690.025n

.meas tran vdout0_7ck1370 FIND v(dout0_7) AT=690.025n

.meas tran vdout0_8ck1370 FIND v(dout0_8) AT=690.025n

.meas tran vdout0_9ck1370 FIND v(dout0_9) AT=690.025n

.meas tran vdout0_10ck1370 FIND v(dout0_10) AT=690.025n

.meas tran vdout0_11ck1370 FIND v(dout0_11) AT=690.025n

.meas tran vdout0_12ck1370 FIND v(dout0_12) AT=690.025n

.meas tran vdout0_13ck1370 FIND v(dout0_13) AT=690.025n

.meas tran vdout0_14ck1370 FIND v(dout0_14) AT=690.025n

.meas tran vdout0_15ck1370 FIND v(dout0_15) AT=690.025n

.meas tran vdout0_16ck1370 FIND v(dout0_16) AT=690.025n

.meas tran vdout0_17ck1370 FIND v(dout0_17) AT=690.025n

.meas tran vdout0_18ck1370 FIND v(dout0_18) AT=690.025n

.meas tran vdout0_19ck1370 FIND v(dout0_19) AT=690.025n

.meas tran vdout0_20ck1370 FIND v(dout0_20) AT=690.025n

.meas tran vdout0_21ck1370 FIND v(dout0_21) AT=690.025n

.meas tran vdout0_22ck1370 FIND v(dout0_22) AT=690.025n

.meas tran vdout0_23ck1370 FIND v(dout0_23) AT=690.025n

.meas tran vdout0_24ck1370 FIND v(dout0_24) AT=690.025n

.meas tran vdout0_25ck1370 FIND v(dout0_25) AT=690.025n

.meas tran vdout0_26ck1370 FIND v(dout0_26) AT=690.025n

.meas tran vdout0_27ck1370 FIND v(dout0_27) AT=690.025n

.meas tran vdout0_28ck1370 FIND v(dout0_28) AT=690.025n

.meas tran vdout0_29ck1370 FIND v(dout0_29) AT=690.025n

.meas tran vdout0_30ck1370 FIND v(dout0_30) AT=690.025n

.meas tran vdout0_31ck1370 FIND v(dout0_31) AT=690.025n

.meas tran vdout0_32ck1370 FIND v(dout0_32) AT=690.025n

.meas tran vdout0_33ck1370 FIND v(dout0_33) AT=690.025n

.meas tran vdout0_34ck1370 FIND v(dout0_34) AT=690.025n

.meas tran vdout0_35ck1370 FIND v(dout0_35) AT=690.025n

.meas tran vdout0_36ck1370 FIND v(dout0_36) AT=690.025n

.meas tran vdout0_37ck1370 FIND v(dout0_37) AT=690.025n

.meas tran vdout0_38ck1370 FIND v(dout0_38) AT=690.025n

.meas tran vdout0_39ck1370 FIND v(dout0_39) AT=690.025n

.meas tran vdout0_40ck1370 FIND v(dout0_40) AT=690.025n

.meas tran vdout0_41ck1370 FIND v(dout0_41) AT=690.025n

.meas tran vdout0_42ck1370 FIND v(dout0_42) AT=690.025n

.meas tran vdout0_43ck1370 FIND v(dout0_43) AT=690.025n

.meas tran vdout0_44ck1370 FIND v(dout0_44) AT=690.025n

.meas tran vdout0_45ck1370 FIND v(dout0_45) AT=690.025n

.meas tran vdout0_46ck1370 FIND v(dout0_46) AT=690.025n

.meas tran vdout0_47ck1370 FIND v(dout0_47) AT=690.025n

.meas tran vdout0_48ck1370 FIND v(dout0_48) AT=690.025n

.meas tran vdout0_49ck1370 FIND v(dout0_49) AT=690.025n

.meas tran vdout0_50ck1370 FIND v(dout0_50) AT=690.025n

.meas tran vdout0_51ck1370 FIND v(dout0_51) AT=690.025n

.meas tran vdout0_52ck1370 FIND v(dout0_52) AT=690.025n

.meas tran vdout0_53ck1370 FIND v(dout0_53) AT=690.025n

.meas tran vdout0_54ck1370 FIND v(dout0_54) AT=690.025n

.meas tran vdout0_55ck1370 FIND v(dout0_55) AT=690.025n

.meas tran vdout0_56ck1370 FIND v(dout0_56) AT=690.025n

.meas tran vdout0_57ck1370 FIND v(dout0_57) AT=690.025n

.meas tran vdout0_58ck1370 FIND v(dout0_58) AT=690.025n

.meas tran vdout0_59ck1370 FIND v(dout0_59) AT=690.025n

.meas tran vdout0_60ck1370 FIND v(dout0_60) AT=690.025n

.meas tran vdout0_61ck1370 FIND v(dout0_61) AT=690.025n

.meas tran vdout0_62ck1370 FIND v(dout0_62) AT=690.025n

.meas tran vdout0_63ck1370 FIND v(dout0_63) AT=690.025n

.meas tran vdout0_64ck1370 FIND v(dout0_64) AT=690.025n

.meas tran vdout0_65ck1370 FIND v(dout0_65) AT=690.025n

.meas tran vdout0_66ck1370 FIND v(dout0_66) AT=690.025n

.meas tran vdout0_67ck1370 FIND v(dout0_67) AT=690.025n

.meas tran vdout0_68ck1370 FIND v(dout0_68) AT=690.025n

.meas tran vdout0_69ck1370 FIND v(dout0_69) AT=690.025n

.meas tran vdout0_70ck1370 FIND v(dout0_70) AT=690.025n

.meas tran vdout0_71ck1370 FIND v(dout0_71) AT=690.025n

.meas tran vdout0_72ck1370 FIND v(dout0_72) AT=690.025n

.meas tran vdout0_73ck1370 FIND v(dout0_73) AT=690.025n

.meas tran vdout0_74ck1370 FIND v(dout0_74) AT=690.025n

.meas tran vdout0_75ck1370 FIND v(dout0_75) AT=690.025n

.meas tran vdout0_76ck1370 FIND v(dout0_76) AT=690.025n

.meas tran vdout0_77ck1370 FIND v(dout0_77) AT=690.025n

.meas tran vdout0_78ck1370 FIND v(dout0_78) AT=690.025n

.meas tran vdout0_79ck1370 FIND v(dout0_79) AT=690.025n

.meas tran vdout0_80ck1370 FIND v(dout0_80) AT=690.025n

.meas tran vdout0_81ck1370 FIND v(dout0_81) AT=690.025n

.meas tran vdout0_82ck1370 FIND v(dout0_82) AT=690.025n

.meas tran vdout0_83ck1370 FIND v(dout0_83) AT=690.025n

.meas tran vdout0_84ck1370 FIND v(dout0_84) AT=690.025n

.meas tran vdout0_85ck1370 FIND v(dout0_85) AT=690.025n

.meas tran vdout0_86ck1370 FIND v(dout0_86) AT=690.025n

.meas tran vdout0_87ck1370 FIND v(dout0_87) AT=690.025n

.meas tran vdout0_88ck1370 FIND v(dout0_88) AT=690.025n

.meas tran vdout0_89ck1370 FIND v(dout0_89) AT=690.025n

.meas tran vdout0_90ck1370 FIND v(dout0_90) AT=690.025n

.meas tran vdout0_91ck1370 FIND v(dout0_91) AT=690.025n

.meas tran vdout0_92ck1370 FIND v(dout0_92) AT=690.025n

.meas tran vdout0_93ck1370 FIND v(dout0_93) AT=690.025n

.meas tran vdout0_94ck1370 FIND v(dout0_94) AT=690.025n

.meas tran vdout0_95ck1370 FIND v(dout0_95) AT=690.025n

.meas tran vdout0_96ck1370 FIND v(dout0_96) AT=690.025n

.meas tran vdout0_97ck1370 FIND v(dout0_97) AT=690.025n

.meas tran vdout0_98ck1370 FIND v(dout0_98) AT=690.025n

.meas tran vdout0_99ck1370 FIND v(dout0_99) AT=690.025n

.meas tran vdout0_100ck1370 FIND v(dout0_100) AT=690.025n

.meas tran vdout0_101ck1370 FIND v(dout0_101) AT=690.025n

.meas tran vdout0_102ck1370 FIND v(dout0_102) AT=690.025n

.meas tran vdout0_103ck1370 FIND v(dout0_103) AT=690.025n

.meas tran vdout0_104ck1370 FIND v(dout0_104) AT=690.025n

.meas tran vdout0_105ck1370 FIND v(dout0_105) AT=690.025n

.meas tran vdout0_106ck1370 FIND v(dout0_106) AT=690.025n

.meas tran vdout0_107ck1370 FIND v(dout0_107) AT=690.025n

.meas tran vdout0_108ck1370 FIND v(dout0_108) AT=690.025n

.meas tran vdout0_109ck1370 FIND v(dout0_109) AT=690.025n

.meas tran vdout0_110ck1370 FIND v(dout0_110) AT=690.025n

.meas tran vdout0_111ck1370 FIND v(dout0_111) AT=690.025n

.meas tran vdout0_112ck1370 FIND v(dout0_112) AT=690.025n

.meas tran vdout0_113ck1370 FIND v(dout0_113) AT=690.025n

.meas tran vdout0_114ck1370 FIND v(dout0_114) AT=690.025n

.meas tran vdout0_115ck1370 FIND v(dout0_115) AT=690.025n

.meas tran vdout0_116ck1370 FIND v(dout0_116) AT=690.025n

.meas tran vdout0_117ck1370 FIND v(dout0_117) AT=690.025n

.meas tran vdout0_118ck1370 FIND v(dout0_118) AT=690.025n

.meas tran vdout0_119ck1370 FIND v(dout0_119) AT=690.025n

.meas tran vdout0_120ck1370 FIND v(dout0_120) AT=690.025n

.meas tran vdout0_121ck1370 FIND v(dout0_121) AT=690.025n

.meas tran vdout0_122ck1370 FIND v(dout0_122) AT=690.025n

.meas tran vdout0_123ck1370 FIND v(dout0_123) AT=690.025n

.meas tran vdout0_124ck1370 FIND v(dout0_124) AT=690.025n

.meas tran vdout0_125ck1370 FIND v(dout0_125) AT=690.025n

.meas tran vdout0_126ck1370 FIND v(dout0_126) AT=690.025n

.meas tran vdout0_127ck1370 FIND v(dout0_127) AT=690.025n

.meas tran vdout0_128ck1370 FIND v(dout0_128) AT=690.025n

.meas tran vdout0_129ck1370 FIND v(dout0_129) AT=690.025n

.meas tran vdout0_130ck1370 FIND v(dout0_130) AT=690.025n

.meas tran vdout0_131ck1370 FIND v(dout0_131) AT=690.025n

.meas tran vdout0_132ck1370 FIND v(dout0_132) AT=690.025n

.meas tran vdout0_133ck1370 FIND v(dout0_133) AT=690.025n

.meas tran vdout0_134ck1370 FIND v(dout0_134) AT=690.025n

.meas tran vdout0_135ck1370 FIND v(dout0_135) AT=690.025n

.meas tran vdout0_136ck1370 FIND v(dout0_136) AT=690.025n

.meas tran vdout0_137ck1370 FIND v(dout0_137) AT=690.025n

.meas tran vdout0_138ck1370 FIND v(dout0_138) AT=690.025n

.meas tran vdout0_139ck1370 FIND v(dout0_139) AT=690.025n

.meas tran vdout0_140ck1370 FIND v(dout0_140) AT=690.025n

.meas tran vdout0_141ck1370 FIND v(dout0_141) AT=690.025n

.meas tran vdout0_142ck1370 FIND v(dout0_142) AT=690.025n

.meas tran vdout0_143ck1370 FIND v(dout0_143) AT=690.025n

.meas tran vdout0_144ck1370 FIND v(dout0_144) AT=690.025n

.meas tran vdout0_145ck1370 FIND v(dout0_145) AT=690.025n

.meas tran vdout0_146ck1370 FIND v(dout0_146) AT=690.025n

.meas tran vdout0_147ck1370 FIND v(dout0_147) AT=690.025n

.meas tran vdout0_148ck1370 FIND v(dout0_148) AT=690.025n

.meas tran vdout0_149ck1370 FIND v(dout0_149) AT=690.025n

.meas tran vdout0_150ck1370 FIND v(dout0_150) AT=690.025n

.meas tran vdout0_151ck1370 FIND v(dout0_151) AT=690.025n

.meas tran vdout0_152ck1370 FIND v(dout0_152) AT=690.025n

.meas tran vdout0_153ck1370 FIND v(dout0_153) AT=690.025n

.meas tran vdout0_154ck1370 FIND v(dout0_154) AT=690.025n

.meas tran vdout0_155ck1370 FIND v(dout0_155) AT=690.025n

.meas tran vdout0_156ck1370 FIND v(dout0_156) AT=690.025n

.meas tran vdout0_157ck1370 FIND v(dout0_157) AT=690.025n

.meas tran vdout0_158ck1370 FIND v(dout0_158) AT=690.025n

.meas tran vdout0_159ck1370 FIND v(dout0_159) AT=690.025n

.meas tran vdout0_160ck1370 FIND v(dout0_160) AT=690.025n

.meas tran vdout0_161ck1370 FIND v(dout0_161) AT=690.025n

.meas tran vdout0_162ck1370 FIND v(dout0_162) AT=690.025n

.meas tran vdout0_163ck1370 FIND v(dout0_163) AT=690.025n

.meas tran vdout0_164ck1370 FIND v(dout0_164) AT=690.025n

.meas tran vdout0_165ck1370 FIND v(dout0_165) AT=690.025n

.meas tran vdout0_166ck1370 FIND v(dout0_166) AT=690.025n

.meas tran vdout0_167ck1370 FIND v(dout0_167) AT=690.025n

.meas tran vdout0_168ck1370 FIND v(dout0_168) AT=690.025n

.meas tran vdout0_169ck1370 FIND v(dout0_169) AT=690.025n

.meas tran vdout0_170ck1370 FIND v(dout0_170) AT=690.025n

.meas tran vdout0_171ck1370 FIND v(dout0_171) AT=690.025n

.meas tran vdout0_172ck1370 FIND v(dout0_172) AT=690.025n

.meas tran vdout0_173ck1370 FIND v(dout0_173) AT=690.025n

.meas tran vdout0_174ck1370 FIND v(dout0_174) AT=690.025n

.meas tran vdout0_175ck1370 FIND v(dout0_175) AT=690.025n

.meas tran vdout0_176ck1370 FIND v(dout0_176) AT=690.025n

.meas tran vdout0_177ck1370 FIND v(dout0_177) AT=690.025n

.meas tran vdout0_178ck1370 FIND v(dout0_178) AT=690.025n

.meas tran vdout0_179ck1370 FIND v(dout0_179) AT=690.025n

.meas tran vdout0_180ck1370 FIND v(dout0_180) AT=690.025n

.meas tran vdout0_181ck1370 FIND v(dout0_181) AT=690.025n

.meas tran vdout0_182ck1370 FIND v(dout0_182) AT=690.025n

.meas tran vdout0_183ck1370 FIND v(dout0_183) AT=690.025n

.meas tran vdout0_184ck1370 FIND v(dout0_184) AT=690.025n

.meas tran vdout0_185ck1370 FIND v(dout0_185) AT=690.025n

.meas tran vdout0_186ck1370 FIND v(dout0_186) AT=690.025n

.meas tran vdout0_187ck1370 FIND v(dout0_187) AT=690.025n

.meas tran vdout0_188ck1370 FIND v(dout0_188) AT=690.025n

.meas tran vdout0_189ck1370 FIND v(dout0_189) AT=690.025n

.meas tran vdout0_190ck1370 FIND v(dout0_190) AT=690.025n

.meas tran vdout0_191ck1370 FIND v(dout0_191) AT=690.025n

.meas tran vdout0_192ck1370 FIND v(dout0_192) AT=690.025n

.meas tran vdout0_193ck1370 FIND v(dout0_193) AT=690.025n

.meas tran vdout0_194ck1370 FIND v(dout0_194) AT=690.025n

.meas tran vdout0_195ck1370 FIND v(dout0_195) AT=690.025n

.meas tran vdout0_196ck1370 FIND v(dout0_196) AT=690.025n

.meas tran vdout0_197ck1370 FIND v(dout0_197) AT=690.025n

.meas tran vdout0_198ck1370 FIND v(dout0_198) AT=690.025n

.meas tran vdout0_199ck1370 FIND v(dout0_199) AT=690.025n

.meas tran vdout0_200ck1370 FIND v(dout0_200) AT=690.025n

.meas tran vdout0_201ck1370 FIND v(dout0_201) AT=690.025n

.meas tran vdout0_202ck1370 FIND v(dout0_202) AT=690.025n

.meas tran vdout0_203ck1370 FIND v(dout0_203) AT=690.025n

.meas tran vdout0_204ck1370 FIND v(dout0_204) AT=690.025n

.meas tran vdout0_205ck1370 FIND v(dout0_205) AT=690.025n

.meas tran vdout0_206ck1370 FIND v(dout0_206) AT=690.025n

.meas tran vdout0_207ck1370 FIND v(dout0_207) AT=690.025n

.meas tran vdout0_208ck1370 FIND v(dout0_208) AT=690.025n

.meas tran vdout0_209ck1370 FIND v(dout0_209) AT=690.025n

.meas tran vdout0_210ck1370 FIND v(dout0_210) AT=690.025n

.meas tran vdout0_211ck1370 FIND v(dout0_211) AT=690.025n

.meas tran vdout0_212ck1370 FIND v(dout0_212) AT=690.025n

.meas tran vdout0_213ck1370 FIND v(dout0_213) AT=690.025n

.meas tran vdout0_214ck1370 FIND v(dout0_214) AT=690.025n

.meas tran vdout0_215ck1370 FIND v(dout0_215) AT=690.025n

.meas tran vdout0_216ck1370 FIND v(dout0_216) AT=690.025n

.meas tran vdout0_217ck1370 FIND v(dout0_217) AT=690.025n

.meas tran vdout0_218ck1370 FIND v(dout0_218) AT=690.025n

.meas tran vdout0_219ck1370 FIND v(dout0_219) AT=690.025n

.meas tran vdout0_220ck1370 FIND v(dout0_220) AT=690.025n

.meas tran vdout0_221ck1370 FIND v(dout0_221) AT=690.025n

.meas tran vdout0_222ck1370 FIND v(dout0_222) AT=690.025n

.meas tran vdout0_223ck1370 FIND v(dout0_223) AT=690.025n

.meas tran vdout0_224ck1370 FIND v(dout0_224) AT=690.025n

.meas tran vdout0_225ck1370 FIND v(dout0_225) AT=690.025n

.meas tran vdout0_226ck1370 FIND v(dout0_226) AT=690.025n

.meas tran vdout0_227ck1370 FIND v(dout0_227) AT=690.025n

.meas tran vdout0_228ck1370 FIND v(dout0_228) AT=690.025n

.meas tran vdout0_229ck1370 FIND v(dout0_229) AT=690.025n

.meas tran vdout0_230ck1370 FIND v(dout0_230) AT=690.025n

.meas tran vdout0_231ck1370 FIND v(dout0_231) AT=690.025n

.meas tran vdout0_232ck1370 FIND v(dout0_232) AT=690.025n

.meas tran vdout0_233ck1370 FIND v(dout0_233) AT=690.025n

.meas tran vdout0_234ck1370 FIND v(dout0_234) AT=690.025n

.meas tran vdout0_235ck1370 FIND v(dout0_235) AT=690.025n

.meas tran vdout0_236ck1370 FIND v(dout0_236) AT=690.025n

.meas tran vdout0_237ck1370 FIND v(dout0_237) AT=690.025n

.meas tran vdout0_238ck1370 FIND v(dout0_238) AT=690.025n

.meas tran vdout0_239ck1370 FIND v(dout0_239) AT=690.025n

.meas tran vdout0_240ck1370 FIND v(dout0_240) AT=690.025n

.meas tran vdout0_241ck1370 FIND v(dout0_241) AT=690.025n

.meas tran vdout0_242ck1370 FIND v(dout0_242) AT=690.025n

.meas tran vdout0_243ck1370 FIND v(dout0_243) AT=690.025n

.meas tran vdout0_244ck1370 FIND v(dout0_244) AT=690.025n

.meas tran vdout0_245ck1370 FIND v(dout0_245) AT=690.025n

.meas tran vdout0_246ck1370 FIND v(dout0_246) AT=690.025n

.meas tran vdout0_247ck1370 FIND v(dout0_247) AT=690.025n

.meas tran vdout0_248ck1370 FIND v(dout0_248) AT=690.025n

.meas tran vdout0_249ck1370 FIND v(dout0_249) AT=690.025n

.meas tran vdout0_250ck1370 FIND v(dout0_250) AT=690.025n

.meas tran vdout0_251ck1370 FIND v(dout0_251) AT=690.025n

.meas tran vdout0_252ck1370 FIND v(dout0_252) AT=690.025n

.meas tran vdout0_253ck1370 FIND v(dout0_253) AT=690.025n

.meas tran vdout0_254ck1370 FIND v(dout0_254) AT=690.025n

.meas tran vdout0_255ck1370 FIND v(dout0_255) AT=690.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_128ck1400 FIND v(dout0_128) AT=705.025n

.meas tran vdout0_129ck1400 FIND v(dout0_129) AT=705.025n

.meas tran vdout0_130ck1400 FIND v(dout0_130) AT=705.025n

.meas tran vdout0_131ck1400 FIND v(dout0_131) AT=705.025n

.meas tran vdout0_132ck1400 FIND v(dout0_132) AT=705.025n

.meas tran vdout0_133ck1400 FIND v(dout0_133) AT=705.025n

.meas tran vdout0_134ck1400 FIND v(dout0_134) AT=705.025n

.meas tran vdout0_135ck1400 FIND v(dout0_135) AT=705.025n

.meas tran vdout0_136ck1400 FIND v(dout0_136) AT=705.025n

.meas tran vdout0_137ck1400 FIND v(dout0_137) AT=705.025n

.meas tran vdout0_138ck1400 FIND v(dout0_138) AT=705.025n

.meas tran vdout0_139ck1400 FIND v(dout0_139) AT=705.025n

.meas tran vdout0_140ck1400 FIND v(dout0_140) AT=705.025n

.meas tran vdout0_141ck1400 FIND v(dout0_141) AT=705.025n

.meas tran vdout0_142ck1400 FIND v(dout0_142) AT=705.025n

.meas tran vdout0_143ck1400 FIND v(dout0_143) AT=705.025n

.meas tran vdout0_144ck1400 FIND v(dout0_144) AT=705.025n

.meas tran vdout0_145ck1400 FIND v(dout0_145) AT=705.025n

.meas tran vdout0_146ck1400 FIND v(dout0_146) AT=705.025n

.meas tran vdout0_147ck1400 FIND v(dout0_147) AT=705.025n

.meas tran vdout0_148ck1400 FIND v(dout0_148) AT=705.025n

.meas tran vdout0_149ck1400 FIND v(dout0_149) AT=705.025n

.meas tran vdout0_150ck1400 FIND v(dout0_150) AT=705.025n

.meas tran vdout0_151ck1400 FIND v(dout0_151) AT=705.025n

.meas tran vdout0_152ck1400 FIND v(dout0_152) AT=705.025n

.meas tran vdout0_153ck1400 FIND v(dout0_153) AT=705.025n

.meas tran vdout0_154ck1400 FIND v(dout0_154) AT=705.025n

.meas tran vdout0_155ck1400 FIND v(dout0_155) AT=705.025n

.meas tran vdout0_156ck1400 FIND v(dout0_156) AT=705.025n

.meas tran vdout0_157ck1400 FIND v(dout0_157) AT=705.025n

.meas tran vdout0_158ck1400 FIND v(dout0_158) AT=705.025n

.meas tran vdout0_159ck1400 FIND v(dout0_159) AT=705.025n

.meas tran vdout0_160ck1400 FIND v(dout0_160) AT=705.025n

.meas tran vdout0_161ck1400 FIND v(dout0_161) AT=705.025n

.meas tran vdout0_162ck1400 FIND v(dout0_162) AT=705.025n

.meas tran vdout0_163ck1400 FIND v(dout0_163) AT=705.025n

.meas tran vdout0_164ck1400 FIND v(dout0_164) AT=705.025n

.meas tran vdout0_165ck1400 FIND v(dout0_165) AT=705.025n

.meas tran vdout0_166ck1400 FIND v(dout0_166) AT=705.025n

.meas tran vdout0_167ck1400 FIND v(dout0_167) AT=705.025n

.meas tran vdout0_168ck1400 FIND v(dout0_168) AT=705.025n

.meas tran vdout0_169ck1400 FIND v(dout0_169) AT=705.025n

.meas tran vdout0_170ck1400 FIND v(dout0_170) AT=705.025n

.meas tran vdout0_171ck1400 FIND v(dout0_171) AT=705.025n

.meas tran vdout0_172ck1400 FIND v(dout0_172) AT=705.025n

.meas tran vdout0_173ck1400 FIND v(dout0_173) AT=705.025n

.meas tran vdout0_174ck1400 FIND v(dout0_174) AT=705.025n

.meas tran vdout0_175ck1400 FIND v(dout0_175) AT=705.025n

.meas tran vdout0_176ck1400 FIND v(dout0_176) AT=705.025n

.meas tran vdout0_177ck1400 FIND v(dout0_177) AT=705.025n

.meas tran vdout0_178ck1400 FIND v(dout0_178) AT=705.025n

.meas tran vdout0_179ck1400 FIND v(dout0_179) AT=705.025n

.meas tran vdout0_180ck1400 FIND v(dout0_180) AT=705.025n

.meas tran vdout0_181ck1400 FIND v(dout0_181) AT=705.025n

.meas tran vdout0_182ck1400 FIND v(dout0_182) AT=705.025n

.meas tran vdout0_183ck1400 FIND v(dout0_183) AT=705.025n

.meas tran vdout0_184ck1400 FIND v(dout0_184) AT=705.025n

.meas tran vdout0_185ck1400 FIND v(dout0_185) AT=705.025n

.meas tran vdout0_186ck1400 FIND v(dout0_186) AT=705.025n

.meas tran vdout0_187ck1400 FIND v(dout0_187) AT=705.025n

.meas tran vdout0_188ck1400 FIND v(dout0_188) AT=705.025n

.meas tran vdout0_189ck1400 FIND v(dout0_189) AT=705.025n

.meas tran vdout0_190ck1400 FIND v(dout0_190) AT=705.025n

.meas tran vdout0_191ck1400 FIND v(dout0_191) AT=705.025n

.meas tran vdout0_192ck1400 FIND v(dout0_192) AT=705.025n

.meas tran vdout0_193ck1400 FIND v(dout0_193) AT=705.025n

.meas tran vdout0_194ck1400 FIND v(dout0_194) AT=705.025n

.meas tran vdout0_195ck1400 FIND v(dout0_195) AT=705.025n

.meas tran vdout0_196ck1400 FIND v(dout0_196) AT=705.025n

.meas tran vdout0_197ck1400 FIND v(dout0_197) AT=705.025n

.meas tran vdout0_198ck1400 FIND v(dout0_198) AT=705.025n

.meas tran vdout0_199ck1400 FIND v(dout0_199) AT=705.025n

.meas tran vdout0_200ck1400 FIND v(dout0_200) AT=705.025n

.meas tran vdout0_201ck1400 FIND v(dout0_201) AT=705.025n

.meas tran vdout0_202ck1400 FIND v(dout0_202) AT=705.025n

.meas tran vdout0_203ck1400 FIND v(dout0_203) AT=705.025n

.meas tran vdout0_204ck1400 FIND v(dout0_204) AT=705.025n

.meas tran vdout0_205ck1400 FIND v(dout0_205) AT=705.025n

.meas tran vdout0_206ck1400 FIND v(dout0_206) AT=705.025n

.meas tran vdout0_207ck1400 FIND v(dout0_207) AT=705.025n

.meas tran vdout0_208ck1400 FIND v(dout0_208) AT=705.025n

.meas tran vdout0_209ck1400 FIND v(dout0_209) AT=705.025n

.meas tran vdout0_210ck1400 FIND v(dout0_210) AT=705.025n

.meas tran vdout0_211ck1400 FIND v(dout0_211) AT=705.025n

.meas tran vdout0_212ck1400 FIND v(dout0_212) AT=705.025n

.meas tran vdout0_213ck1400 FIND v(dout0_213) AT=705.025n

.meas tran vdout0_214ck1400 FIND v(dout0_214) AT=705.025n

.meas tran vdout0_215ck1400 FIND v(dout0_215) AT=705.025n

.meas tran vdout0_216ck1400 FIND v(dout0_216) AT=705.025n

.meas tran vdout0_217ck1400 FIND v(dout0_217) AT=705.025n

.meas tran vdout0_218ck1400 FIND v(dout0_218) AT=705.025n

.meas tran vdout0_219ck1400 FIND v(dout0_219) AT=705.025n

.meas tran vdout0_220ck1400 FIND v(dout0_220) AT=705.025n

.meas tran vdout0_221ck1400 FIND v(dout0_221) AT=705.025n

.meas tran vdout0_222ck1400 FIND v(dout0_222) AT=705.025n

.meas tran vdout0_223ck1400 FIND v(dout0_223) AT=705.025n

.meas tran vdout0_224ck1400 FIND v(dout0_224) AT=705.025n

.meas tran vdout0_225ck1400 FIND v(dout0_225) AT=705.025n

.meas tran vdout0_226ck1400 FIND v(dout0_226) AT=705.025n

.meas tran vdout0_227ck1400 FIND v(dout0_227) AT=705.025n

.meas tran vdout0_228ck1400 FIND v(dout0_228) AT=705.025n

.meas tran vdout0_229ck1400 FIND v(dout0_229) AT=705.025n

.meas tran vdout0_230ck1400 FIND v(dout0_230) AT=705.025n

.meas tran vdout0_231ck1400 FIND v(dout0_231) AT=705.025n

.meas tran vdout0_232ck1400 FIND v(dout0_232) AT=705.025n

.meas tran vdout0_233ck1400 FIND v(dout0_233) AT=705.025n

.meas tran vdout0_234ck1400 FIND v(dout0_234) AT=705.025n

.meas tran vdout0_235ck1400 FIND v(dout0_235) AT=705.025n

.meas tran vdout0_236ck1400 FIND v(dout0_236) AT=705.025n

.meas tran vdout0_237ck1400 FIND v(dout0_237) AT=705.025n

.meas tran vdout0_238ck1400 FIND v(dout0_238) AT=705.025n

.meas tran vdout0_239ck1400 FIND v(dout0_239) AT=705.025n

.meas tran vdout0_240ck1400 FIND v(dout0_240) AT=705.025n

.meas tran vdout0_241ck1400 FIND v(dout0_241) AT=705.025n

.meas tran vdout0_242ck1400 FIND v(dout0_242) AT=705.025n

.meas tran vdout0_243ck1400 FIND v(dout0_243) AT=705.025n

.meas tran vdout0_244ck1400 FIND v(dout0_244) AT=705.025n

.meas tran vdout0_245ck1400 FIND v(dout0_245) AT=705.025n

.meas tran vdout0_246ck1400 FIND v(dout0_246) AT=705.025n

.meas tran vdout0_247ck1400 FIND v(dout0_247) AT=705.025n

.meas tran vdout0_248ck1400 FIND v(dout0_248) AT=705.025n

.meas tran vdout0_249ck1400 FIND v(dout0_249) AT=705.025n

.meas tran vdout0_250ck1400 FIND v(dout0_250) AT=705.025n

.meas tran vdout0_251ck1400 FIND v(dout0_251) AT=705.025n

.meas tran vdout0_252ck1400 FIND v(dout0_252) AT=705.025n

.meas tran vdout0_253ck1400 FIND v(dout0_253) AT=705.025n

.meas tran vdout0_254ck1400 FIND v(dout0_254) AT=705.025n

.meas tran vdout0_255ck1400 FIND v(dout0_255) AT=705.025n

.meas tran vdout0_0ck1450 FIND v(dout0_0) AT=730.025n

.meas tran vdout0_1ck1450 FIND v(dout0_1) AT=730.025n

.meas tran vdout0_2ck1450 FIND v(dout0_2) AT=730.025n

.meas tran vdout0_3ck1450 FIND v(dout0_3) AT=730.025n

.meas tran vdout0_4ck1450 FIND v(dout0_4) AT=730.025n

.meas tran vdout0_5ck1450 FIND v(dout0_5) AT=730.025n

.meas tran vdout0_6ck1450 FIND v(dout0_6) AT=730.025n

.meas tran vdout0_7ck1450 FIND v(dout0_7) AT=730.025n

.meas tran vdout0_8ck1450 FIND v(dout0_8) AT=730.025n

.meas tran vdout0_9ck1450 FIND v(dout0_9) AT=730.025n

.meas tran vdout0_10ck1450 FIND v(dout0_10) AT=730.025n

.meas tran vdout0_11ck1450 FIND v(dout0_11) AT=730.025n

.meas tran vdout0_12ck1450 FIND v(dout0_12) AT=730.025n

.meas tran vdout0_13ck1450 FIND v(dout0_13) AT=730.025n

.meas tran vdout0_14ck1450 FIND v(dout0_14) AT=730.025n

.meas tran vdout0_15ck1450 FIND v(dout0_15) AT=730.025n

.meas tran vdout0_16ck1450 FIND v(dout0_16) AT=730.025n

.meas tran vdout0_17ck1450 FIND v(dout0_17) AT=730.025n

.meas tran vdout0_18ck1450 FIND v(dout0_18) AT=730.025n

.meas tran vdout0_19ck1450 FIND v(dout0_19) AT=730.025n

.meas tran vdout0_20ck1450 FIND v(dout0_20) AT=730.025n

.meas tran vdout0_21ck1450 FIND v(dout0_21) AT=730.025n

.meas tran vdout0_22ck1450 FIND v(dout0_22) AT=730.025n

.meas tran vdout0_23ck1450 FIND v(dout0_23) AT=730.025n

.meas tran vdout0_24ck1450 FIND v(dout0_24) AT=730.025n

.meas tran vdout0_25ck1450 FIND v(dout0_25) AT=730.025n

.meas tran vdout0_26ck1450 FIND v(dout0_26) AT=730.025n

.meas tran vdout0_27ck1450 FIND v(dout0_27) AT=730.025n

.meas tran vdout0_28ck1450 FIND v(dout0_28) AT=730.025n

.meas tran vdout0_29ck1450 FIND v(dout0_29) AT=730.025n

.meas tran vdout0_30ck1450 FIND v(dout0_30) AT=730.025n

.meas tran vdout0_31ck1450 FIND v(dout0_31) AT=730.025n

.meas tran vdout0_32ck1450 FIND v(dout0_32) AT=730.025n

.meas tran vdout0_33ck1450 FIND v(dout0_33) AT=730.025n

.meas tran vdout0_34ck1450 FIND v(dout0_34) AT=730.025n

.meas tran vdout0_35ck1450 FIND v(dout0_35) AT=730.025n

.meas tran vdout0_36ck1450 FIND v(dout0_36) AT=730.025n

.meas tran vdout0_37ck1450 FIND v(dout0_37) AT=730.025n

.meas tran vdout0_38ck1450 FIND v(dout0_38) AT=730.025n

.meas tran vdout0_39ck1450 FIND v(dout0_39) AT=730.025n

.meas tran vdout0_40ck1450 FIND v(dout0_40) AT=730.025n

.meas tran vdout0_41ck1450 FIND v(dout0_41) AT=730.025n

.meas tran vdout0_42ck1450 FIND v(dout0_42) AT=730.025n

.meas tran vdout0_43ck1450 FIND v(dout0_43) AT=730.025n

.meas tran vdout0_44ck1450 FIND v(dout0_44) AT=730.025n

.meas tran vdout0_45ck1450 FIND v(dout0_45) AT=730.025n

.meas tran vdout0_46ck1450 FIND v(dout0_46) AT=730.025n

.meas tran vdout0_47ck1450 FIND v(dout0_47) AT=730.025n

.meas tran vdout0_48ck1450 FIND v(dout0_48) AT=730.025n

.meas tran vdout0_49ck1450 FIND v(dout0_49) AT=730.025n

.meas tran vdout0_50ck1450 FIND v(dout0_50) AT=730.025n

.meas tran vdout0_51ck1450 FIND v(dout0_51) AT=730.025n

.meas tran vdout0_52ck1450 FIND v(dout0_52) AT=730.025n

.meas tran vdout0_53ck1450 FIND v(dout0_53) AT=730.025n

.meas tran vdout0_54ck1450 FIND v(dout0_54) AT=730.025n

.meas tran vdout0_55ck1450 FIND v(dout0_55) AT=730.025n

.meas tran vdout0_56ck1450 FIND v(dout0_56) AT=730.025n

.meas tran vdout0_57ck1450 FIND v(dout0_57) AT=730.025n

.meas tran vdout0_58ck1450 FIND v(dout0_58) AT=730.025n

.meas tran vdout0_59ck1450 FIND v(dout0_59) AT=730.025n

.meas tran vdout0_60ck1450 FIND v(dout0_60) AT=730.025n

.meas tran vdout0_61ck1450 FIND v(dout0_61) AT=730.025n

.meas tran vdout0_62ck1450 FIND v(dout0_62) AT=730.025n

.meas tran vdout0_63ck1450 FIND v(dout0_63) AT=730.025n

.meas tran vdout0_64ck1450 FIND v(dout0_64) AT=730.025n

.meas tran vdout0_65ck1450 FIND v(dout0_65) AT=730.025n

.meas tran vdout0_66ck1450 FIND v(dout0_66) AT=730.025n

.meas tran vdout0_67ck1450 FIND v(dout0_67) AT=730.025n

.meas tran vdout0_68ck1450 FIND v(dout0_68) AT=730.025n

.meas tran vdout0_69ck1450 FIND v(dout0_69) AT=730.025n

.meas tran vdout0_70ck1450 FIND v(dout0_70) AT=730.025n

.meas tran vdout0_71ck1450 FIND v(dout0_71) AT=730.025n

.meas tran vdout0_72ck1450 FIND v(dout0_72) AT=730.025n

.meas tran vdout0_73ck1450 FIND v(dout0_73) AT=730.025n

.meas tran vdout0_74ck1450 FIND v(dout0_74) AT=730.025n

.meas tran vdout0_75ck1450 FIND v(dout0_75) AT=730.025n

.meas tran vdout0_76ck1450 FIND v(dout0_76) AT=730.025n

.meas tran vdout0_77ck1450 FIND v(dout0_77) AT=730.025n

.meas tran vdout0_78ck1450 FIND v(dout0_78) AT=730.025n

.meas tran vdout0_79ck1450 FIND v(dout0_79) AT=730.025n

.meas tran vdout0_80ck1450 FIND v(dout0_80) AT=730.025n

.meas tran vdout0_81ck1450 FIND v(dout0_81) AT=730.025n

.meas tran vdout0_82ck1450 FIND v(dout0_82) AT=730.025n

.meas tran vdout0_83ck1450 FIND v(dout0_83) AT=730.025n

.meas tran vdout0_84ck1450 FIND v(dout0_84) AT=730.025n

.meas tran vdout0_85ck1450 FIND v(dout0_85) AT=730.025n

.meas tran vdout0_86ck1450 FIND v(dout0_86) AT=730.025n

.meas tran vdout0_87ck1450 FIND v(dout0_87) AT=730.025n

.meas tran vdout0_88ck1450 FIND v(dout0_88) AT=730.025n

.meas tran vdout0_89ck1450 FIND v(dout0_89) AT=730.025n

.meas tran vdout0_90ck1450 FIND v(dout0_90) AT=730.025n

.meas tran vdout0_91ck1450 FIND v(dout0_91) AT=730.025n

.meas tran vdout0_92ck1450 FIND v(dout0_92) AT=730.025n

.meas tran vdout0_93ck1450 FIND v(dout0_93) AT=730.025n

.meas tran vdout0_94ck1450 FIND v(dout0_94) AT=730.025n

.meas tran vdout0_95ck1450 FIND v(dout0_95) AT=730.025n

.meas tran vdout0_96ck1450 FIND v(dout0_96) AT=730.025n

.meas tran vdout0_97ck1450 FIND v(dout0_97) AT=730.025n

.meas tran vdout0_98ck1450 FIND v(dout0_98) AT=730.025n

.meas tran vdout0_99ck1450 FIND v(dout0_99) AT=730.025n

.meas tran vdout0_100ck1450 FIND v(dout0_100) AT=730.025n

.meas tran vdout0_101ck1450 FIND v(dout0_101) AT=730.025n

.meas tran vdout0_102ck1450 FIND v(dout0_102) AT=730.025n

.meas tran vdout0_103ck1450 FIND v(dout0_103) AT=730.025n

.meas tran vdout0_104ck1450 FIND v(dout0_104) AT=730.025n

.meas tran vdout0_105ck1450 FIND v(dout0_105) AT=730.025n

.meas tran vdout0_106ck1450 FIND v(dout0_106) AT=730.025n

.meas tran vdout0_107ck1450 FIND v(dout0_107) AT=730.025n

.meas tran vdout0_108ck1450 FIND v(dout0_108) AT=730.025n

.meas tran vdout0_109ck1450 FIND v(dout0_109) AT=730.025n

.meas tran vdout0_110ck1450 FIND v(dout0_110) AT=730.025n

.meas tran vdout0_111ck1450 FIND v(dout0_111) AT=730.025n

.meas tran vdout0_112ck1450 FIND v(dout0_112) AT=730.025n

.meas tran vdout0_113ck1450 FIND v(dout0_113) AT=730.025n

.meas tran vdout0_114ck1450 FIND v(dout0_114) AT=730.025n

.meas tran vdout0_115ck1450 FIND v(dout0_115) AT=730.025n

.meas tran vdout0_116ck1450 FIND v(dout0_116) AT=730.025n

.meas tran vdout0_117ck1450 FIND v(dout0_117) AT=730.025n

.meas tran vdout0_118ck1450 FIND v(dout0_118) AT=730.025n

.meas tran vdout0_119ck1450 FIND v(dout0_119) AT=730.025n

.meas tran vdout0_120ck1450 FIND v(dout0_120) AT=730.025n

.meas tran vdout0_121ck1450 FIND v(dout0_121) AT=730.025n

.meas tran vdout0_122ck1450 FIND v(dout0_122) AT=730.025n

.meas tran vdout0_123ck1450 FIND v(dout0_123) AT=730.025n

.meas tran vdout0_124ck1450 FIND v(dout0_124) AT=730.025n

.meas tran vdout0_125ck1450 FIND v(dout0_125) AT=730.025n

.meas tran vdout0_126ck1450 FIND v(dout0_126) AT=730.025n

.meas tran vdout0_127ck1450 FIND v(dout0_127) AT=730.025n

.meas tran vdout0_128ck1450 FIND v(dout0_128) AT=730.025n

.meas tran vdout0_129ck1450 FIND v(dout0_129) AT=730.025n

.meas tran vdout0_130ck1450 FIND v(dout0_130) AT=730.025n

.meas tran vdout0_131ck1450 FIND v(dout0_131) AT=730.025n

.meas tran vdout0_132ck1450 FIND v(dout0_132) AT=730.025n

.meas tran vdout0_133ck1450 FIND v(dout0_133) AT=730.025n

.meas tran vdout0_134ck1450 FIND v(dout0_134) AT=730.025n

.meas tran vdout0_135ck1450 FIND v(dout0_135) AT=730.025n

.meas tran vdout0_136ck1450 FIND v(dout0_136) AT=730.025n

.meas tran vdout0_137ck1450 FIND v(dout0_137) AT=730.025n

.meas tran vdout0_138ck1450 FIND v(dout0_138) AT=730.025n

.meas tran vdout0_139ck1450 FIND v(dout0_139) AT=730.025n

.meas tran vdout0_140ck1450 FIND v(dout0_140) AT=730.025n

.meas tran vdout0_141ck1450 FIND v(dout0_141) AT=730.025n

.meas tran vdout0_142ck1450 FIND v(dout0_142) AT=730.025n

.meas tran vdout0_143ck1450 FIND v(dout0_143) AT=730.025n

.meas tran vdout0_144ck1450 FIND v(dout0_144) AT=730.025n

.meas tran vdout0_145ck1450 FIND v(dout0_145) AT=730.025n

.meas tran vdout0_146ck1450 FIND v(dout0_146) AT=730.025n

.meas tran vdout0_147ck1450 FIND v(dout0_147) AT=730.025n

.meas tran vdout0_148ck1450 FIND v(dout0_148) AT=730.025n

.meas tran vdout0_149ck1450 FIND v(dout0_149) AT=730.025n

.meas tran vdout0_150ck1450 FIND v(dout0_150) AT=730.025n

.meas tran vdout0_151ck1450 FIND v(dout0_151) AT=730.025n

.meas tran vdout0_152ck1450 FIND v(dout0_152) AT=730.025n

.meas tran vdout0_153ck1450 FIND v(dout0_153) AT=730.025n

.meas tran vdout0_154ck1450 FIND v(dout0_154) AT=730.025n

.meas tran vdout0_155ck1450 FIND v(dout0_155) AT=730.025n

.meas tran vdout0_156ck1450 FIND v(dout0_156) AT=730.025n

.meas tran vdout0_157ck1450 FIND v(dout0_157) AT=730.025n

.meas tran vdout0_158ck1450 FIND v(dout0_158) AT=730.025n

.meas tran vdout0_159ck1450 FIND v(dout0_159) AT=730.025n

.meas tran vdout0_160ck1450 FIND v(dout0_160) AT=730.025n

.meas tran vdout0_161ck1450 FIND v(dout0_161) AT=730.025n

.meas tran vdout0_162ck1450 FIND v(dout0_162) AT=730.025n

.meas tran vdout0_163ck1450 FIND v(dout0_163) AT=730.025n

.meas tran vdout0_164ck1450 FIND v(dout0_164) AT=730.025n

.meas tran vdout0_165ck1450 FIND v(dout0_165) AT=730.025n

.meas tran vdout0_166ck1450 FIND v(dout0_166) AT=730.025n

.meas tran vdout0_167ck1450 FIND v(dout0_167) AT=730.025n

.meas tran vdout0_168ck1450 FIND v(dout0_168) AT=730.025n

.meas tran vdout0_169ck1450 FIND v(dout0_169) AT=730.025n

.meas tran vdout0_170ck1450 FIND v(dout0_170) AT=730.025n

.meas tran vdout0_171ck1450 FIND v(dout0_171) AT=730.025n

.meas tran vdout0_172ck1450 FIND v(dout0_172) AT=730.025n

.meas tran vdout0_173ck1450 FIND v(dout0_173) AT=730.025n

.meas tran vdout0_174ck1450 FIND v(dout0_174) AT=730.025n

.meas tran vdout0_175ck1450 FIND v(dout0_175) AT=730.025n

.meas tran vdout0_176ck1450 FIND v(dout0_176) AT=730.025n

.meas tran vdout0_177ck1450 FIND v(dout0_177) AT=730.025n

.meas tran vdout0_178ck1450 FIND v(dout0_178) AT=730.025n

.meas tran vdout0_179ck1450 FIND v(dout0_179) AT=730.025n

.meas tran vdout0_180ck1450 FIND v(dout0_180) AT=730.025n

.meas tran vdout0_181ck1450 FIND v(dout0_181) AT=730.025n

.meas tran vdout0_182ck1450 FIND v(dout0_182) AT=730.025n

.meas tran vdout0_183ck1450 FIND v(dout0_183) AT=730.025n

.meas tran vdout0_184ck1450 FIND v(dout0_184) AT=730.025n

.meas tran vdout0_185ck1450 FIND v(dout0_185) AT=730.025n

.meas tran vdout0_186ck1450 FIND v(dout0_186) AT=730.025n

.meas tran vdout0_187ck1450 FIND v(dout0_187) AT=730.025n

.meas tran vdout0_188ck1450 FIND v(dout0_188) AT=730.025n

.meas tran vdout0_189ck1450 FIND v(dout0_189) AT=730.025n

.meas tran vdout0_190ck1450 FIND v(dout0_190) AT=730.025n

.meas tran vdout0_191ck1450 FIND v(dout0_191) AT=730.025n

.meas tran vdout0_192ck1450 FIND v(dout0_192) AT=730.025n

.meas tran vdout0_193ck1450 FIND v(dout0_193) AT=730.025n

.meas tran vdout0_194ck1450 FIND v(dout0_194) AT=730.025n

.meas tran vdout0_195ck1450 FIND v(dout0_195) AT=730.025n

.meas tran vdout0_196ck1450 FIND v(dout0_196) AT=730.025n

.meas tran vdout0_197ck1450 FIND v(dout0_197) AT=730.025n

.meas tran vdout0_198ck1450 FIND v(dout0_198) AT=730.025n

.meas tran vdout0_199ck1450 FIND v(dout0_199) AT=730.025n

.meas tran vdout0_200ck1450 FIND v(dout0_200) AT=730.025n

.meas tran vdout0_201ck1450 FIND v(dout0_201) AT=730.025n

.meas tran vdout0_202ck1450 FIND v(dout0_202) AT=730.025n

.meas tran vdout0_203ck1450 FIND v(dout0_203) AT=730.025n

.meas tran vdout0_204ck1450 FIND v(dout0_204) AT=730.025n

.meas tran vdout0_205ck1450 FIND v(dout0_205) AT=730.025n

.meas tran vdout0_206ck1450 FIND v(dout0_206) AT=730.025n

.meas tran vdout0_207ck1450 FIND v(dout0_207) AT=730.025n

.meas tran vdout0_208ck1450 FIND v(dout0_208) AT=730.025n

.meas tran vdout0_209ck1450 FIND v(dout0_209) AT=730.025n

.meas tran vdout0_210ck1450 FIND v(dout0_210) AT=730.025n

.meas tran vdout0_211ck1450 FIND v(dout0_211) AT=730.025n

.meas tran vdout0_212ck1450 FIND v(dout0_212) AT=730.025n

.meas tran vdout0_213ck1450 FIND v(dout0_213) AT=730.025n

.meas tran vdout0_214ck1450 FIND v(dout0_214) AT=730.025n

.meas tran vdout0_215ck1450 FIND v(dout0_215) AT=730.025n

.meas tran vdout0_216ck1450 FIND v(dout0_216) AT=730.025n

.meas tran vdout0_217ck1450 FIND v(dout0_217) AT=730.025n

.meas tran vdout0_218ck1450 FIND v(dout0_218) AT=730.025n

.meas tran vdout0_219ck1450 FIND v(dout0_219) AT=730.025n

.meas tran vdout0_220ck1450 FIND v(dout0_220) AT=730.025n

.meas tran vdout0_221ck1450 FIND v(dout0_221) AT=730.025n

.meas tran vdout0_222ck1450 FIND v(dout0_222) AT=730.025n

.meas tran vdout0_223ck1450 FIND v(dout0_223) AT=730.025n

.meas tran vdout0_224ck1450 FIND v(dout0_224) AT=730.025n

.meas tran vdout0_225ck1450 FIND v(dout0_225) AT=730.025n

.meas tran vdout0_226ck1450 FIND v(dout0_226) AT=730.025n

.meas tran vdout0_227ck1450 FIND v(dout0_227) AT=730.025n

.meas tran vdout0_228ck1450 FIND v(dout0_228) AT=730.025n

.meas tran vdout0_229ck1450 FIND v(dout0_229) AT=730.025n

.meas tran vdout0_230ck1450 FIND v(dout0_230) AT=730.025n

.meas tran vdout0_231ck1450 FIND v(dout0_231) AT=730.025n

.meas tran vdout0_232ck1450 FIND v(dout0_232) AT=730.025n

.meas tran vdout0_233ck1450 FIND v(dout0_233) AT=730.025n

.meas tran vdout0_234ck1450 FIND v(dout0_234) AT=730.025n

.meas tran vdout0_235ck1450 FIND v(dout0_235) AT=730.025n

.meas tran vdout0_236ck1450 FIND v(dout0_236) AT=730.025n

.meas tran vdout0_237ck1450 FIND v(dout0_237) AT=730.025n

.meas tran vdout0_238ck1450 FIND v(dout0_238) AT=730.025n

.meas tran vdout0_239ck1450 FIND v(dout0_239) AT=730.025n

.meas tran vdout0_240ck1450 FIND v(dout0_240) AT=730.025n

.meas tran vdout0_241ck1450 FIND v(dout0_241) AT=730.025n

.meas tran vdout0_242ck1450 FIND v(dout0_242) AT=730.025n

.meas tran vdout0_243ck1450 FIND v(dout0_243) AT=730.025n

.meas tran vdout0_244ck1450 FIND v(dout0_244) AT=730.025n

.meas tran vdout0_245ck1450 FIND v(dout0_245) AT=730.025n

.meas tran vdout0_246ck1450 FIND v(dout0_246) AT=730.025n

.meas tran vdout0_247ck1450 FIND v(dout0_247) AT=730.025n

.meas tran vdout0_248ck1450 FIND v(dout0_248) AT=730.025n

.meas tran vdout0_249ck1450 FIND v(dout0_249) AT=730.025n

.meas tran vdout0_250ck1450 FIND v(dout0_250) AT=730.025n

.meas tran vdout0_251ck1450 FIND v(dout0_251) AT=730.025n

.meas tran vdout0_252ck1450 FIND v(dout0_252) AT=730.025n

.meas tran vdout0_253ck1450 FIND v(dout0_253) AT=730.025n

.meas tran vdout0_254ck1450 FIND v(dout0_254) AT=730.025n

.meas tran vdout0_255ck1450 FIND v(dout0_255) AT=730.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_128ck1460 FIND v(dout0_128) AT=735.025n

.meas tran vdout0_129ck1460 FIND v(dout0_129) AT=735.025n

.meas tran vdout0_130ck1460 FIND v(dout0_130) AT=735.025n

.meas tran vdout0_131ck1460 FIND v(dout0_131) AT=735.025n

.meas tran vdout0_132ck1460 FIND v(dout0_132) AT=735.025n

.meas tran vdout0_133ck1460 FIND v(dout0_133) AT=735.025n

.meas tran vdout0_134ck1460 FIND v(dout0_134) AT=735.025n

.meas tran vdout0_135ck1460 FIND v(dout0_135) AT=735.025n

.meas tran vdout0_136ck1460 FIND v(dout0_136) AT=735.025n

.meas tran vdout0_137ck1460 FIND v(dout0_137) AT=735.025n

.meas tran vdout0_138ck1460 FIND v(dout0_138) AT=735.025n

.meas tran vdout0_139ck1460 FIND v(dout0_139) AT=735.025n

.meas tran vdout0_140ck1460 FIND v(dout0_140) AT=735.025n

.meas tran vdout0_141ck1460 FIND v(dout0_141) AT=735.025n

.meas tran vdout0_142ck1460 FIND v(dout0_142) AT=735.025n

.meas tran vdout0_143ck1460 FIND v(dout0_143) AT=735.025n

.meas tran vdout0_144ck1460 FIND v(dout0_144) AT=735.025n

.meas tran vdout0_145ck1460 FIND v(dout0_145) AT=735.025n

.meas tran vdout0_146ck1460 FIND v(dout0_146) AT=735.025n

.meas tran vdout0_147ck1460 FIND v(dout0_147) AT=735.025n

.meas tran vdout0_148ck1460 FIND v(dout0_148) AT=735.025n

.meas tran vdout0_149ck1460 FIND v(dout0_149) AT=735.025n

.meas tran vdout0_150ck1460 FIND v(dout0_150) AT=735.025n

.meas tran vdout0_151ck1460 FIND v(dout0_151) AT=735.025n

.meas tran vdout0_152ck1460 FIND v(dout0_152) AT=735.025n

.meas tran vdout0_153ck1460 FIND v(dout0_153) AT=735.025n

.meas tran vdout0_154ck1460 FIND v(dout0_154) AT=735.025n

.meas tran vdout0_155ck1460 FIND v(dout0_155) AT=735.025n

.meas tran vdout0_156ck1460 FIND v(dout0_156) AT=735.025n

.meas tran vdout0_157ck1460 FIND v(dout0_157) AT=735.025n

.meas tran vdout0_158ck1460 FIND v(dout0_158) AT=735.025n

.meas tran vdout0_159ck1460 FIND v(dout0_159) AT=735.025n

.meas tran vdout0_160ck1460 FIND v(dout0_160) AT=735.025n

.meas tran vdout0_161ck1460 FIND v(dout0_161) AT=735.025n

.meas tran vdout0_162ck1460 FIND v(dout0_162) AT=735.025n

.meas tran vdout0_163ck1460 FIND v(dout0_163) AT=735.025n

.meas tran vdout0_164ck1460 FIND v(dout0_164) AT=735.025n

.meas tran vdout0_165ck1460 FIND v(dout0_165) AT=735.025n

.meas tran vdout0_166ck1460 FIND v(dout0_166) AT=735.025n

.meas tran vdout0_167ck1460 FIND v(dout0_167) AT=735.025n

.meas tran vdout0_168ck1460 FIND v(dout0_168) AT=735.025n

.meas tran vdout0_169ck1460 FIND v(dout0_169) AT=735.025n

.meas tran vdout0_170ck1460 FIND v(dout0_170) AT=735.025n

.meas tran vdout0_171ck1460 FIND v(dout0_171) AT=735.025n

.meas tran vdout0_172ck1460 FIND v(dout0_172) AT=735.025n

.meas tran vdout0_173ck1460 FIND v(dout0_173) AT=735.025n

.meas tran vdout0_174ck1460 FIND v(dout0_174) AT=735.025n

.meas tran vdout0_175ck1460 FIND v(dout0_175) AT=735.025n

.meas tran vdout0_176ck1460 FIND v(dout0_176) AT=735.025n

.meas tran vdout0_177ck1460 FIND v(dout0_177) AT=735.025n

.meas tran vdout0_178ck1460 FIND v(dout0_178) AT=735.025n

.meas tran vdout0_179ck1460 FIND v(dout0_179) AT=735.025n

.meas tran vdout0_180ck1460 FIND v(dout0_180) AT=735.025n

.meas tran vdout0_181ck1460 FIND v(dout0_181) AT=735.025n

.meas tran vdout0_182ck1460 FIND v(dout0_182) AT=735.025n

.meas tran vdout0_183ck1460 FIND v(dout0_183) AT=735.025n

.meas tran vdout0_184ck1460 FIND v(dout0_184) AT=735.025n

.meas tran vdout0_185ck1460 FIND v(dout0_185) AT=735.025n

.meas tran vdout0_186ck1460 FIND v(dout0_186) AT=735.025n

.meas tran vdout0_187ck1460 FIND v(dout0_187) AT=735.025n

.meas tran vdout0_188ck1460 FIND v(dout0_188) AT=735.025n

.meas tran vdout0_189ck1460 FIND v(dout0_189) AT=735.025n

.meas tran vdout0_190ck1460 FIND v(dout0_190) AT=735.025n

.meas tran vdout0_191ck1460 FIND v(dout0_191) AT=735.025n

.meas tran vdout0_192ck1460 FIND v(dout0_192) AT=735.025n

.meas tran vdout0_193ck1460 FIND v(dout0_193) AT=735.025n

.meas tran vdout0_194ck1460 FIND v(dout0_194) AT=735.025n

.meas tran vdout0_195ck1460 FIND v(dout0_195) AT=735.025n

.meas tran vdout0_196ck1460 FIND v(dout0_196) AT=735.025n

.meas tran vdout0_197ck1460 FIND v(dout0_197) AT=735.025n

.meas tran vdout0_198ck1460 FIND v(dout0_198) AT=735.025n

.meas tran vdout0_199ck1460 FIND v(dout0_199) AT=735.025n

.meas tran vdout0_200ck1460 FIND v(dout0_200) AT=735.025n

.meas tran vdout0_201ck1460 FIND v(dout0_201) AT=735.025n

.meas tran vdout0_202ck1460 FIND v(dout0_202) AT=735.025n

.meas tran vdout0_203ck1460 FIND v(dout0_203) AT=735.025n

.meas tran vdout0_204ck1460 FIND v(dout0_204) AT=735.025n

.meas tran vdout0_205ck1460 FIND v(dout0_205) AT=735.025n

.meas tran vdout0_206ck1460 FIND v(dout0_206) AT=735.025n

.meas tran vdout0_207ck1460 FIND v(dout0_207) AT=735.025n

.meas tran vdout0_208ck1460 FIND v(dout0_208) AT=735.025n

.meas tran vdout0_209ck1460 FIND v(dout0_209) AT=735.025n

.meas tran vdout0_210ck1460 FIND v(dout0_210) AT=735.025n

.meas tran vdout0_211ck1460 FIND v(dout0_211) AT=735.025n

.meas tran vdout0_212ck1460 FIND v(dout0_212) AT=735.025n

.meas tran vdout0_213ck1460 FIND v(dout0_213) AT=735.025n

.meas tran vdout0_214ck1460 FIND v(dout0_214) AT=735.025n

.meas tran vdout0_215ck1460 FIND v(dout0_215) AT=735.025n

.meas tran vdout0_216ck1460 FIND v(dout0_216) AT=735.025n

.meas tran vdout0_217ck1460 FIND v(dout0_217) AT=735.025n

.meas tran vdout0_218ck1460 FIND v(dout0_218) AT=735.025n

.meas tran vdout0_219ck1460 FIND v(dout0_219) AT=735.025n

.meas tran vdout0_220ck1460 FIND v(dout0_220) AT=735.025n

.meas tran vdout0_221ck1460 FIND v(dout0_221) AT=735.025n

.meas tran vdout0_222ck1460 FIND v(dout0_222) AT=735.025n

.meas tran vdout0_223ck1460 FIND v(dout0_223) AT=735.025n

.meas tran vdout0_224ck1460 FIND v(dout0_224) AT=735.025n

.meas tran vdout0_225ck1460 FIND v(dout0_225) AT=735.025n

.meas tran vdout0_226ck1460 FIND v(dout0_226) AT=735.025n

.meas tran vdout0_227ck1460 FIND v(dout0_227) AT=735.025n

.meas tran vdout0_228ck1460 FIND v(dout0_228) AT=735.025n

.meas tran vdout0_229ck1460 FIND v(dout0_229) AT=735.025n

.meas tran vdout0_230ck1460 FIND v(dout0_230) AT=735.025n

.meas tran vdout0_231ck1460 FIND v(dout0_231) AT=735.025n

.meas tran vdout0_232ck1460 FIND v(dout0_232) AT=735.025n

.meas tran vdout0_233ck1460 FIND v(dout0_233) AT=735.025n

.meas tran vdout0_234ck1460 FIND v(dout0_234) AT=735.025n

.meas tran vdout0_235ck1460 FIND v(dout0_235) AT=735.025n

.meas tran vdout0_236ck1460 FIND v(dout0_236) AT=735.025n

.meas tran vdout0_237ck1460 FIND v(dout0_237) AT=735.025n

.meas tran vdout0_238ck1460 FIND v(dout0_238) AT=735.025n

.meas tran vdout0_239ck1460 FIND v(dout0_239) AT=735.025n

.meas tran vdout0_240ck1460 FIND v(dout0_240) AT=735.025n

.meas tran vdout0_241ck1460 FIND v(dout0_241) AT=735.025n

.meas tran vdout0_242ck1460 FIND v(dout0_242) AT=735.025n

.meas tran vdout0_243ck1460 FIND v(dout0_243) AT=735.025n

.meas tran vdout0_244ck1460 FIND v(dout0_244) AT=735.025n

.meas tran vdout0_245ck1460 FIND v(dout0_245) AT=735.025n

.meas tran vdout0_246ck1460 FIND v(dout0_246) AT=735.025n

.meas tran vdout0_247ck1460 FIND v(dout0_247) AT=735.025n

.meas tran vdout0_248ck1460 FIND v(dout0_248) AT=735.025n

.meas tran vdout0_249ck1460 FIND v(dout0_249) AT=735.025n

.meas tran vdout0_250ck1460 FIND v(dout0_250) AT=735.025n

.meas tran vdout0_251ck1460 FIND v(dout0_251) AT=735.025n

.meas tran vdout0_252ck1460 FIND v(dout0_252) AT=735.025n

.meas tran vdout0_253ck1460 FIND v(dout0_253) AT=735.025n

.meas tran vdout0_254ck1460 FIND v(dout0_254) AT=735.025n

.meas tran vdout0_255ck1460 FIND v(dout0_255) AT=735.025n

.meas tran vdout0_0ck1500 FIND v(dout0_0) AT=755.025n

.meas tran vdout0_1ck1500 FIND v(dout0_1) AT=755.025n

.meas tran vdout0_2ck1500 FIND v(dout0_2) AT=755.025n

.meas tran vdout0_3ck1500 FIND v(dout0_3) AT=755.025n

.meas tran vdout0_4ck1500 FIND v(dout0_4) AT=755.025n

.meas tran vdout0_5ck1500 FIND v(dout0_5) AT=755.025n

.meas tran vdout0_6ck1500 FIND v(dout0_6) AT=755.025n

.meas tran vdout0_7ck1500 FIND v(dout0_7) AT=755.025n

.meas tran vdout0_8ck1500 FIND v(dout0_8) AT=755.025n

.meas tran vdout0_9ck1500 FIND v(dout0_9) AT=755.025n

.meas tran vdout0_10ck1500 FIND v(dout0_10) AT=755.025n

.meas tran vdout0_11ck1500 FIND v(dout0_11) AT=755.025n

.meas tran vdout0_12ck1500 FIND v(dout0_12) AT=755.025n

.meas tran vdout0_13ck1500 FIND v(dout0_13) AT=755.025n

.meas tran vdout0_14ck1500 FIND v(dout0_14) AT=755.025n

.meas tran vdout0_15ck1500 FIND v(dout0_15) AT=755.025n

.meas tran vdout0_16ck1500 FIND v(dout0_16) AT=755.025n

.meas tran vdout0_17ck1500 FIND v(dout0_17) AT=755.025n

.meas tran vdout0_18ck1500 FIND v(dout0_18) AT=755.025n

.meas tran vdout0_19ck1500 FIND v(dout0_19) AT=755.025n

.meas tran vdout0_20ck1500 FIND v(dout0_20) AT=755.025n

.meas tran vdout0_21ck1500 FIND v(dout0_21) AT=755.025n

.meas tran vdout0_22ck1500 FIND v(dout0_22) AT=755.025n

.meas tran vdout0_23ck1500 FIND v(dout0_23) AT=755.025n

.meas tran vdout0_24ck1500 FIND v(dout0_24) AT=755.025n

.meas tran vdout0_25ck1500 FIND v(dout0_25) AT=755.025n

.meas tran vdout0_26ck1500 FIND v(dout0_26) AT=755.025n

.meas tran vdout0_27ck1500 FIND v(dout0_27) AT=755.025n

.meas tran vdout0_28ck1500 FIND v(dout0_28) AT=755.025n

.meas tran vdout0_29ck1500 FIND v(dout0_29) AT=755.025n

.meas tran vdout0_30ck1500 FIND v(dout0_30) AT=755.025n

.meas tran vdout0_31ck1500 FIND v(dout0_31) AT=755.025n

.meas tran vdout0_32ck1500 FIND v(dout0_32) AT=755.025n

.meas tran vdout0_33ck1500 FIND v(dout0_33) AT=755.025n

.meas tran vdout0_34ck1500 FIND v(dout0_34) AT=755.025n

.meas tran vdout0_35ck1500 FIND v(dout0_35) AT=755.025n

.meas tran vdout0_36ck1500 FIND v(dout0_36) AT=755.025n

.meas tran vdout0_37ck1500 FIND v(dout0_37) AT=755.025n

.meas tran vdout0_38ck1500 FIND v(dout0_38) AT=755.025n

.meas tran vdout0_39ck1500 FIND v(dout0_39) AT=755.025n

.meas tran vdout0_40ck1500 FIND v(dout0_40) AT=755.025n

.meas tran vdout0_41ck1500 FIND v(dout0_41) AT=755.025n

.meas tran vdout0_42ck1500 FIND v(dout0_42) AT=755.025n

.meas tran vdout0_43ck1500 FIND v(dout0_43) AT=755.025n

.meas tran vdout0_44ck1500 FIND v(dout0_44) AT=755.025n

.meas tran vdout0_45ck1500 FIND v(dout0_45) AT=755.025n

.meas tran vdout0_46ck1500 FIND v(dout0_46) AT=755.025n

.meas tran vdout0_47ck1500 FIND v(dout0_47) AT=755.025n

.meas tran vdout0_48ck1500 FIND v(dout0_48) AT=755.025n

.meas tran vdout0_49ck1500 FIND v(dout0_49) AT=755.025n

.meas tran vdout0_50ck1500 FIND v(dout0_50) AT=755.025n

.meas tran vdout0_51ck1500 FIND v(dout0_51) AT=755.025n

.meas tran vdout0_52ck1500 FIND v(dout0_52) AT=755.025n

.meas tran vdout0_53ck1500 FIND v(dout0_53) AT=755.025n

.meas tran vdout0_54ck1500 FIND v(dout0_54) AT=755.025n

.meas tran vdout0_55ck1500 FIND v(dout0_55) AT=755.025n

.meas tran vdout0_56ck1500 FIND v(dout0_56) AT=755.025n

.meas tran vdout0_57ck1500 FIND v(dout0_57) AT=755.025n

.meas tran vdout0_58ck1500 FIND v(dout0_58) AT=755.025n

.meas tran vdout0_59ck1500 FIND v(dout0_59) AT=755.025n

.meas tran vdout0_60ck1500 FIND v(dout0_60) AT=755.025n

.meas tran vdout0_61ck1500 FIND v(dout0_61) AT=755.025n

.meas tran vdout0_62ck1500 FIND v(dout0_62) AT=755.025n

.meas tran vdout0_63ck1500 FIND v(dout0_63) AT=755.025n

.meas tran vdout0_64ck1500 FIND v(dout0_64) AT=755.025n

.meas tran vdout0_65ck1500 FIND v(dout0_65) AT=755.025n

.meas tran vdout0_66ck1500 FIND v(dout0_66) AT=755.025n

.meas tran vdout0_67ck1500 FIND v(dout0_67) AT=755.025n

.meas tran vdout0_68ck1500 FIND v(dout0_68) AT=755.025n

.meas tran vdout0_69ck1500 FIND v(dout0_69) AT=755.025n

.meas tran vdout0_70ck1500 FIND v(dout0_70) AT=755.025n

.meas tran vdout0_71ck1500 FIND v(dout0_71) AT=755.025n

.meas tran vdout0_72ck1500 FIND v(dout0_72) AT=755.025n

.meas tran vdout0_73ck1500 FIND v(dout0_73) AT=755.025n

.meas tran vdout0_74ck1500 FIND v(dout0_74) AT=755.025n

.meas tran vdout0_75ck1500 FIND v(dout0_75) AT=755.025n

.meas tran vdout0_76ck1500 FIND v(dout0_76) AT=755.025n

.meas tran vdout0_77ck1500 FIND v(dout0_77) AT=755.025n

.meas tran vdout0_78ck1500 FIND v(dout0_78) AT=755.025n

.meas tran vdout0_79ck1500 FIND v(dout0_79) AT=755.025n

.meas tran vdout0_80ck1500 FIND v(dout0_80) AT=755.025n

.meas tran vdout0_81ck1500 FIND v(dout0_81) AT=755.025n

.meas tran vdout0_82ck1500 FIND v(dout0_82) AT=755.025n

.meas tran vdout0_83ck1500 FIND v(dout0_83) AT=755.025n

.meas tran vdout0_84ck1500 FIND v(dout0_84) AT=755.025n

.meas tran vdout0_85ck1500 FIND v(dout0_85) AT=755.025n

.meas tran vdout0_86ck1500 FIND v(dout0_86) AT=755.025n

.meas tran vdout0_87ck1500 FIND v(dout0_87) AT=755.025n

.meas tran vdout0_88ck1500 FIND v(dout0_88) AT=755.025n

.meas tran vdout0_89ck1500 FIND v(dout0_89) AT=755.025n

.meas tran vdout0_90ck1500 FIND v(dout0_90) AT=755.025n

.meas tran vdout0_91ck1500 FIND v(dout0_91) AT=755.025n

.meas tran vdout0_92ck1500 FIND v(dout0_92) AT=755.025n

.meas tran vdout0_93ck1500 FIND v(dout0_93) AT=755.025n

.meas tran vdout0_94ck1500 FIND v(dout0_94) AT=755.025n

.meas tran vdout0_95ck1500 FIND v(dout0_95) AT=755.025n

.meas tran vdout0_96ck1500 FIND v(dout0_96) AT=755.025n

.meas tran vdout0_97ck1500 FIND v(dout0_97) AT=755.025n

.meas tran vdout0_98ck1500 FIND v(dout0_98) AT=755.025n

.meas tran vdout0_99ck1500 FIND v(dout0_99) AT=755.025n

.meas tran vdout0_100ck1500 FIND v(dout0_100) AT=755.025n

.meas tran vdout0_101ck1500 FIND v(dout0_101) AT=755.025n

.meas tran vdout0_102ck1500 FIND v(dout0_102) AT=755.025n

.meas tran vdout0_103ck1500 FIND v(dout0_103) AT=755.025n

.meas tran vdout0_104ck1500 FIND v(dout0_104) AT=755.025n

.meas tran vdout0_105ck1500 FIND v(dout0_105) AT=755.025n

.meas tran vdout0_106ck1500 FIND v(dout0_106) AT=755.025n

.meas tran vdout0_107ck1500 FIND v(dout0_107) AT=755.025n

.meas tran vdout0_108ck1500 FIND v(dout0_108) AT=755.025n

.meas tran vdout0_109ck1500 FIND v(dout0_109) AT=755.025n

.meas tran vdout0_110ck1500 FIND v(dout0_110) AT=755.025n

.meas tran vdout0_111ck1500 FIND v(dout0_111) AT=755.025n

.meas tran vdout0_112ck1500 FIND v(dout0_112) AT=755.025n

.meas tran vdout0_113ck1500 FIND v(dout0_113) AT=755.025n

.meas tran vdout0_114ck1500 FIND v(dout0_114) AT=755.025n

.meas tran vdout0_115ck1500 FIND v(dout0_115) AT=755.025n

.meas tran vdout0_116ck1500 FIND v(dout0_116) AT=755.025n

.meas tran vdout0_117ck1500 FIND v(dout0_117) AT=755.025n

.meas tran vdout0_118ck1500 FIND v(dout0_118) AT=755.025n

.meas tran vdout0_119ck1500 FIND v(dout0_119) AT=755.025n

.meas tran vdout0_120ck1500 FIND v(dout0_120) AT=755.025n

.meas tran vdout0_121ck1500 FIND v(dout0_121) AT=755.025n

.meas tran vdout0_122ck1500 FIND v(dout0_122) AT=755.025n

.meas tran vdout0_123ck1500 FIND v(dout0_123) AT=755.025n

.meas tran vdout0_124ck1500 FIND v(dout0_124) AT=755.025n

.meas tran vdout0_125ck1500 FIND v(dout0_125) AT=755.025n

.meas tran vdout0_126ck1500 FIND v(dout0_126) AT=755.025n

.meas tran vdout0_127ck1500 FIND v(dout0_127) AT=755.025n

.meas tran vdout0_128ck1500 FIND v(dout0_128) AT=755.025n

.meas tran vdout0_129ck1500 FIND v(dout0_129) AT=755.025n

.meas tran vdout0_130ck1500 FIND v(dout0_130) AT=755.025n

.meas tran vdout0_131ck1500 FIND v(dout0_131) AT=755.025n

.meas tran vdout0_132ck1500 FIND v(dout0_132) AT=755.025n

.meas tran vdout0_133ck1500 FIND v(dout0_133) AT=755.025n

.meas tran vdout0_134ck1500 FIND v(dout0_134) AT=755.025n

.meas tran vdout0_135ck1500 FIND v(dout0_135) AT=755.025n

.meas tran vdout0_136ck1500 FIND v(dout0_136) AT=755.025n

.meas tran vdout0_137ck1500 FIND v(dout0_137) AT=755.025n

.meas tran vdout0_138ck1500 FIND v(dout0_138) AT=755.025n

.meas tran vdout0_139ck1500 FIND v(dout0_139) AT=755.025n

.meas tran vdout0_140ck1500 FIND v(dout0_140) AT=755.025n

.meas tran vdout0_141ck1500 FIND v(dout0_141) AT=755.025n

.meas tran vdout0_142ck1500 FIND v(dout0_142) AT=755.025n

.meas tran vdout0_143ck1500 FIND v(dout0_143) AT=755.025n

.meas tran vdout0_144ck1500 FIND v(dout0_144) AT=755.025n

.meas tran vdout0_145ck1500 FIND v(dout0_145) AT=755.025n

.meas tran vdout0_146ck1500 FIND v(dout0_146) AT=755.025n

.meas tran vdout0_147ck1500 FIND v(dout0_147) AT=755.025n

.meas tran vdout0_148ck1500 FIND v(dout0_148) AT=755.025n

.meas tran vdout0_149ck1500 FIND v(dout0_149) AT=755.025n

.meas tran vdout0_150ck1500 FIND v(dout0_150) AT=755.025n

.meas tran vdout0_151ck1500 FIND v(dout0_151) AT=755.025n

.meas tran vdout0_152ck1500 FIND v(dout0_152) AT=755.025n

.meas tran vdout0_153ck1500 FIND v(dout0_153) AT=755.025n

.meas tran vdout0_154ck1500 FIND v(dout0_154) AT=755.025n

.meas tran vdout0_155ck1500 FIND v(dout0_155) AT=755.025n

.meas tran vdout0_156ck1500 FIND v(dout0_156) AT=755.025n

.meas tran vdout0_157ck1500 FIND v(dout0_157) AT=755.025n

.meas tran vdout0_158ck1500 FIND v(dout0_158) AT=755.025n

.meas tran vdout0_159ck1500 FIND v(dout0_159) AT=755.025n

.meas tran vdout0_160ck1500 FIND v(dout0_160) AT=755.025n

.meas tran vdout0_161ck1500 FIND v(dout0_161) AT=755.025n

.meas tran vdout0_162ck1500 FIND v(dout0_162) AT=755.025n

.meas tran vdout0_163ck1500 FIND v(dout0_163) AT=755.025n

.meas tran vdout0_164ck1500 FIND v(dout0_164) AT=755.025n

.meas tran vdout0_165ck1500 FIND v(dout0_165) AT=755.025n

.meas tran vdout0_166ck1500 FIND v(dout0_166) AT=755.025n

.meas tran vdout0_167ck1500 FIND v(dout0_167) AT=755.025n

.meas tran vdout0_168ck1500 FIND v(dout0_168) AT=755.025n

.meas tran vdout0_169ck1500 FIND v(dout0_169) AT=755.025n

.meas tran vdout0_170ck1500 FIND v(dout0_170) AT=755.025n

.meas tran vdout0_171ck1500 FIND v(dout0_171) AT=755.025n

.meas tran vdout0_172ck1500 FIND v(dout0_172) AT=755.025n

.meas tran vdout0_173ck1500 FIND v(dout0_173) AT=755.025n

.meas tran vdout0_174ck1500 FIND v(dout0_174) AT=755.025n

.meas tran vdout0_175ck1500 FIND v(dout0_175) AT=755.025n

.meas tran vdout0_176ck1500 FIND v(dout0_176) AT=755.025n

.meas tran vdout0_177ck1500 FIND v(dout0_177) AT=755.025n

.meas tran vdout0_178ck1500 FIND v(dout0_178) AT=755.025n

.meas tran vdout0_179ck1500 FIND v(dout0_179) AT=755.025n

.meas tran vdout0_180ck1500 FIND v(dout0_180) AT=755.025n

.meas tran vdout0_181ck1500 FIND v(dout0_181) AT=755.025n

.meas tran vdout0_182ck1500 FIND v(dout0_182) AT=755.025n

.meas tran vdout0_183ck1500 FIND v(dout0_183) AT=755.025n

.meas tran vdout0_184ck1500 FIND v(dout0_184) AT=755.025n

.meas tran vdout0_185ck1500 FIND v(dout0_185) AT=755.025n

.meas tran vdout0_186ck1500 FIND v(dout0_186) AT=755.025n

.meas tran vdout0_187ck1500 FIND v(dout0_187) AT=755.025n

.meas tran vdout0_188ck1500 FIND v(dout0_188) AT=755.025n

.meas tran vdout0_189ck1500 FIND v(dout0_189) AT=755.025n

.meas tran vdout0_190ck1500 FIND v(dout0_190) AT=755.025n

.meas tran vdout0_191ck1500 FIND v(dout0_191) AT=755.025n

.meas tran vdout0_192ck1500 FIND v(dout0_192) AT=755.025n

.meas tran vdout0_193ck1500 FIND v(dout0_193) AT=755.025n

.meas tran vdout0_194ck1500 FIND v(dout0_194) AT=755.025n

.meas tran vdout0_195ck1500 FIND v(dout0_195) AT=755.025n

.meas tran vdout0_196ck1500 FIND v(dout0_196) AT=755.025n

.meas tran vdout0_197ck1500 FIND v(dout0_197) AT=755.025n

.meas tran vdout0_198ck1500 FIND v(dout0_198) AT=755.025n

.meas tran vdout0_199ck1500 FIND v(dout0_199) AT=755.025n

.meas tran vdout0_200ck1500 FIND v(dout0_200) AT=755.025n

.meas tran vdout0_201ck1500 FIND v(dout0_201) AT=755.025n

.meas tran vdout0_202ck1500 FIND v(dout0_202) AT=755.025n

.meas tran vdout0_203ck1500 FIND v(dout0_203) AT=755.025n

.meas tran vdout0_204ck1500 FIND v(dout0_204) AT=755.025n

.meas tran vdout0_205ck1500 FIND v(dout0_205) AT=755.025n

.meas tran vdout0_206ck1500 FIND v(dout0_206) AT=755.025n

.meas tran vdout0_207ck1500 FIND v(dout0_207) AT=755.025n

.meas tran vdout0_208ck1500 FIND v(dout0_208) AT=755.025n

.meas tran vdout0_209ck1500 FIND v(dout0_209) AT=755.025n

.meas tran vdout0_210ck1500 FIND v(dout0_210) AT=755.025n

.meas tran vdout0_211ck1500 FIND v(dout0_211) AT=755.025n

.meas tran vdout0_212ck1500 FIND v(dout0_212) AT=755.025n

.meas tran vdout0_213ck1500 FIND v(dout0_213) AT=755.025n

.meas tran vdout0_214ck1500 FIND v(dout0_214) AT=755.025n

.meas tran vdout0_215ck1500 FIND v(dout0_215) AT=755.025n

.meas tran vdout0_216ck1500 FIND v(dout0_216) AT=755.025n

.meas tran vdout0_217ck1500 FIND v(dout0_217) AT=755.025n

.meas tran vdout0_218ck1500 FIND v(dout0_218) AT=755.025n

.meas tran vdout0_219ck1500 FIND v(dout0_219) AT=755.025n

.meas tran vdout0_220ck1500 FIND v(dout0_220) AT=755.025n

.meas tran vdout0_221ck1500 FIND v(dout0_221) AT=755.025n

.meas tran vdout0_222ck1500 FIND v(dout0_222) AT=755.025n

.meas tran vdout0_223ck1500 FIND v(dout0_223) AT=755.025n

.meas tran vdout0_224ck1500 FIND v(dout0_224) AT=755.025n

.meas tran vdout0_225ck1500 FIND v(dout0_225) AT=755.025n

.meas tran vdout0_226ck1500 FIND v(dout0_226) AT=755.025n

.meas tran vdout0_227ck1500 FIND v(dout0_227) AT=755.025n

.meas tran vdout0_228ck1500 FIND v(dout0_228) AT=755.025n

.meas tran vdout0_229ck1500 FIND v(dout0_229) AT=755.025n

.meas tran vdout0_230ck1500 FIND v(dout0_230) AT=755.025n

.meas tran vdout0_231ck1500 FIND v(dout0_231) AT=755.025n

.meas tran vdout0_232ck1500 FIND v(dout0_232) AT=755.025n

.meas tran vdout0_233ck1500 FIND v(dout0_233) AT=755.025n

.meas tran vdout0_234ck1500 FIND v(dout0_234) AT=755.025n

.meas tran vdout0_235ck1500 FIND v(dout0_235) AT=755.025n

.meas tran vdout0_236ck1500 FIND v(dout0_236) AT=755.025n

.meas tran vdout0_237ck1500 FIND v(dout0_237) AT=755.025n

.meas tran vdout0_238ck1500 FIND v(dout0_238) AT=755.025n

.meas tran vdout0_239ck1500 FIND v(dout0_239) AT=755.025n

.meas tran vdout0_240ck1500 FIND v(dout0_240) AT=755.025n

.meas tran vdout0_241ck1500 FIND v(dout0_241) AT=755.025n

.meas tran vdout0_242ck1500 FIND v(dout0_242) AT=755.025n

.meas tran vdout0_243ck1500 FIND v(dout0_243) AT=755.025n

.meas tran vdout0_244ck1500 FIND v(dout0_244) AT=755.025n

.meas tran vdout0_245ck1500 FIND v(dout0_245) AT=755.025n

.meas tran vdout0_246ck1500 FIND v(dout0_246) AT=755.025n

.meas tran vdout0_247ck1500 FIND v(dout0_247) AT=755.025n

.meas tran vdout0_248ck1500 FIND v(dout0_248) AT=755.025n

.meas tran vdout0_249ck1500 FIND v(dout0_249) AT=755.025n

.meas tran vdout0_250ck1500 FIND v(dout0_250) AT=755.025n

.meas tran vdout0_251ck1500 FIND v(dout0_251) AT=755.025n

.meas tran vdout0_252ck1500 FIND v(dout0_252) AT=755.025n

.meas tran vdout0_253ck1500 FIND v(dout0_253) AT=755.025n

.meas tran vdout0_254ck1500 FIND v(dout0_254) AT=755.025n

.meas tran vdout0_255ck1500 FIND v(dout0_255) AT=755.025n

.meas tran vdout0_0ck1510 FIND v(dout0_0) AT=760.025n

.meas tran vdout0_1ck1510 FIND v(dout0_1) AT=760.025n

.meas tran vdout0_2ck1510 FIND v(dout0_2) AT=760.025n

.meas tran vdout0_3ck1510 FIND v(dout0_3) AT=760.025n

.meas tran vdout0_4ck1510 FIND v(dout0_4) AT=760.025n

.meas tran vdout0_5ck1510 FIND v(dout0_5) AT=760.025n

.meas tran vdout0_6ck1510 FIND v(dout0_6) AT=760.025n

.meas tran vdout0_7ck1510 FIND v(dout0_7) AT=760.025n

.meas tran vdout0_8ck1510 FIND v(dout0_8) AT=760.025n

.meas tran vdout0_9ck1510 FIND v(dout0_9) AT=760.025n

.meas tran vdout0_10ck1510 FIND v(dout0_10) AT=760.025n

.meas tran vdout0_11ck1510 FIND v(dout0_11) AT=760.025n

.meas tran vdout0_12ck1510 FIND v(dout0_12) AT=760.025n

.meas tran vdout0_13ck1510 FIND v(dout0_13) AT=760.025n

.meas tran vdout0_14ck1510 FIND v(dout0_14) AT=760.025n

.meas tran vdout0_15ck1510 FIND v(dout0_15) AT=760.025n

.meas tran vdout0_16ck1510 FIND v(dout0_16) AT=760.025n

.meas tran vdout0_17ck1510 FIND v(dout0_17) AT=760.025n

.meas tran vdout0_18ck1510 FIND v(dout0_18) AT=760.025n

.meas tran vdout0_19ck1510 FIND v(dout0_19) AT=760.025n

.meas tran vdout0_20ck1510 FIND v(dout0_20) AT=760.025n

.meas tran vdout0_21ck1510 FIND v(dout0_21) AT=760.025n

.meas tran vdout0_22ck1510 FIND v(dout0_22) AT=760.025n

.meas tran vdout0_23ck1510 FIND v(dout0_23) AT=760.025n

.meas tran vdout0_24ck1510 FIND v(dout0_24) AT=760.025n

.meas tran vdout0_25ck1510 FIND v(dout0_25) AT=760.025n

.meas tran vdout0_26ck1510 FIND v(dout0_26) AT=760.025n

.meas tran vdout0_27ck1510 FIND v(dout0_27) AT=760.025n

.meas tran vdout0_28ck1510 FIND v(dout0_28) AT=760.025n

.meas tran vdout0_29ck1510 FIND v(dout0_29) AT=760.025n

.meas tran vdout0_30ck1510 FIND v(dout0_30) AT=760.025n

.meas tran vdout0_31ck1510 FIND v(dout0_31) AT=760.025n

.meas tran vdout0_32ck1510 FIND v(dout0_32) AT=760.025n

.meas tran vdout0_33ck1510 FIND v(dout0_33) AT=760.025n

.meas tran vdout0_34ck1510 FIND v(dout0_34) AT=760.025n

.meas tran vdout0_35ck1510 FIND v(dout0_35) AT=760.025n

.meas tran vdout0_36ck1510 FIND v(dout0_36) AT=760.025n

.meas tran vdout0_37ck1510 FIND v(dout0_37) AT=760.025n

.meas tran vdout0_38ck1510 FIND v(dout0_38) AT=760.025n

.meas tran vdout0_39ck1510 FIND v(dout0_39) AT=760.025n

.meas tran vdout0_40ck1510 FIND v(dout0_40) AT=760.025n

.meas tran vdout0_41ck1510 FIND v(dout0_41) AT=760.025n

.meas tran vdout0_42ck1510 FIND v(dout0_42) AT=760.025n

.meas tran vdout0_43ck1510 FIND v(dout0_43) AT=760.025n

.meas tran vdout0_44ck1510 FIND v(dout0_44) AT=760.025n

.meas tran vdout0_45ck1510 FIND v(dout0_45) AT=760.025n

.meas tran vdout0_46ck1510 FIND v(dout0_46) AT=760.025n

.meas tran vdout0_47ck1510 FIND v(dout0_47) AT=760.025n

.meas tran vdout0_48ck1510 FIND v(dout0_48) AT=760.025n

.meas tran vdout0_49ck1510 FIND v(dout0_49) AT=760.025n

.meas tran vdout0_50ck1510 FIND v(dout0_50) AT=760.025n

.meas tran vdout0_51ck1510 FIND v(dout0_51) AT=760.025n

.meas tran vdout0_52ck1510 FIND v(dout0_52) AT=760.025n

.meas tran vdout0_53ck1510 FIND v(dout0_53) AT=760.025n

.meas tran vdout0_54ck1510 FIND v(dout0_54) AT=760.025n

.meas tran vdout0_55ck1510 FIND v(dout0_55) AT=760.025n

.meas tran vdout0_56ck1510 FIND v(dout0_56) AT=760.025n

.meas tran vdout0_57ck1510 FIND v(dout0_57) AT=760.025n

.meas tran vdout0_58ck1510 FIND v(dout0_58) AT=760.025n

.meas tran vdout0_59ck1510 FIND v(dout0_59) AT=760.025n

.meas tran vdout0_60ck1510 FIND v(dout0_60) AT=760.025n

.meas tran vdout0_61ck1510 FIND v(dout0_61) AT=760.025n

.meas tran vdout0_62ck1510 FIND v(dout0_62) AT=760.025n

.meas tran vdout0_63ck1510 FIND v(dout0_63) AT=760.025n

.meas tran vdout0_64ck1510 FIND v(dout0_64) AT=760.025n

.meas tran vdout0_65ck1510 FIND v(dout0_65) AT=760.025n

.meas tran vdout0_66ck1510 FIND v(dout0_66) AT=760.025n

.meas tran vdout0_67ck1510 FIND v(dout0_67) AT=760.025n

.meas tran vdout0_68ck1510 FIND v(dout0_68) AT=760.025n

.meas tran vdout0_69ck1510 FIND v(dout0_69) AT=760.025n

.meas tran vdout0_70ck1510 FIND v(dout0_70) AT=760.025n

.meas tran vdout0_71ck1510 FIND v(dout0_71) AT=760.025n

.meas tran vdout0_72ck1510 FIND v(dout0_72) AT=760.025n

.meas tran vdout0_73ck1510 FIND v(dout0_73) AT=760.025n

.meas tran vdout0_74ck1510 FIND v(dout0_74) AT=760.025n

.meas tran vdout0_75ck1510 FIND v(dout0_75) AT=760.025n

.meas tran vdout0_76ck1510 FIND v(dout0_76) AT=760.025n

.meas tran vdout0_77ck1510 FIND v(dout0_77) AT=760.025n

.meas tran vdout0_78ck1510 FIND v(dout0_78) AT=760.025n

.meas tran vdout0_79ck1510 FIND v(dout0_79) AT=760.025n

.meas tran vdout0_80ck1510 FIND v(dout0_80) AT=760.025n

.meas tran vdout0_81ck1510 FIND v(dout0_81) AT=760.025n

.meas tran vdout0_82ck1510 FIND v(dout0_82) AT=760.025n

.meas tran vdout0_83ck1510 FIND v(dout0_83) AT=760.025n

.meas tran vdout0_84ck1510 FIND v(dout0_84) AT=760.025n

.meas tran vdout0_85ck1510 FIND v(dout0_85) AT=760.025n

.meas tran vdout0_86ck1510 FIND v(dout0_86) AT=760.025n

.meas tran vdout0_87ck1510 FIND v(dout0_87) AT=760.025n

.meas tran vdout0_88ck1510 FIND v(dout0_88) AT=760.025n

.meas tran vdout0_89ck1510 FIND v(dout0_89) AT=760.025n

.meas tran vdout0_90ck1510 FIND v(dout0_90) AT=760.025n

.meas tran vdout0_91ck1510 FIND v(dout0_91) AT=760.025n

.meas tran vdout0_92ck1510 FIND v(dout0_92) AT=760.025n

.meas tran vdout0_93ck1510 FIND v(dout0_93) AT=760.025n

.meas tran vdout0_94ck1510 FIND v(dout0_94) AT=760.025n

.meas tran vdout0_95ck1510 FIND v(dout0_95) AT=760.025n

.meas tran vdout0_96ck1510 FIND v(dout0_96) AT=760.025n

.meas tran vdout0_97ck1510 FIND v(dout0_97) AT=760.025n

.meas tran vdout0_98ck1510 FIND v(dout0_98) AT=760.025n

.meas tran vdout0_99ck1510 FIND v(dout0_99) AT=760.025n

.meas tran vdout0_100ck1510 FIND v(dout0_100) AT=760.025n

.meas tran vdout0_101ck1510 FIND v(dout0_101) AT=760.025n

.meas tran vdout0_102ck1510 FIND v(dout0_102) AT=760.025n

.meas tran vdout0_103ck1510 FIND v(dout0_103) AT=760.025n

.meas tran vdout0_104ck1510 FIND v(dout0_104) AT=760.025n

.meas tran vdout0_105ck1510 FIND v(dout0_105) AT=760.025n

.meas tran vdout0_106ck1510 FIND v(dout0_106) AT=760.025n

.meas tran vdout0_107ck1510 FIND v(dout0_107) AT=760.025n

.meas tran vdout0_108ck1510 FIND v(dout0_108) AT=760.025n

.meas tran vdout0_109ck1510 FIND v(dout0_109) AT=760.025n

.meas tran vdout0_110ck1510 FIND v(dout0_110) AT=760.025n

.meas tran vdout0_111ck1510 FIND v(dout0_111) AT=760.025n

.meas tran vdout0_112ck1510 FIND v(dout0_112) AT=760.025n

.meas tran vdout0_113ck1510 FIND v(dout0_113) AT=760.025n

.meas tran vdout0_114ck1510 FIND v(dout0_114) AT=760.025n

.meas tran vdout0_115ck1510 FIND v(dout0_115) AT=760.025n

.meas tran vdout0_116ck1510 FIND v(dout0_116) AT=760.025n

.meas tran vdout0_117ck1510 FIND v(dout0_117) AT=760.025n

.meas tran vdout0_118ck1510 FIND v(dout0_118) AT=760.025n

.meas tran vdout0_119ck1510 FIND v(dout0_119) AT=760.025n

.meas tran vdout0_120ck1510 FIND v(dout0_120) AT=760.025n

.meas tran vdout0_121ck1510 FIND v(dout0_121) AT=760.025n

.meas tran vdout0_122ck1510 FIND v(dout0_122) AT=760.025n

.meas tran vdout0_123ck1510 FIND v(dout0_123) AT=760.025n

.meas tran vdout0_124ck1510 FIND v(dout0_124) AT=760.025n

.meas tran vdout0_125ck1510 FIND v(dout0_125) AT=760.025n

.meas tran vdout0_126ck1510 FIND v(dout0_126) AT=760.025n

.meas tran vdout0_127ck1510 FIND v(dout0_127) AT=760.025n

.meas tran vdout0_128ck1510 FIND v(dout0_128) AT=760.025n

.meas tran vdout0_129ck1510 FIND v(dout0_129) AT=760.025n

.meas tran vdout0_130ck1510 FIND v(dout0_130) AT=760.025n

.meas tran vdout0_131ck1510 FIND v(dout0_131) AT=760.025n

.meas tran vdout0_132ck1510 FIND v(dout0_132) AT=760.025n

.meas tran vdout0_133ck1510 FIND v(dout0_133) AT=760.025n

.meas tran vdout0_134ck1510 FIND v(dout0_134) AT=760.025n

.meas tran vdout0_135ck1510 FIND v(dout0_135) AT=760.025n

.meas tran vdout0_136ck1510 FIND v(dout0_136) AT=760.025n

.meas tran vdout0_137ck1510 FIND v(dout0_137) AT=760.025n

.meas tran vdout0_138ck1510 FIND v(dout0_138) AT=760.025n

.meas tran vdout0_139ck1510 FIND v(dout0_139) AT=760.025n

.meas tran vdout0_140ck1510 FIND v(dout0_140) AT=760.025n

.meas tran vdout0_141ck1510 FIND v(dout0_141) AT=760.025n

.meas tran vdout0_142ck1510 FIND v(dout0_142) AT=760.025n

.meas tran vdout0_143ck1510 FIND v(dout0_143) AT=760.025n

.meas tran vdout0_144ck1510 FIND v(dout0_144) AT=760.025n

.meas tran vdout0_145ck1510 FIND v(dout0_145) AT=760.025n

.meas tran vdout0_146ck1510 FIND v(dout0_146) AT=760.025n

.meas tran vdout0_147ck1510 FIND v(dout0_147) AT=760.025n

.meas tran vdout0_148ck1510 FIND v(dout0_148) AT=760.025n

.meas tran vdout0_149ck1510 FIND v(dout0_149) AT=760.025n

.meas tran vdout0_150ck1510 FIND v(dout0_150) AT=760.025n

.meas tran vdout0_151ck1510 FIND v(dout0_151) AT=760.025n

.meas tran vdout0_152ck1510 FIND v(dout0_152) AT=760.025n

.meas tran vdout0_153ck1510 FIND v(dout0_153) AT=760.025n

.meas tran vdout0_154ck1510 FIND v(dout0_154) AT=760.025n

.meas tran vdout0_155ck1510 FIND v(dout0_155) AT=760.025n

.meas tran vdout0_156ck1510 FIND v(dout0_156) AT=760.025n

.meas tran vdout0_157ck1510 FIND v(dout0_157) AT=760.025n

.meas tran vdout0_158ck1510 FIND v(dout0_158) AT=760.025n

.meas tran vdout0_159ck1510 FIND v(dout0_159) AT=760.025n

.meas tran vdout0_160ck1510 FIND v(dout0_160) AT=760.025n

.meas tran vdout0_161ck1510 FIND v(dout0_161) AT=760.025n

.meas tran vdout0_162ck1510 FIND v(dout0_162) AT=760.025n

.meas tran vdout0_163ck1510 FIND v(dout0_163) AT=760.025n

.meas tran vdout0_164ck1510 FIND v(dout0_164) AT=760.025n

.meas tran vdout0_165ck1510 FIND v(dout0_165) AT=760.025n

.meas tran vdout0_166ck1510 FIND v(dout0_166) AT=760.025n

.meas tran vdout0_167ck1510 FIND v(dout0_167) AT=760.025n

.meas tran vdout0_168ck1510 FIND v(dout0_168) AT=760.025n

.meas tran vdout0_169ck1510 FIND v(dout0_169) AT=760.025n

.meas tran vdout0_170ck1510 FIND v(dout0_170) AT=760.025n

.meas tran vdout0_171ck1510 FIND v(dout0_171) AT=760.025n

.meas tran vdout0_172ck1510 FIND v(dout0_172) AT=760.025n

.meas tran vdout0_173ck1510 FIND v(dout0_173) AT=760.025n

.meas tran vdout0_174ck1510 FIND v(dout0_174) AT=760.025n

.meas tran vdout0_175ck1510 FIND v(dout0_175) AT=760.025n

.meas tran vdout0_176ck1510 FIND v(dout0_176) AT=760.025n

.meas tran vdout0_177ck1510 FIND v(dout0_177) AT=760.025n

.meas tran vdout0_178ck1510 FIND v(dout0_178) AT=760.025n

.meas tran vdout0_179ck1510 FIND v(dout0_179) AT=760.025n

.meas tran vdout0_180ck1510 FIND v(dout0_180) AT=760.025n

.meas tran vdout0_181ck1510 FIND v(dout0_181) AT=760.025n

.meas tran vdout0_182ck1510 FIND v(dout0_182) AT=760.025n

.meas tran vdout0_183ck1510 FIND v(dout0_183) AT=760.025n

.meas tran vdout0_184ck1510 FIND v(dout0_184) AT=760.025n

.meas tran vdout0_185ck1510 FIND v(dout0_185) AT=760.025n

.meas tran vdout0_186ck1510 FIND v(dout0_186) AT=760.025n

.meas tran vdout0_187ck1510 FIND v(dout0_187) AT=760.025n

.meas tran vdout0_188ck1510 FIND v(dout0_188) AT=760.025n

.meas tran vdout0_189ck1510 FIND v(dout0_189) AT=760.025n

.meas tran vdout0_190ck1510 FIND v(dout0_190) AT=760.025n

.meas tran vdout0_191ck1510 FIND v(dout0_191) AT=760.025n

.meas tran vdout0_192ck1510 FIND v(dout0_192) AT=760.025n

.meas tran vdout0_193ck1510 FIND v(dout0_193) AT=760.025n

.meas tran vdout0_194ck1510 FIND v(dout0_194) AT=760.025n

.meas tran vdout0_195ck1510 FIND v(dout0_195) AT=760.025n

.meas tran vdout0_196ck1510 FIND v(dout0_196) AT=760.025n

.meas tran vdout0_197ck1510 FIND v(dout0_197) AT=760.025n

.meas tran vdout0_198ck1510 FIND v(dout0_198) AT=760.025n

.meas tran vdout0_199ck1510 FIND v(dout0_199) AT=760.025n

.meas tran vdout0_200ck1510 FIND v(dout0_200) AT=760.025n

.meas tran vdout0_201ck1510 FIND v(dout0_201) AT=760.025n

.meas tran vdout0_202ck1510 FIND v(dout0_202) AT=760.025n

.meas tran vdout0_203ck1510 FIND v(dout0_203) AT=760.025n

.meas tran vdout0_204ck1510 FIND v(dout0_204) AT=760.025n

.meas tran vdout0_205ck1510 FIND v(dout0_205) AT=760.025n

.meas tran vdout0_206ck1510 FIND v(dout0_206) AT=760.025n

.meas tran vdout0_207ck1510 FIND v(dout0_207) AT=760.025n

.meas tran vdout0_208ck1510 FIND v(dout0_208) AT=760.025n

.meas tran vdout0_209ck1510 FIND v(dout0_209) AT=760.025n

.meas tran vdout0_210ck1510 FIND v(dout0_210) AT=760.025n

.meas tran vdout0_211ck1510 FIND v(dout0_211) AT=760.025n

.meas tran vdout0_212ck1510 FIND v(dout0_212) AT=760.025n

.meas tran vdout0_213ck1510 FIND v(dout0_213) AT=760.025n

.meas tran vdout0_214ck1510 FIND v(dout0_214) AT=760.025n

.meas tran vdout0_215ck1510 FIND v(dout0_215) AT=760.025n

.meas tran vdout0_216ck1510 FIND v(dout0_216) AT=760.025n

.meas tran vdout0_217ck1510 FIND v(dout0_217) AT=760.025n

.meas tran vdout0_218ck1510 FIND v(dout0_218) AT=760.025n

.meas tran vdout0_219ck1510 FIND v(dout0_219) AT=760.025n

.meas tran vdout0_220ck1510 FIND v(dout0_220) AT=760.025n

.meas tran vdout0_221ck1510 FIND v(dout0_221) AT=760.025n

.meas tran vdout0_222ck1510 FIND v(dout0_222) AT=760.025n

.meas tran vdout0_223ck1510 FIND v(dout0_223) AT=760.025n

.meas tran vdout0_224ck1510 FIND v(dout0_224) AT=760.025n

.meas tran vdout0_225ck1510 FIND v(dout0_225) AT=760.025n

.meas tran vdout0_226ck1510 FIND v(dout0_226) AT=760.025n

.meas tran vdout0_227ck1510 FIND v(dout0_227) AT=760.025n

.meas tran vdout0_228ck1510 FIND v(dout0_228) AT=760.025n

.meas tran vdout0_229ck1510 FIND v(dout0_229) AT=760.025n

.meas tran vdout0_230ck1510 FIND v(dout0_230) AT=760.025n

.meas tran vdout0_231ck1510 FIND v(dout0_231) AT=760.025n

.meas tran vdout0_232ck1510 FIND v(dout0_232) AT=760.025n

.meas tran vdout0_233ck1510 FIND v(dout0_233) AT=760.025n

.meas tran vdout0_234ck1510 FIND v(dout0_234) AT=760.025n

.meas tran vdout0_235ck1510 FIND v(dout0_235) AT=760.025n

.meas tran vdout0_236ck1510 FIND v(dout0_236) AT=760.025n

.meas tran vdout0_237ck1510 FIND v(dout0_237) AT=760.025n

.meas tran vdout0_238ck1510 FIND v(dout0_238) AT=760.025n

.meas tran vdout0_239ck1510 FIND v(dout0_239) AT=760.025n

.meas tran vdout0_240ck1510 FIND v(dout0_240) AT=760.025n

.meas tran vdout0_241ck1510 FIND v(dout0_241) AT=760.025n

.meas tran vdout0_242ck1510 FIND v(dout0_242) AT=760.025n

.meas tran vdout0_243ck1510 FIND v(dout0_243) AT=760.025n

.meas tran vdout0_244ck1510 FIND v(dout0_244) AT=760.025n

.meas tran vdout0_245ck1510 FIND v(dout0_245) AT=760.025n

.meas tran vdout0_246ck1510 FIND v(dout0_246) AT=760.025n

.meas tran vdout0_247ck1510 FIND v(dout0_247) AT=760.025n

.meas tran vdout0_248ck1510 FIND v(dout0_248) AT=760.025n

.meas tran vdout0_249ck1510 FIND v(dout0_249) AT=760.025n

.meas tran vdout0_250ck1510 FIND v(dout0_250) AT=760.025n

.meas tran vdout0_251ck1510 FIND v(dout0_251) AT=760.025n

.meas tran vdout0_252ck1510 FIND v(dout0_252) AT=760.025n

.meas tran vdout0_253ck1510 FIND v(dout0_253) AT=760.025n

.meas tran vdout0_254ck1510 FIND v(dout0_254) AT=760.025n

.meas tran vdout0_255ck1510 FIND v(dout0_255) AT=760.025n

.meas tran vdout0_0ck1530 FIND v(dout0_0) AT=770.025n

.meas tran vdout0_1ck1530 FIND v(dout0_1) AT=770.025n

.meas tran vdout0_2ck1530 FIND v(dout0_2) AT=770.025n

.meas tran vdout0_3ck1530 FIND v(dout0_3) AT=770.025n

.meas tran vdout0_4ck1530 FIND v(dout0_4) AT=770.025n

.meas tran vdout0_5ck1530 FIND v(dout0_5) AT=770.025n

.meas tran vdout0_6ck1530 FIND v(dout0_6) AT=770.025n

.meas tran vdout0_7ck1530 FIND v(dout0_7) AT=770.025n

.meas tran vdout0_8ck1530 FIND v(dout0_8) AT=770.025n

.meas tran vdout0_9ck1530 FIND v(dout0_9) AT=770.025n

.meas tran vdout0_10ck1530 FIND v(dout0_10) AT=770.025n

.meas tran vdout0_11ck1530 FIND v(dout0_11) AT=770.025n

.meas tran vdout0_12ck1530 FIND v(dout0_12) AT=770.025n

.meas tran vdout0_13ck1530 FIND v(dout0_13) AT=770.025n

.meas tran vdout0_14ck1530 FIND v(dout0_14) AT=770.025n

.meas tran vdout0_15ck1530 FIND v(dout0_15) AT=770.025n

.meas tran vdout0_16ck1530 FIND v(dout0_16) AT=770.025n

.meas tran vdout0_17ck1530 FIND v(dout0_17) AT=770.025n

.meas tran vdout0_18ck1530 FIND v(dout0_18) AT=770.025n

.meas tran vdout0_19ck1530 FIND v(dout0_19) AT=770.025n

.meas tran vdout0_20ck1530 FIND v(dout0_20) AT=770.025n

.meas tran vdout0_21ck1530 FIND v(dout0_21) AT=770.025n

.meas tran vdout0_22ck1530 FIND v(dout0_22) AT=770.025n

.meas tran vdout0_23ck1530 FIND v(dout0_23) AT=770.025n

.meas tran vdout0_24ck1530 FIND v(dout0_24) AT=770.025n

.meas tran vdout0_25ck1530 FIND v(dout0_25) AT=770.025n

.meas tran vdout0_26ck1530 FIND v(dout0_26) AT=770.025n

.meas tran vdout0_27ck1530 FIND v(dout0_27) AT=770.025n

.meas tran vdout0_28ck1530 FIND v(dout0_28) AT=770.025n

.meas tran vdout0_29ck1530 FIND v(dout0_29) AT=770.025n

.meas tran vdout0_30ck1530 FIND v(dout0_30) AT=770.025n

.meas tran vdout0_31ck1530 FIND v(dout0_31) AT=770.025n

.meas tran vdout0_32ck1530 FIND v(dout0_32) AT=770.025n

.meas tran vdout0_33ck1530 FIND v(dout0_33) AT=770.025n

.meas tran vdout0_34ck1530 FIND v(dout0_34) AT=770.025n

.meas tran vdout0_35ck1530 FIND v(dout0_35) AT=770.025n

.meas tran vdout0_36ck1530 FIND v(dout0_36) AT=770.025n

.meas tran vdout0_37ck1530 FIND v(dout0_37) AT=770.025n

.meas tran vdout0_38ck1530 FIND v(dout0_38) AT=770.025n

.meas tran vdout0_39ck1530 FIND v(dout0_39) AT=770.025n

.meas tran vdout0_40ck1530 FIND v(dout0_40) AT=770.025n

.meas tran vdout0_41ck1530 FIND v(dout0_41) AT=770.025n

.meas tran vdout0_42ck1530 FIND v(dout0_42) AT=770.025n

.meas tran vdout0_43ck1530 FIND v(dout0_43) AT=770.025n

.meas tran vdout0_44ck1530 FIND v(dout0_44) AT=770.025n

.meas tran vdout0_45ck1530 FIND v(dout0_45) AT=770.025n

.meas tran vdout0_46ck1530 FIND v(dout0_46) AT=770.025n

.meas tran vdout0_47ck1530 FIND v(dout0_47) AT=770.025n

.meas tran vdout0_48ck1530 FIND v(dout0_48) AT=770.025n

.meas tran vdout0_49ck1530 FIND v(dout0_49) AT=770.025n

.meas tran vdout0_50ck1530 FIND v(dout0_50) AT=770.025n

.meas tran vdout0_51ck1530 FIND v(dout0_51) AT=770.025n

.meas tran vdout0_52ck1530 FIND v(dout0_52) AT=770.025n

.meas tran vdout0_53ck1530 FIND v(dout0_53) AT=770.025n

.meas tran vdout0_54ck1530 FIND v(dout0_54) AT=770.025n

.meas tran vdout0_55ck1530 FIND v(dout0_55) AT=770.025n

.meas tran vdout0_56ck1530 FIND v(dout0_56) AT=770.025n

.meas tran vdout0_57ck1530 FIND v(dout0_57) AT=770.025n

.meas tran vdout0_58ck1530 FIND v(dout0_58) AT=770.025n

.meas tran vdout0_59ck1530 FIND v(dout0_59) AT=770.025n

.meas tran vdout0_60ck1530 FIND v(dout0_60) AT=770.025n

.meas tran vdout0_61ck1530 FIND v(dout0_61) AT=770.025n

.meas tran vdout0_62ck1530 FIND v(dout0_62) AT=770.025n

.meas tran vdout0_63ck1530 FIND v(dout0_63) AT=770.025n

.meas tran vdout0_64ck1530 FIND v(dout0_64) AT=770.025n

.meas tran vdout0_65ck1530 FIND v(dout0_65) AT=770.025n

.meas tran vdout0_66ck1530 FIND v(dout0_66) AT=770.025n

.meas tran vdout0_67ck1530 FIND v(dout0_67) AT=770.025n

.meas tran vdout0_68ck1530 FIND v(dout0_68) AT=770.025n

.meas tran vdout0_69ck1530 FIND v(dout0_69) AT=770.025n

.meas tran vdout0_70ck1530 FIND v(dout0_70) AT=770.025n

.meas tran vdout0_71ck1530 FIND v(dout0_71) AT=770.025n

.meas tran vdout0_72ck1530 FIND v(dout0_72) AT=770.025n

.meas tran vdout0_73ck1530 FIND v(dout0_73) AT=770.025n

.meas tran vdout0_74ck1530 FIND v(dout0_74) AT=770.025n

.meas tran vdout0_75ck1530 FIND v(dout0_75) AT=770.025n

.meas tran vdout0_76ck1530 FIND v(dout0_76) AT=770.025n

.meas tran vdout0_77ck1530 FIND v(dout0_77) AT=770.025n

.meas tran vdout0_78ck1530 FIND v(dout0_78) AT=770.025n

.meas tran vdout0_79ck1530 FIND v(dout0_79) AT=770.025n

.meas tran vdout0_80ck1530 FIND v(dout0_80) AT=770.025n

.meas tran vdout0_81ck1530 FIND v(dout0_81) AT=770.025n

.meas tran vdout0_82ck1530 FIND v(dout0_82) AT=770.025n

.meas tran vdout0_83ck1530 FIND v(dout0_83) AT=770.025n

.meas tran vdout0_84ck1530 FIND v(dout0_84) AT=770.025n

.meas tran vdout0_85ck1530 FIND v(dout0_85) AT=770.025n

.meas tran vdout0_86ck1530 FIND v(dout0_86) AT=770.025n

.meas tran vdout0_87ck1530 FIND v(dout0_87) AT=770.025n

.meas tran vdout0_88ck1530 FIND v(dout0_88) AT=770.025n

.meas tran vdout0_89ck1530 FIND v(dout0_89) AT=770.025n

.meas tran vdout0_90ck1530 FIND v(dout0_90) AT=770.025n

.meas tran vdout0_91ck1530 FIND v(dout0_91) AT=770.025n

.meas tran vdout0_92ck1530 FIND v(dout0_92) AT=770.025n

.meas tran vdout0_93ck1530 FIND v(dout0_93) AT=770.025n

.meas tran vdout0_94ck1530 FIND v(dout0_94) AT=770.025n

.meas tran vdout0_95ck1530 FIND v(dout0_95) AT=770.025n

.meas tran vdout0_96ck1530 FIND v(dout0_96) AT=770.025n

.meas tran vdout0_97ck1530 FIND v(dout0_97) AT=770.025n

.meas tran vdout0_98ck1530 FIND v(dout0_98) AT=770.025n

.meas tran vdout0_99ck1530 FIND v(dout0_99) AT=770.025n

.meas tran vdout0_100ck1530 FIND v(dout0_100) AT=770.025n

.meas tran vdout0_101ck1530 FIND v(dout0_101) AT=770.025n

.meas tran vdout0_102ck1530 FIND v(dout0_102) AT=770.025n

.meas tran vdout0_103ck1530 FIND v(dout0_103) AT=770.025n

.meas tran vdout0_104ck1530 FIND v(dout0_104) AT=770.025n

.meas tran vdout0_105ck1530 FIND v(dout0_105) AT=770.025n

.meas tran vdout0_106ck1530 FIND v(dout0_106) AT=770.025n

.meas tran vdout0_107ck1530 FIND v(dout0_107) AT=770.025n

.meas tran vdout0_108ck1530 FIND v(dout0_108) AT=770.025n

.meas tran vdout0_109ck1530 FIND v(dout0_109) AT=770.025n

.meas tran vdout0_110ck1530 FIND v(dout0_110) AT=770.025n

.meas tran vdout0_111ck1530 FIND v(dout0_111) AT=770.025n

.meas tran vdout0_112ck1530 FIND v(dout0_112) AT=770.025n

.meas tran vdout0_113ck1530 FIND v(dout0_113) AT=770.025n

.meas tran vdout0_114ck1530 FIND v(dout0_114) AT=770.025n

.meas tran vdout0_115ck1530 FIND v(dout0_115) AT=770.025n

.meas tran vdout0_116ck1530 FIND v(dout0_116) AT=770.025n

.meas tran vdout0_117ck1530 FIND v(dout0_117) AT=770.025n

.meas tran vdout0_118ck1530 FIND v(dout0_118) AT=770.025n

.meas tran vdout0_119ck1530 FIND v(dout0_119) AT=770.025n

.meas tran vdout0_120ck1530 FIND v(dout0_120) AT=770.025n

.meas tran vdout0_121ck1530 FIND v(dout0_121) AT=770.025n

.meas tran vdout0_122ck1530 FIND v(dout0_122) AT=770.025n

.meas tran vdout0_123ck1530 FIND v(dout0_123) AT=770.025n

.meas tran vdout0_124ck1530 FIND v(dout0_124) AT=770.025n

.meas tran vdout0_125ck1530 FIND v(dout0_125) AT=770.025n

.meas tran vdout0_126ck1530 FIND v(dout0_126) AT=770.025n

.meas tran vdout0_127ck1530 FIND v(dout0_127) AT=770.025n

.meas tran vdout0_128ck1530 FIND v(dout0_128) AT=770.025n

.meas tran vdout0_129ck1530 FIND v(dout0_129) AT=770.025n

.meas tran vdout0_130ck1530 FIND v(dout0_130) AT=770.025n

.meas tran vdout0_131ck1530 FIND v(dout0_131) AT=770.025n

.meas tran vdout0_132ck1530 FIND v(dout0_132) AT=770.025n

.meas tran vdout0_133ck1530 FIND v(dout0_133) AT=770.025n

.meas tran vdout0_134ck1530 FIND v(dout0_134) AT=770.025n

.meas tran vdout0_135ck1530 FIND v(dout0_135) AT=770.025n

.meas tran vdout0_136ck1530 FIND v(dout0_136) AT=770.025n

.meas tran vdout0_137ck1530 FIND v(dout0_137) AT=770.025n

.meas tran vdout0_138ck1530 FIND v(dout0_138) AT=770.025n

.meas tran vdout0_139ck1530 FIND v(dout0_139) AT=770.025n

.meas tran vdout0_140ck1530 FIND v(dout0_140) AT=770.025n

.meas tran vdout0_141ck1530 FIND v(dout0_141) AT=770.025n

.meas tran vdout0_142ck1530 FIND v(dout0_142) AT=770.025n

.meas tran vdout0_143ck1530 FIND v(dout0_143) AT=770.025n

.meas tran vdout0_144ck1530 FIND v(dout0_144) AT=770.025n

.meas tran vdout0_145ck1530 FIND v(dout0_145) AT=770.025n

.meas tran vdout0_146ck1530 FIND v(dout0_146) AT=770.025n

.meas tran vdout0_147ck1530 FIND v(dout0_147) AT=770.025n

.meas tran vdout0_148ck1530 FIND v(dout0_148) AT=770.025n

.meas tran vdout0_149ck1530 FIND v(dout0_149) AT=770.025n

.meas tran vdout0_150ck1530 FIND v(dout0_150) AT=770.025n

.meas tran vdout0_151ck1530 FIND v(dout0_151) AT=770.025n

.meas tran vdout0_152ck1530 FIND v(dout0_152) AT=770.025n

.meas tran vdout0_153ck1530 FIND v(dout0_153) AT=770.025n

.meas tran vdout0_154ck1530 FIND v(dout0_154) AT=770.025n

.meas tran vdout0_155ck1530 FIND v(dout0_155) AT=770.025n

.meas tran vdout0_156ck1530 FIND v(dout0_156) AT=770.025n

.meas tran vdout0_157ck1530 FIND v(dout0_157) AT=770.025n

.meas tran vdout0_158ck1530 FIND v(dout0_158) AT=770.025n

.meas tran vdout0_159ck1530 FIND v(dout0_159) AT=770.025n

.meas tran vdout0_160ck1530 FIND v(dout0_160) AT=770.025n

.meas tran vdout0_161ck1530 FIND v(dout0_161) AT=770.025n

.meas tran vdout0_162ck1530 FIND v(dout0_162) AT=770.025n

.meas tran vdout0_163ck1530 FIND v(dout0_163) AT=770.025n

.meas tran vdout0_164ck1530 FIND v(dout0_164) AT=770.025n

.meas tran vdout0_165ck1530 FIND v(dout0_165) AT=770.025n

.meas tran vdout0_166ck1530 FIND v(dout0_166) AT=770.025n

.meas tran vdout0_167ck1530 FIND v(dout0_167) AT=770.025n

.meas tran vdout0_168ck1530 FIND v(dout0_168) AT=770.025n

.meas tran vdout0_169ck1530 FIND v(dout0_169) AT=770.025n

.meas tran vdout0_170ck1530 FIND v(dout0_170) AT=770.025n

.meas tran vdout0_171ck1530 FIND v(dout0_171) AT=770.025n

.meas tran vdout0_172ck1530 FIND v(dout0_172) AT=770.025n

.meas tran vdout0_173ck1530 FIND v(dout0_173) AT=770.025n

.meas tran vdout0_174ck1530 FIND v(dout0_174) AT=770.025n

.meas tran vdout0_175ck1530 FIND v(dout0_175) AT=770.025n

.meas tran vdout0_176ck1530 FIND v(dout0_176) AT=770.025n

.meas tran vdout0_177ck1530 FIND v(dout0_177) AT=770.025n

.meas tran vdout0_178ck1530 FIND v(dout0_178) AT=770.025n

.meas tran vdout0_179ck1530 FIND v(dout0_179) AT=770.025n

.meas tran vdout0_180ck1530 FIND v(dout0_180) AT=770.025n

.meas tran vdout0_181ck1530 FIND v(dout0_181) AT=770.025n

.meas tran vdout0_182ck1530 FIND v(dout0_182) AT=770.025n

.meas tran vdout0_183ck1530 FIND v(dout0_183) AT=770.025n

.meas tran vdout0_184ck1530 FIND v(dout0_184) AT=770.025n

.meas tran vdout0_185ck1530 FIND v(dout0_185) AT=770.025n

.meas tran vdout0_186ck1530 FIND v(dout0_186) AT=770.025n

.meas tran vdout0_187ck1530 FIND v(dout0_187) AT=770.025n

.meas tran vdout0_188ck1530 FIND v(dout0_188) AT=770.025n

.meas tran vdout0_189ck1530 FIND v(dout0_189) AT=770.025n

.meas tran vdout0_190ck1530 FIND v(dout0_190) AT=770.025n

.meas tran vdout0_191ck1530 FIND v(dout0_191) AT=770.025n

.meas tran vdout0_192ck1530 FIND v(dout0_192) AT=770.025n

.meas tran vdout0_193ck1530 FIND v(dout0_193) AT=770.025n

.meas tran vdout0_194ck1530 FIND v(dout0_194) AT=770.025n

.meas tran vdout0_195ck1530 FIND v(dout0_195) AT=770.025n

.meas tran vdout0_196ck1530 FIND v(dout0_196) AT=770.025n

.meas tran vdout0_197ck1530 FIND v(dout0_197) AT=770.025n

.meas tran vdout0_198ck1530 FIND v(dout0_198) AT=770.025n

.meas tran vdout0_199ck1530 FIND v(dout0_199) AT=770.025n

.meas tran vdout0_200ck1530 FIND v(dout0_200) AT=770.025n

.meas tran vdout0_201ck1530 FIND v(dout0_201) AT=770.025n

.meas tran vdout0_202ck1530 FIND v(dout0_202) AT=770.025n

.meas tran vdout0_203ck1530 FIND v(dout0_203) AT=770.025n

.meas tran vdout0_204ck1530 FIND v(dout0_204) AT=770.025n

.meas tran vdout0_205ck1530 FIND v(dout0_205) AT=770.025n

.meas tran vdout0_206ck1530 FIND v(dout0_206) AT=770.025n

.meas tran vdout0_207ck1530 FIND v(dout0_207) AT=770.025n

.meas tran vdout0_208ck1530 FIND v(dout0_208) AT=770.025n

.meas tran vdout0_209ck1530 FIND v(dout0_209) AT=770.025n

.meas tran vdout0_210ck1530 FIND v(dout0_210) AT=770.025n

.meas tran vdout0_211ck1530 FIND v(dout0_211) AT=770.025n

.meas tran vdout0_212ck1530 FIND v(dout0_212) AT=770.025n

.meas tran vdout0_213ck1530 FIND v(dout0_213) AT=770.025n

.meas tran vdout0_214ck1530 FIND v(dout0_214) AT=770.025n

.meas tran vdout0_215ck1530 FIND v(dout0_215) AT=770.025n

.meas tran vdout0_216ck1530 FIND v(dout0_216) AT=770.025n

.meas tran vdout0_217ck1530 FIND v(dout0_217) AT=770.025n

.meas tran vdout0_218ck1530 FIND v(dout0_218) AT=770.025n

.meas tran vdout0_219ck1530 FIND v(dout0_219) AT=770.025n

.meas tran vdout0_220ck1530 FIND v(dout0_220) AT=770.025n

.meas tran vdout0_221ck1530 FIND v(dout0_221) AT=770.025n

.meas tran vdout0_222ck1530 FIND v(dout0_222) AT=770.025n

.meas tran vdout0_223ck1530 FIND v(dout0_223) AT=770.025n

.meas tran vdout0_224ck1530 FIND v(dout0_224) AT=770.025n

.meas tran vdout0_225ck1530 FIND v(dout0_225) AT=770.025n

.meas tran vdout0_226ck1530 FIND v(dout0_226) AT=770.025n

.meas tran vdout0_227ck1530 FIND v(dout0_227) AT=770.025n

.meas tran vdout0_228ck1530 FIND v(dout0_228) AT=770.025n

.meas tran vdout0_229ck1530 FIND v(dout0_229) AT=770.025n

.meas tran vdout0_230ck1530 FIND v(dout0_230) AT=770.025n

.meas tran vdout0_231ck1530 FIND v(dout0_231) AT=770.025n

.meas tran vdout0_232ck1530 FIND v(dout0_232) AT=770.025n

.meas tran vdout0_233ck1530 FIND v(dout0_233) AT=770.025n

.meas tran vdout0_234ck1530 FIND v(dout0_234) AT=770.025n

.meas tran vdout0_235ck1530 FIND v(dout0_235) AT=770.025n

.meas tran vdout0_236ck1530 FIND v(dout0_236) AT=770.025n

.meas tran vdout0_237ck1530 FIND v(dout0_237) AT=770.025n

.meas tran vdout0_238ck1530 FIND v(dout0_238) AT=770.025n

.meas tran vdout0_239ck1530 FIND v(dout0_239) AT=770.025n

.meas tran vdout0_240ck1530 FIND v(dout0_240) AT=770.025n

.meas tran vdout0_241ck1530 FIND v(dout0_241) AT=770.025n

.meas tran vdout0_242ck1530 FIND v(dout0_242) AT=770.025n

.meas tran vdout0_243ck1530 FIND v(dout0_243) AT=770.025n

.meas tran vdout0_244ck1530 FIND v(dout0_244) AT=770.025n

.meas tran vdout0_245ck1530 FIND v(dout0_245) AT=770.025n

.meas tran vdout0_246ck1530 FIND v(dout0_246) AT=770.025n

.meas tran vdout0_247ck1530 FIND v(dout0_247) AT=770.025n

.meas tran vdout0_248ck1530 FIND v(dout0_248) AT=770.025n

.meas tran vdout0_249ck1530 FIND v(dout0_249) AT=770.025n

.meas tran vdout0_250ck1530 FIND v(dout0_250) AT=770.025n

.meas tran vdout0_251ck1530 FIND v(dout0_251) AT=770.025n

.meas tran vdout0_252ck1530 FIND v(dout0_252) AT=770.025n

.meas tran vdout0_253ck1530 FIND v(dout0_253) AT=770.025n

.meas tran vdout0_254ck1530 FIND v(dout0_254) AT=770.025n

.meas tran vdout0_255ck1530 FIND v(dout0_255) AT=770.025n

.meas tran vdout0_0ck1560 FIND v(dout0_0) AT=785.025n

.meas tran vdout0_1ck1560 FIND v(dout0_1) AT=785.025n

.meas tran vdout0_2ck1560 FIND v(dout0_2) AT=785.025n

.meas tran vdout0_3ck1560 FIND v(dout0_3) AT=785.025n

.meas tran vdout0_4ck1560 FIND v(dout0_4) AT=785.025n

.meas tran vdout0_5ck1560 FIND v(dout0_5) AT=785.025n

.meas tran vdout0_6ck1560 FIND v(dout0_6) AT=785.025n

.meas tran vdout0_7ck1560 FIND v(dout0_7) AT=785.025n

.meas tran vdout0_8ck1560 FIND v(dout0_8) AT=785.025n

.meas tran vdout0_9ck1560 FIND v(dout0_9) AT=785.025n

.meas tran vdout0_10ck1560 FIND v(dout0_10) AT=785.025n

.meas tran vdout0_11ck1560 FIND v(dout0_11) AT=785.025n

.meas tran vdout0_12ck1560 FIND v(dout0_12) AT=785.025n

.meas tran vdout0_13ck1560 FIND v(dout0_13) AT=785.025n

.meas tran vdout0_14ck1560 FIND v(dout0_14) AT=785.025n

.meas tran vdout0_15ck1560 FIND v(dout0_15) AT=785.025n

.meas tran vdout0_16ck1560 FIND v(dout0_16) AT=785.025n

.meas tran vdout0_17ck1560 FIND v(dout0_17) AT=785.025n

.meas tran vdout0_18ck1560 FIND v(dout0_18) AT=785.025n

.meas tran vdout0_19ck1560 FIND v(dout0_19) AT=785.025n

.meas tran vdout0_20ck1560 FIND v(dout0_20) AT=785.025n

.meas tran vdout0_21ck1560 FIND v(dout0_21) AT=785.025n

.meas tran vdout0_22ck1560 FIND v(dout0_22) AT=785.025n

.meas tran vdout0_23ck1560 FIND v(dout0_23) AT=785.025n

.meas tran vdout0_24ck1560 FIND v(dout0_24) AT=785.025n

.meas tran vdout0_25ck1560 FIND v(dout0_25) AT=785.025n

.meas tran vdout0_26ck1560 FIND v(dout0_26) AT=785.025n

.meas tran vdout0_27ck1560 FIND v(dout0_27) AT=785.025n

.meas tran vdout0_28ck1560 FIND v(dout0_28) AT=785.025n

.meas tran vdout0_29ck1560 FIND v(dout0_29) AT=785.025n

.meas tran vdout0_30ck1560 FIND v(dout0_30) AT=785.025n

.meas tran vdout0_31ck1560 FIND v(dout0_31) AT=785.025n

.meas tran vdout0_32ck1560 FIND v(dout0_32) AT=785.025n

.meas tran vdout0_33ck1560 FIND v(dout0_33) AT=785.025n

.meas tran vdout0_34ck1560 FIND v(dout0_34) AT=785.025n

.meas tran vdout0_35ck1560 FIND v(dout0_35) AT=785.025n

.meas tran vdout0_36ck1560 FIND v(dout0_36) AT=785.025n

.meas tran vdout0_37ck1560 FIND v(dout0_37) AT=785.025n

.meas tran vdout0_38ck1560 FIND v(dout0_38) AT=785.025n

.meas tran vdout0_39ck1560 FIND v(dout0_39) AT=785.025n

.meas tran vdout0_40ck1560 FIND v(dout0_40) AT=785.025n

.meas tran vdout0_41ck1560 FIND v(dout0_41) AT=785.025n

.meas tran vdout0_42ck1560 FIND v(dout0_42) AT=785.025n

.meas tran vdout0_43ck1560 FIND v(dout0_43) AT=785.025n

.meas tran vdout0_44ck1560 FIND v(dout0_44) AT=785.025n

.meas tran vdout0_45ck1560 FIND v(dout0_45) AT=785.025n

.meas tran vdout0_46ck1560 FIND v(dout0_46) AT=785.025n

.meas tran vdout0_47ck1560 FIND v(dout0_47) AT=785.025n

.meas tran vdout0_48ck1560 FIND v(dout0_48) AT=785.025n

.meas tran vdout0_49ck1560 FIND v(dout0_49) AT=785.025n

.meas tran vdout0_50ck1560 FIND v(dout0_50) AT=785.025n

.meas tran vdout0_51ck1560 FIND v(dout0_51) AT=785.025n

.meas tran vdout0_52ck1560 FIND v(dout0_52) AT=785.025n

.meas tran vdout0_53ck1560 FIND v(dout0_53) AT=785.025n

.meas tran vdout0_54ck1560 FIND v(dout0_54) AT=785.025n

.meas tran vdout0_55ck1560 FIND v(dout0_55) AT=785.025n

.meas tran vdout0_56ck1560 FIND v(dout0_56) AT=785.025n

.meas tran vdout0_57ck1560 FIND v(dout0_57) AT=785.025n

.meas tran vdout0_58ck1560 FIND v(dout0_58) AT=785.025n

.meas tran vdout0_59ck1560 FIND v(dout0_59) AT=785.025n

.meas tran vdout0_60ck1560 FIND v(dout0_60) AT=785.025n

.meas tran vdout0_61ck1560 FIND v(dout0_61) AT=785.025n

.meas tran vdout0_62ck1560 FIND v(dout0_62) AT=785.025n

.meas tran vdout0_63ck1560 FIND v(dout0_63) AT=785.025n

.meas tran vdout0_64ck1560 FIND v(dout0_64) AT=785.025n

.meas tran vdout0_65ck1560 FIND v(dout0_65) AT=785.025n

.meas tran vdout0_66ck1560 FIND v(dout0_66) AT=785.025n

.meas tran vdout0_67ck1560 FIND v(dout0_67) AT=785.025n

.meas tran vdout0_68ck1560 FIND v(dout0_68) AT=785.025n

.meas tran vdout0_69ck1560 FIND v(dout0_69) AT=785.025n

.meas tran vdout0_70ck1560 FIND v(dout0_70) AT=785.025n

.meas tran vdout0_71ck1560 FIND v(dout0_71) AT=785.025n

.meas tran vdout0_72ck1560 FIND v(dout0_72) AT=785.025n

.meas tran vdout0_73ck1560 FIND v(dout0_73) AT=785.025n

.meas tran vdout0_74ck1560 FIND v(dout0_74) AT=785.025n

.meas tran vdout0_75ck1560 FIND v(dout0_75) AT=785.025n

.meas tran vdout0_76ck1560 FIND v(dout0_76) AT=785.025n

.meas tran vdout0_77ck1560 FIND v(dout0_77) AT=785.025n

.meas tran vdout0_78ck1560 FIND v(dout0_78) AT=785.025n

.meas tran vdout0_79ck1560 FIND v(dout0_79) AT=785.025n

.meas tran vdout0_80ck1560 FIND v(dout0_80) AT=785.025n

.meas tran vdout0_81ck1560 FIND v(dout0_81) AT=785.025n

.meas tran vdout0_82ck1560 FIND v(dout0_82) AT=785.025n

.meas tran vdout0_83ck1560 FIND v(dout0_83) AT=785.025n

.meas tran vdout0_84ck1560 FIND v(dout0_84) AT=785.025n

.meas tran vdout0_85ck1560 FIND v(dout0_85) AT=785.025n

.meas tran vdout0_86ck1560 FIND v(dout0_86) AT=785.025n

.meas tran vdout0_87ck1560 FIND v(dout0_87) AT=785.025n

.meas tran vdout0_88ck1560 FIND v(dout0_88) AT=785.025n

.meas tran vdout0_89ck1560 FIND v(dout0_89) AT=785.025n

.meas tran vdout0_90ck1560 FIND v(dout0_90) AT=785.025n

.meas tran vdout0_91ck1560 FIND v(dout0_91) AT=785.025n

.meas tran vdout0_92ck1560 FIND v(dout0_92) AT=785.025n

.meas tran vdout0_93ck1560 FIND v(dout0_93) AT=785.025n

.meas tran vdout0_94ck1560 FIND v(dout0_94) AT=785.025n

.meas tran vdout0_95ck1560 FIND v(dout0_95) AT=785.025n

.meas tran vdout0_96ck1560 FIND v(dout0_96) AT=785.025n

.meas tran vdout0_97ck1560 FIND v(dout0_97) AT=785.025n

.meas tran vdout0_98ck1560 FIND v(dout0_98) AT=785.025n

.meas tran vdout0_99ck1560 FIND v(dout0_99) AT=785.025n

.meas tran vdout0_100ck1560 FIND v(dout0_100) AT=785.025n

.meas tran vdout0_101ck1560 FIND v(dout0_101) AT=785.025n

.meas tran vdout0_102ck1560 FIND v(dout0_102) AT=785.025n

.meas tran vdout0_103ck1560 FIND v(dout0_103) AT=785.025n

.meas tran vdout0_104ck1560 FIND v(dout0_104) AT=785.025n

.meas tran vdout0_105ck1560 FIND v(dout0_105) AT=785.025n

.meas tran vdout0_106ck1560 FIND v(dout0_106) AT=785.025n

.meas tran vdout0_107ck1560 FIND v(dout0_107) AT=785.025n

.meas tran vdout0_108ck1560 FIND v(dout0_108) AT=785.025n

.meas tran vdout0_109ck1560 FIND v(dout0_109) AT=785.025n

.meas tran vdout0_110ck1560 FIND v(dout0_110) AT=785.025n

.meas tran vdout0_111ck1560 FIND v(dout0_111) AT=785.025n

.meas tran vdout0_112ck1560 FIND v(dout0_112) AT=785.025n

.meas tran vdout0_113ck1560 FIND v(dout0_113) AT=785.025n

.meas tran vdout0_114ck1560 FIND v(dout0_114) AT=785.025n

.meas tran vdout0_115ck1560 FIND v(dout0_115) AT=785.025n

.meas tran vdout0_116ck1560 FIND v(dout0_116) AT=785.025n

.meas tran vdout0_117ck1560 FIND v(dout0_117) AT=785.025n

.meas tran vdout0_118ck1560 FIND v(dout0_118) AT=785.025n

.meas tran vdout0_119ck1560 FIND v(dout0_119) AT=785.025n

.meas tran vdout0_120ck1560 FIND v(dout0_120) AT=785.025n

.meas tran vdout0_121ck1560 FIND v(dout0_121) AT=785.025n

.meas tran vdout0_122ck1560 FIND v(dout0_122) AT=785.025n

.meas tran vdout0_123ck1560 FIND v(dout0_123) AT=785.025n

.meas tran vdout0_124ck1560 FIND v(dout0_124) AT=785.025n

.meas tran vdout0_125ck1560 FIND v(dout0_125) AT=785.025n

.meas tran vdout0_126ck1560 FIND v(dout0_126) AT=785.025n

.meas tran vdout0_127ck1560 FIND v(dout0_127) AT=785.025n

.meas tran vdout0_128ck1560 FIND v(dout0_128) AT=785.025n

.meas tran vdout0_129ck1560 FIND v(dout0_129) AT=785.025n

.meas tran vdout0_130ck1560 FIND v(dout0_130) AT=785.025n

.meas tran vdout0_131ck1560 FIND v(dout0_131) AT=785.025n

.meas tran vdout0_132ck1560 FIND v(dout0_132) AT=785.025n

.meas tran vdout0_133ck1560 FIND v(dout0_133) AT=785.025n

.meas tran vdout0_134ck1560 FIND v(dout0_134) AT=785.025n

.meas tran vdout0_135ck1560 FIND v(dout0_135) AT=785.025n

.meas tran vdout0_136ck1560 FIND v(dout0_136) AT=785.025n

.meas tran vdout0_137ck1560 FIND v(dout0_137) AT=785.025n

.meas tran vdout0_138ck1560 FIND v(dout0_138) AT=785.025n

.meas tran vdout0_139ck1560 FIND v(dout0_139) AT=785.025n

.meas tran vdout0_140ck1560 FIND v(dout0_140) AT=785.025n

.meas tran vdout0_141ck1560 FIND v(dout0_141) AT=785.025n

.meas tran vdout0_142ck1560 FIND v(dout0_142) AT=785.025n

.meas tran vdout0_143ck1560 FIND v(dout0_143) AT=785.025n

.meas tran vdout0_144ck1560 FIND v(dout0_144) AT=785.025n

.meas tran vdout0_145ck1560 FIND v(dout0_145) AT=785.025n

.meas tran vdout0_146ck1560 FIND v(dout0_146) AT=785.025n

.meas tran vdout0_147ck1560 FIND v(dout0_147) AT=785.025n

.meas tran vdout0_148ck1560 FIND v(dout0_148) AT=785.025n

.meas tran vdout0_149ck1560 FIND v(dout0_149) AT=785.025n

.meas tran vdout0_150ck1560 FIND v(dout0_150) AT=785.025n

.meas tran vdout0_151ck1560 FIND v(dout0_151) AT=785.025n

.meas tran vdout0_152ck1560 FIND v(dout0_152) AT=785.025n

.meas tran vdout0_153ck1560 FIND v(dout0_153) AT=785.025n

.meas tran vdout0_154ck1560 FIND v(dout0_154) AT=785.025n

.meas tran vdout0_155ck1560 FIND v(dout0_155) AT=785.025n

.meas tran vdout0_156ck1560 FIND v(dout0_156) AT=785.025n

.meas tran vdout0_157ck1560 FIND v(dout0_157) AT=785.025n

.meas tran vdout0_158ck1560 FIND v(dout0_158) AT=785.025n

.meas tran vdout0_159ck1560 FIND v(dout0_159) AT=785.025n

.meas tran vdout0_160ck1560 FIND v(dout0_160) AT=785.025n

.meas tran vdout0_161ck1560 FIND v(dout0_161) AT=785.025n

.meas tran vdout0_162ck1560 FIND v(dout0_162) AT=785.025n

.meas tran vdout0_163ck1560 FIND v(dout0_163) AT=785.025n

.meas tran vdout0_164ck1560 FIND v(dout0_164) AT=785.025n

.meas tran vdout0_165ck1560 FIND v(dout0_165) AT=785.025n

.meas tran vdout0_166ck1560 FIND v(dout0_166) AT=785.025n

.meas tran vdout0_167ck1560 FIND v(dout0_167) AT=785.025n

.meas tran vdout0_168ck1560 FIND v(dout0_168) AT=785.025n

.meas tran vdout0_169ck1560 FIND v(dout0_169) AT=785.025n

.meas tran vdout0_170ck1560 FIND v(dout0_170) AT=785.025n

.meas tran vdout0_171ck1560 FIND v(dout0_171) AT=785.025n

.meas tran vdout0_172ck1560 FIND v(dout0_172) AT=785.025n

.meas tran vdout0_173ck1560 FIND v(dout0_173) AT=785.025n

.meas tran vdout0_174ck1560 FIND v(dout0_174) AT=785.025n

.meas tran vdout0_175ck1560 FIND v(dout0_175) AT=785.025n

.meas tran vdout0_176ck1560 FIND v(dout0_176) AT=785.025n

.meas tran vdout0_177ck1560 FIND v(dout0_177) AT=785.025n

.meas tran vdout0_178ck1560 FIND v(dout0_178) AT=785.025n

.meas tran vdout0_179ck1560 FIND v(dout0_179) AT=785.025n

.meas tran vdout0_180ck1560 FIND v(dout0_180) AT=785.025n

.meas tran vdout0_181ck1560 FIND v(dout0_181) AT=785.025n

.meas tran vdout0_182ck1560 FIND v(dout0_182) AT=785.025n

.meas tran vdout0_183ck1560 FIND v(dout0_183) AT=785.025n

.meas tran vdout0_184ck1560 FIND v(dout0_184) AT=785.025n

.meas tran vdout0_185ck1560 FIND v(dout0_185) AT=785.025n

.meas tran vdout0_186ck1560 FIND v(dout0_186) AT=785.025n

.meas tran vdout0_187ck1560 FIND v(dout0_187) AT=785.025n

.meas tran vdout0_188ck1560 FIND v(dout0_188) AT=785.025n

.meas tran vdout0_189ck1560 FIND v(dout0_189) AT=785.025n

.meas tran vdout0_190ck1560 FIND v(dout0_190) AT=785.025n

.meas tran vdout0_191ck1560 FIND v(dout0_191) AT=785.025n

.meas tran vdout0_192ck1560 FIND v(dout0_192) AT=785.025n

.meas tran vdout0_193ck1560 FIND v(dout0_193) AT=785.025n

.meas tran vdout0_194ck1560 FIND v(dout0_194) AT=785.025n

.meas tran vdout0_195ck1560 FIND v(dout0_195) AT=785.025n

.meas tran vdout0_196ck1560 FIND v(dout0_196) AT=785.025n

.meas tran vdout0_197ck1560 FIND v(dout0_197) AT=785.025n

.meas tran vdout0_198ck1560 FIND v(dout0_198) AT=785.025n

.meas tran vdout0_199ck1560 FIND v(dout0_199) AT=785.025n

.meas tran vdout0_200ck1560 FIND v(dout0_200) AT=785.025n

.meas tran vdout0_201ck1560 FIND v(dout0_201) AT=785.025n

.meas tran vdout0_202ck1560 FIND v(dout0_202) AT=785.025n

.meas tran vdout0_203ck1560 FIND v(dout0_203) AT=785.025n

.meas tran vdout0_204ck1560 FIND v(dout0_204) AT=785.025n

.meas tran vdout0_205ck1560 FIND v(dout0_205) AT=785.025n

.meas tran vdout0_206ck1560 FIND v(dout0_206) AT=785.025n

.meas tran vdout0_207ck1560 FIND v(dout0_207) AT=785.025n

.meas tran vdout0_208ck1560 FIND v(dout0_208) AT=785.025n

.meas tran vdout0_209ck1560 FIND v(dout0_209) AT=785.025n

.meas tran vdout0_210ck1560 FIND v(dout0_210) AT=785.025n

.meas tran vdout0_211ck1560 FIND v(dout0_211) AT=785.025n

.meas tran vdout0_212ck1560 FIND v(dout0_212) AT=785.025n

.meas tran vdout0_213ck1560 FIND v(dout0_213) AT=785.025n

.meas tran vdout0_214ck1560 FIND v(dout0_214) AT=785.025n

.meas tran vdout0_215ck1560 FIND v(dout0_215) AT=785.025n

.meas tran vdout0_216ck1560 FIND v(dout0_216) AT=785.025n

.meas tran vdout0_217ck1560 FIND v(dout0_217) AT=785.025n

.meas tran vdout0_218ck1560 FIND v(dout0_218) AT=785.025n

.meas tran vdout0_219ck1560 FIND v(dout0_219) AT=785.025n

.meas tran vdout0_220ck1560 FIND v(dout0_220) AT=785.025n

.meas tran vdout0_221ck1560 FIND v(dout0_221) AT=785.025n

.meas tran vdout0_222ck1560 FIND v(dout0_222) AT=785.025n

.meas tran vdout0_223ck1560 FIND v(dout0_223) AT=785.025n

.meas tran vdout0_224ck1560 FIND v(dout0_224) AT=785.025n

.meas tran vdout0_225ck1560 FIND v(dout0_225) AT=785.025n

.meas tran vdout0_226ck1560 FIND v(dout0_226) AT=785.025n

.meas tran vdout0_227ck1560 FIND v(dout0_227) AT=785.025n

.meas tran vdout0_228ck1560 FIND v(dout0_228) AT=785.025n

.meas tran vdout0_229ck1560 FIND v(dout0_229) AT=785.025n

.meas tran vdout0_230ck1560 FIND v(dout0_230) AT=785.025n

.meas tran vdout0_231ck1560 FIND v(dout0_231) AT=785.025n

.meas tran vdout0_232ck1560 FIND v(dout0_232) AT=785.025n

.meas tran vdout0_233ck1560 FIND v(dout0_233) AT=785.025n

.meas tran vdout0_234ck1560 FIND v(dout0_234) AT=785.025n

.meas tran vdout0_235ck1560 FIND v(dout0_235) AT=785.025n

.meas tran vdout0_236ck1560 FIND v(dout0_236) AT=785.025n

.meas tran vdout0_237ck1560 FIND v(dout0_237) AT=785.025n

.meas tran vdout0_238ck1560 FIND v(dout0_238) AT=785.025n

.meas tran vdout0_239ck1560 FIND v(dout0_239) AT=785.025n

.meas tran vdout0_240ck1560 FIND v(dout0_240) AT=785.025n

.meas tran vdout0_241ck1560 FIND v(dout0_241) AT=785.025n

.meas tran vdout0_242ck1560 FIND v(dout0_242) AT=785.025n

.meas tran vdout0_243ck1560 FIND v(dout0_243) AT=785.025n

.meas tran vdout0_244ck1560 FIND v(dout0_244) AT=785.025n

.meas tran vdout0_245ck1560 FIND v(dout0_245) AT=785.025n

.meas tran vdout0_246ck1560 FIND v(dout0_246) AT=785.025n

.meas tran vdout0_247ck1560 FIND v(dout0_247) AT=785.025n

.meas tran vdout0_248ck1560 FIND v(dout0_248) AT=785.025n

.meas tran vdout0_249ck1560 FIND v(dout0_249) AT=785.025n

.meas tran vdout0_250ck1560 FIND v(dout0_250) AT=785.025n

.meas tran vdout0_251ck1560 FIND v(dout0_251) AT=785.025n

.meas tran vdout0_252ck1560 FIND v(dout0_252) AT=785.025n

.meas tran vdout0_253ck1560 FIND v(dout0_253) AT=785.025n

.meas tran vdout0_254ck1560 FIND v(dout0_254) AT=785.025n

.meas tran vdout0_255ck1560 FIND v(dout0_255) AT=785.025n

.meas tran vdout0_0ck1640 FIND v(dout0_0) AT=825.025n

.meas tran vdout0_1ck1640 FIND v(dout0_1) AT=825.025n

.meas tran vdout0_2ck1640 FIND v(dout0_2) AT=825.025n

.meas tran vdout0_3ck1640 FIND v(dout0_3) AT=825.025n

.meas tran vdout0_4ck1640 FIND v(dout0_4) AT=825.025n

.meas tran vdout0_5ck1640 FIND v(dout0_5) AT=825.025n

.meas tran vdout0_6ck1640 FIND v(dout0_6) AT=825.025n

.meas tran vdout0_7ck1640 FIND v(dout0_7) AT=825.025n

.meas tran vdout0_8ck1640 FIND v(dout0_8) AT=825.025n

.meas tran vdout0_9ck1640 FIND v(dout0_9) AT=825.025n

.meas tran vdout0_10ck1640 FIND v(dout0_10) AT=825.025n

.meas tran vdout0_11ck1640 FIND v(dout0_11) AT=825.025n

.meas tran vdout0_12ck1640 FIND v(dout0_12) AT=825.025n

.meas tran vdout0_13ck1640 FIND v(dout0_13) AT=825.025n

.meas tran vdout0_14ck1640 FIND v(dout0_14) AT=825.025n

.meas tran vdout0_15ck1640 FIND v(dout0_15) AT=825.025n

.meas tran vdout0_16ck1640 FIND v(dout0_16) AT=825.025n

.meas tran vdout0_17ck1640 FIND v(dout0_17) AT=825.025n

.meas tran vdout0_18ck1640 FIND v(dout0_18) AT=825.025n

.meas tran vdout0_19ck1640 FIND v(dout0_19) AT=825.025n

.meas tran vdout0_20ck1640 FIND v(dout0_20) AT=825.025n

.meas tran vdout0_21ck1640 FIND v(dout0_21) AT=825.025n

.meas tran vdout0_22ck1640 FIND v(dout0_22) AT=825.025n

.meas tran vdout0_23ck1640 FIND v(dout0_23) AT=825.025n

.meas tran vdout0_24ck1640 FIND v(dout0_24) AT=825.025n

.meas tran vdout0_25ck1640 FIND v(dout0_25) AT=825.025n

.meas tran vdout0_26ck1640 FIND v(dout0_26) AT=825.025n

.meas tran vdout0_27ck1640 FIND v(dout0_27) AT=825.025n

.meas tran vdout0_28ck1640 FIND v(dout0_28) AT=825.025n

.meas tran vdout0_29ck1640 FIND v(dout0_29) AT=825.025n

.meas tran vdout0_30ck1640 FIND v(dout0_30) AT=825.025n

.meas tran vdout0_31ck1640 FIND v(dout0_31) AT=825.025n

.meas tran vdout0_32ck1640 FIND v(dout0_32) AT=825.025n

.meas tran vdout0_33ck1640 FIND v(dout0_33) AT=825.025n

.meas tran vdout0_34ck1640 FIND v(dout0_34) AT=825.025n

.meas tran vdout0_35ck1640 FIND v(dout0_35) AT=825.025n

.meas tran vdout0_36ck1640 FIND v(dout0_36) AT=825.025n

.meas tran vdout0_37ck1640 FIND v(dout0_37) AT=825.025n

.meas tran vdout0_38ck1640 FIND v(dout0_38) AT=825.025n

.meas tran vdout0_39ck1640 FIND v(dout0_39) AT=825.025n

.meas tran vdout0_40ck1640 FIND v(dout0_40) AT=825.025n

.meas tran vdout0_41ck1640 FIND v(dout0_41) AT=825.025n

.meas tran vdout0_42ck1640 FIND v(dout0_42) AT=825.025n

.meas tran vdout0_43ck1640 FIND v(dout0_43) AT=825.025n

.meas tran vdout0_44ck1640 FIND v(dout0_44) AT=825.025n

.meas tran vdout0_45ck1640 FIND v(dout0_45) AT=825.025n

.meas tran vdout0_46ck1640 FIND v(dout0_46) AT=825.025n

.meas tran vdout0_47ck1640 FIND v(dout0_47) AT=825.025n

.meas tran vdout0_48ck1640 FIND v(dout0_48) AT=825.025n

.meas tran vdout0_49ck1640 FIND v(dout0_49) AT=825.025n

.meas tran vdout0_50ck1640 FIND v(dout0_50) AT=825.025n

.meas tran vdout0_51ck1640 FIND v(dout0_51) AT=825.025n

.meas tran vdout0_52ck1640 FIND v(dout0_52) AT=825.025n

.meas tran vdout0_53ck1640 FIND v(dout0_53) AT=825.025n

.meas tran vdout0_54ck1640 FIND v(dout0_54) AT=825.025n

.meas tran vdout0_55ck1640 FIND v(dout0_55) AT=825.025n

.meas tran vdout0_56ck1640 FIND v(dout0_56) AT=825.025n

.meas tran vdout0_57ck1640 FIND v(dout0_57) AT=825.025n

.meas tran vdout0_58ck1640 FIND v(dout0_58) AT=825.025n

.meas tran vdout0_59ck1640 FIND v(dout0_59) AT=825.025n

.meas tran vdout0_60ck1640 FIND v(dout0_60) AT=825.025n

.meas tran vdout0_61ck1640 FIND v(dout0_61) AT=825.025n

.meas tran vdout0_62ck1640 FIND v(dout0_62) AT=825.025n

.meas tran vdout0_63ck1640 FIND v(dout0_63) AT=825.025n

.meas tran vdout0_64ck1640 FIND v(dout0_64) AT=825.025n

.meas tran vdout0_65ck1640 FIND v(dout0_65) AT=825.025n

.meas tran vdout0_66ck1640 FIND v(dout0_66) AT=825.025n

.meas tran vdout0_67ck1640 FIND v(dout0_67) AT=825.025n

.meas tran vdout0_68ck1640 FIND v(dout0_68) AT=825.025n

.meas tran vdout0_69ck1640 FIND v(dout0_69) AT=825.025n

.meas tran vdout0_70ck1640 FIND v(dout0_70) AT=825.025n

.meas tran vdout0_71ck1640 FIND v(dout0_71) AT=825.025n

.meas tran vdout0_72ck1640 FIND v(dout0_72) AT=825.025n

.meas tran vdout0_73ck1640 FIND v(dout0_73) AT=825.025n

.meas tran vdout0_74ck1640 FIND v(dout0_74) AT=825.025n

.meas tran vdout0_75ck1640 FIND v(dout0_75) AT=825.025n

.meas tran vdout0_76ck1640 FIND v(dout0_76) AT=825.025n

.meas tran vdout0_77ck1640 FIND v(dout0_77) AT=825.025n

.meas tran vdout0_78ck1640 FIND v(dout0_78) AT=825.025n

.meas tran vdout0_79ck1640 FIND v(dout0_79) AT=825.025n

.meas tran vdout0_80ck1640 FIND v(dout0_80) AT=825.025n

.meas tran vdout0_81ck1640 FIND v(dout0_81) AT=825.025n

.meas tran vdout0_82ck1640 FIND v(dout0_82) AT=825.025n

.meas tran vdout0_83ck1640 FIND v(dout0_83) AT=825.025n

.meas tran vdout0_84ck1640 FIND v(dout0_84) AT=825.025n

.meas tran vdout0_85ck1640 FIND v(dout0_85) AT=825.025n

.meas tran vdout0_86ck1640 FIND v(dout0_86) AT=825.025n

.meas tran vdout0_87ck1640 FIND v(dout0_87) AT=825.025n

.meas tran vdout0_88ck1640 FIND v(dout0_88) AT=825.025n

.meas tran vdout0_89ck1640 FIND v(dout0_89) AT=825.025n

.meas tran vdout0_90ck1640 FIND v(dout0_90) AT=825.025n

.meas tran vdout0_91ck1640 FIND v(dout0_91) AT=825.025n

.meas tran vdout0_92ck1640 FIND v(dout0_92) AT=825.025n

.meas tran vdout0_93ck1640 FIND v(dout0_93) AT=825.025n

.meas tran vdout0_94ck1640 FIND v(dout0_94) AT=825.025n

.meas tran vdout0_95ck1640 FIND v(dout0_95) AT=825.025n

.meas tran vdout0_96ck1640 FIND v(dout0_96) AT=825.025n

.meas tran vdout0_97ck1640 FIND v(dout0_97) AT=825.025n

.meas tran vdout0_98ck1640 FIND v(dout0_98) AT=825.025n

.meas tran vdout0_99ck1640 FIND v(dout0_99) AT=825.025n

.meas tran vdout0_100ck1640 FIND v(dout0_100) AT=825.025n

.meas tran vdout0_101ck1640 FIND v(dout0_101) AT=825.025n

.meas tran vdout0_102ck1640 FIND v(dout0_102) AT=825.025n

.meas tran vdout0_103ck1640 FIND v(dout0_103) AT=825.025n

.meas tran vdout0_104ck1640 FIND v(dout0_104) AT=825.025n

.meas tran vdout0_105ck1640 FIND v(dout0_105) AT=825.025n

.meas tran vdout0_106ck1640 FIND v(dout0_106) AT=825.025n

.meas tran vdout0_107ck1640 FIND v(dout0_107) AT=825.025n

.meas tran vdout0_108ck1640 FIND v(dout0_108) AT=825.025n

.meas tran vdout0_109ck1640 FIND v(dout0_109) AT=825.025n

.meas tran vdout0_110ck1640 FIND v(dout0_110) AT=825.025n

.meas tran vdout0_111ck1640 FIND v(dout0_111) AT=825.025n

.meas tran vdout0_112ck1640 FIND v(dout0_112) AT=825.025n

.meas tran vdout0_113ck1640 FIND v(dout0_113) AT=825.025n

.meas tran vdout0_114ck1640 FIND v(dout0_114) AT=825.025n

.meas tran vdout0_115ck1640 FIND v(dout0_115) AT=825.025n

.meas tran vdout0_116ck1640 FIND v(dout0_116) AT=825.025n

.meas tran vdout0_117ck1640 FIND v(dout0_117) AT=825.025n

.meas tran vdout0_118ck1640 FIND v(dout0_118) AT=825.025n

.meas tran vdout0_119ck1640 FIND v(dout0_119) AT=825.025n

.meas tran vdout0_120ck1640 FIND v(dout0_120) AT=825.025n

.meas tran vdout0_121ck1640 FIND v(dout0_121) AT=825.025n

.meas tran vdout0_122ck1640 FIND v(dout0_122) AT=825.025n

.meas tran vdout0_123ck1640 FIND v(dout0_123) AT=825.025n

.meas tran vdout0_124ck1640 FIND v(dout0_124) AT=825.025n

.meas tran vdout0_125ck1640 FIND v(dout0_125) AT=825.025n

.meas tran vdout0_126ck1640 FIND v(dout0_126) AT=825.025n

.meas tran vdout0_127ck1640 FIND v(dout0_127) AT=825.025n

.meas tran vdout0_128ck1640 FIND v(dout0_128) AT=825.025n

.meas tran vdout0_129ck1640 FIND v(dout0_129) AT=825.025n

.meas tran vdout0_130ck1640 FIND v(dout0_130) AT=825.025n

.meas tran vdout0_131ck1640 FIND v(dout0_131) AT=825.025n

.meas tran vdout0_132ck1640 FIND v(dout0_132) AT=825.025n

.meas tran vdout0_133ck1640 FIND v(dout0_133) AT=825.025n

.meas tran vdout0_134ck1640 FIND v(dout0_134) AT=825.025n

.meas tran vdout0_135ck1640 FIND v(dout0_135) AT=825.025n

.meas tran vdout0_136ck1640 FIND v(dout0_136) AT=825.025n

.meas tran vdout0_137ck1640 FIND v(dout0_137) AT=825.025n

.meas tran vdout0_138ck1640 FIND v(dout0_138) AT=825.025n

.meas tran vdout0_139ck1640 FIND v(dout0_139) AT=825.025n

.meas tran vdout0_140ck1640 FIND v(dout0_140) AT=825.025n

.meas tran vdout0_141ck1640 FIND v(dout0_141) AT=825.025n

.meas tran vdout0_142ck1640 FIND v(dout0_142) AT=825.025n

.meas tran vdout0_143ck1640 FIND v(dout0_143) AT=825.025n

.meas tran vdout0_144ck1640 FIND v(dout0_144) AT=825.025n

.meas tran vdout0_145ck1640 FIND v(dout0_145) AT=825.025n

.meas tran vdout0_146ck1640 FIND v(dout0_146) AT=825.025n

.meas tran vdout0_147ck1640 FIND v(dout0_147) AT=825.025n

.meas tran vdout0_148ck1640 FIND v(dout0_148) AT=825.025n

.meas tran vdout0_149ck1640 FIND v(dout0_149) AT=825.025n

.meas tran vdout0_150ck1640 FIND v(dout0_150) AT=825.025n

.meas tran vdout0_151ck1640 FIND v(dout0_151) AT=825.025n

.meas tran vdout0_152ck1640 FIND v(dout0_152) AT=825.025n

.meas tran vdout0_153ck1640 FIND v(dout0_153) AT=825.025n

.meas tran vdout0_154ck1640 FIND v(dout0_154) AT=825.025n

.meas tran vdout0_155ck1640 FIND v(dout0_155) AT=825.025n

.meas tran vdout0_156ck1640 FIND v(dout0_156) AT=825.025n

.meas tran vdout0_157ck1640 FIND v(dout0_157) AT=825.025n

.meas tran vdout0_158ck1640 FIND v(dout0_158) AT=825.025n

.meas tran vdout0_159ck1640 FIND v(dout0_159) AT=825.025n

.meas tran vdout0_160ck1640 FIND v(dout0_160) AT=825.025n

.meas tran vdout0_161ck1640 FIND v(dout0_161) AT=825.025n

.meas tran vdout0_162ck1640 FIND v(dout0_162) AT=825.025n

.meas tran vdout0_163ck1640 FIND v(dout0_163) AT=825.025n

.meas tran vdout0_164ck1640 FIND v(dout0_164) AT=825.025n

.meas tran vdout0_165ck1640 FIND v(dout0_165) AT=825.025n

.meas tran vdout0_166ck1640 FIND v(dout0_166) AT=825.025n

.meas tran vdout0_167ck1640 FIND v(dout0_167) AT=825.025n

.meas tran vdout0_168ck1640 FIND v(dout0_168) AT=825.025n

.meas tran vdout0_169ck1640 FIND v(dout0_169) AT=825.025n

.meas tran vdout0_170ck1640 FIND v(dout0_170) AT=825.025n

.meas tran vdout0_171ck1640 FIND v(dout0_171) AT=825.025n

.meas tran vdout0_172ck1640 FIND v(dout0_172) AT=825.025n

.meas tran vdout0_173ck1640 FIND v(dout0_173) AT=825.025n

.meas tran vdout0_174ck1640 FIND v(dout0_174) AT=825.025n

.meas tran vdout0_175ck1640 FIND v(dout0_175) AT=825.025n

.meas tran vdout0_176ck1640 FIND v(dout0_176) AT=825.025n

.meas tran vdout0_177ck1640 FIND v(dout0_177) AT=825.025n

.meas tran vdout0_178ck1640 FIND v(dout0_178) AT=825.025n

.meas tran vdout0_179ck1640 FIND v(dout0_179) AT=825.025n

.meas tran vdout0_180ck1640 FIND v(dout0_180) AT=825.025n

.meas tran vdout0_181ck1640 FIND v(dout0_181) AT=825.025n

.meas tran vdout0_182ck1640 FIND v(dout0_182) AT=825.025n

.meas tran vdout0_183ck1640 FIND v(dout0_183) AT=825.025n

.meas tran vdout0_184ck1640 FIND v(dout0_184) AT=825.025n

.meas tran vdout0_185ck1640 FIND v(dout0_185) AT=825.025n

.meas tran vdout0_186ck1640 FIND v(dout0_186) AT=825.025n

.meas tran vdout0_187ck1640 FIND v(dout0_187) AT=825.025n

.meas tran vdout0_188ck1640 FIND v(dout0_188) AT=825.025n

.meas tran vdout0_189ck1640 FIND v(dout0_189) AT=825.025n

.meas tran vdout0_190ck1640 FIND v(dout0_190) AT=825.025n

.meas tran vdout0_191ck1640 FIND v(dout0_191) AT=825.025n

.meas tran vdout0_192ck1640 FIND v(dout0_192) AT=825.025n

.meas tran vdout0_193ck1640 FIND v(dout0_193) AT=825.025n

.meas tran vdout0_194ck1640 FIND v(dout0_194) AT=825.025n

.meas tran vdout0_195ck1640 FIND v(dout0_195) AT=825.025n

.meas tran vdout0_196ck1640 FIND v(dout0_196) AT=825.025n

.meas tran vdout0_197ck1640 FIND v(dout0_197) AT=825.025n

.meas tran vdout0_198ck1640 FIND v(dout0_198) AT=825.025n

.meas tran vdout0_199ck1640 FIND v(dout0_199) AT=825.025n

.meas tran vdout0_200ck1640 FIND v(dout0_200) AT=825.025n

.meas tran vdout0_201ck1640 FIND v(dout0_201) AT=825.025n

.meas tran vdout0_202ck1640 FIND v(dout0_202) AT=825.025n

.meas tran vdout0_203ck1640 FIND v(dout0_203) AT=825.025n

.meas tran vdout0_204ck1640 FIND v(dout0_204) AT=825.025n

.meas tran vdout0_205ck1640 FIND v(dout0_205) AT=825.025n

.meas tran vdout0_206ck1640 FIND v(dout0_206) AT=825.025n

.meas tran vdout0_207ck1640 FIND v(dout0_207) AT=825.025n

.meas tran vdout0_208ck1640 FIND v(dout0_208) AT=825.025n

.meas tran vdout0_209ck1640 FIND v(dout0_209) AT=825.025n

.meas tran vdout0_210ck1640 FIND v(dout0_210) AT=825.025n

.meas tran vdout0_211ck1640 FIND v(dout0_211) AT=825.025n

.meas tran vdout0_212ck1640 FIND v(dout0_212) AT=825.025n

.meas tran vdout0_213ck1640 FIND v(dout0_213) AT=825.025n

.meas tran vdout0_214ck1640 FIND v(dout0_214) AT=825.025n

.meas tran vdout0_215ck1640 FIND v(dout0_215) AT=825.025n

.meas tran vdout0_216ck1640 FIND v(dout0_216) AT=825.025n

.meas tran vdout0_217ck1640 FIND v(dout0_217) AT=825.025n

.meas tran vdout0_218ck1640 FIND v(dout0_218) AT=825.025n

.meas tran vdout0_219ck1640 FIND v(dout0_219) AT=825.025n

.meas tran vdout0_220ck1640 FIND v(dout0_220) AT=825.025n

.meas tran vdout0_221ck1640 FIND v(dout0_221) AT=825.025n

.meas tran vdout0_222ck1640 FIND v(dout0_222) AT=825.025n

.meas tran vdout0_223ck1640 FIND v(dout0_223) AT=825.025n

.meas tran vdout0_224ck1640 FIND v(dout0_224) AT=825.025n

.meas tran vdout0_225ck1640 FIND v(dout0_225) AT=825.025n

.meas tran vdout0_226ck1640 FIND v(dout0_226) AT=825.025n

.meas tran vdout0_227ck1640 FIND v(dout0_227) AT=825.025n

.meas tran vdout0_228ck1640 FIND v(dout0_228) AT=825.025n

.meas tran vdout0_229ck1640 FIND v(dout0_229) AT=825.025n

.meas tran vdout0_230ck1640 FIND v(dout0_230) AT=825.025n

.meas tran vdout0_231ck1640 FIND v(dout0_231) AT=825.025n

.meas tran vdout0_232ck1640 FIND v(dout0_232) AT=825.025n

.meas tran vdout0_233ck1640 FIND v(dout0_233) AT=825.025n

.meas tran vdout0_234ck1640 FIND v(dout0_234) AT=825.025n

.meas tran vdout0_235ck1640 FIND v(dout0_235) AT=825.025n

.meas tran vdout0_236ck1640 FIND v(dout0_236) AT=825.025n

.meas tran vdout0_237ck1640 FIND v(dout0_237) AT=825.025n

.meas tran vdout0_238ck1640 FIND v(dout0_238) AT=825.025n

.meas tran vdout0_239ck1640 FIND v(dout0_239) AT=825.025n

.meas tran vdout0_240ck1640 FIND v(dout0_240) AT=825.025n

.meas tran vdout0_241ck1640 FIND v(dout0_241) AT=825.025n

.meas tran vdout0_242ck1640 FIND v(dout0_242) AT=825.025n

.meas tran vdout0_243ck1640 FIND v(dout0_243) AT=825.025n

.meas tran vdout0_244ck1640 FIND v(dout0_244) AT=825.025n

.meas tran vdout0_245ck1640 FIND v(dout0_245) AT=825.025n

.meas tran vdout0_246ck1640 FIND v(dout0_246) AT=825.025n

.meas tran vdout0_247ck1640 FIND v(dout0_247) AT=825.025n

.meas tran vdout0_248ck1640 FIND v(dout0_248) AT=825.025n

.meas tran vdout0_249ck1640 FIND v(dout0_249) AT=825.025n

.meas tran vdout0_250ck1640 FIND v(dout0_250) AT=825.025n

.meas tran vdout0_251ck1640 FIND v(dout0_251) AT=825.025n

.meas tran vdout0_252ck1640 FIND v(dout0_252) AT=825.025n

.meas tran vdout0_253ck1640 FIND v(dout0_253) AT=825.025n

.meas tran vdout0_254ck1640 FIND v(dout0_254) AT=825.025n

.meas tran vdout0_255ck1640 FIND v(dout0_255) AT=825.025n

.meas tran vdout0_0ck1680 FIND v(dout0_0) AT=845.025n

.meas tran vdout0_1ck1680 FIND v(dout0_1) AT=845.025n

.meas tran vdout0_2ck1680 FIND v(dout0_2) AT=845.025n

.meas tran vdout0_3ck1680 FIND v(dout0_3) AT=845.025n

.meas tran vdout0_4ck1680 FIND v(dout0_4) AT=845.025n

.meas tran vdout0_5ck1680 FIND v(dout0_5) AT=845.025n

.meas tran vdout0_6ck1680 FIND v(dout0_6) AT=845.025n

.meas tran vdout0_7ck1680 FIND v(dout0_7) AT=845.025n

.meas tran vdout0_8ck1680 FIND v(dout0_8) AT=845.025n

.meas tran vdout0_9ck1680 FIND v(dout0_9) AT=845.025n

.meas tran vdout0_10ck1680 FIND v(dout0_10) AT=845.025n

.meas tran vdout0_11ck1680 FIND v(dout0_11) AT=845.025n

.meas tran vdout0_12ck1680 FIND v(dout0_12) AT=845.025n

.meas tran vdout0_13ck1680 FIND v(dout0_13) AT=845.025n

.meas tran vdout0_14ck1680 FIND v(dout0_14) AT=845.025n

.meas tran vdout0_15ck1680 FIND v(dout0_15) AT=845.025n

.meas tran vdout0_16ck1680 FIND v(dout0_16) AT=845.025n

.meas tran vdout0_17ck1680 FIND v(dout0_17) AT=845.025n

.meas tran vdout0_18ck1680 FIND v(dout0_18) AT=845.025n

.meas tran vdout0_19ck1680 FIND v(dout0_19) AT=845.025n

.meas tran vdout0_20ck1680 FIND v(dout0_20) AT=845.025n

.meas tran vdout0_21ck1680 FIND v(dout0_21) AT=845.025n

.meas tran vdout0_22ck1680 FIND v(dout0_22) AT=845.025n

.meas tran vdout0_23ck1680 FIND v(dout0_23) AT=845.025n

.meas tran vdout0_24ck1680 FIND v(dout0_24) AT=845.025n

.meas tran vdout0_25ck1680 FIND v(dout0_25) AT=845.025n

.meas tran vdout0_26ck1680 FIND v(dout0_26) AT=845.025n

.meas tran vdout0_27ck1680 FIND v(dout0_27) AT=845.025n

.meas tran vdout0_28ck1680 FIND v(dout0_28) AT=845.025n

.meas tran vdout0_29ck1680 FIND v(dout0_29) AT=845.025n

.meas tran vdout0_30ck1680 FIND v(dout0_30) AT=845.025n

.meas tran vdout0_31ck1680 FIND v(dout0_31) AT=845.025n

.meas tran vdout0_32ck1680 FIND v(dout0_32) AT=845.025n

.meas tran vdout0_33ck1680 FIND v(dout0_33) AT=845.025n

.meas tran vdout0_34ck1680 FIND v(dout0_34) AT=845.025n

.meas tran vdout0_35ck1680 FIND v(dout0_35) AT=845.025n

.meas tran vdout0_36ck1680 FIND v(dout0_36) AT=845.025n

.meas tran vdout0_37ck1680 FIND v(dout0_37) AT=845.025n

.meas tran vdout0_38ck1680 FIND v(dout0_38) AT=845.025n

.meas tran vdout0_39ck1680 FIND v(dout0_39) AT=845.025n

.meas tran vdout0_40ck1680 FIND v(dout0_40) AT=845.025n

.meas tran vdout0_41ck1680 FIND v(dout0_41) AT=845.025n

.meas tran vdout0_42ck1680 FIND v(dout0_42) AT=845.025n

.meas tran vdout0_43ck1680 FIND v(dout0_43) AT=845.025n

.meas tran vdout0_44ck1680 FIND v(dout0_44) AT=845.025n

.meas tran vdout0_45ck1680 FIND v(dout0_45) AT=845.025n

.meas tran vdout0_46ck1680 FIND v(dout0_46) AT=845.025n

.meas tran vdout0_47ck1680 FIND v(dout0_47) AT=845.025n

.meas tran vdout0_48ck1680 FIND v(dout0_48) AT=845.025n

.meas tran vdout0_49ck1680 FIND v(dout0_49) AT=845.025n

.meas tran vdout0_50ck1680 FIND v(dout0_50) AT=845.025n

.meas tran vdout0_51ck1680 FIND v(dout0_51) AT=845.025n

.meas tran vdout0_52ck1680 FIND v(dout0_52) AT=845.025n

.meas tran vdout0_53ck1680 FIND v(dout0_53) AT=845.025n

.meas tran vdout0_54ck1680 FIND v(dout0_54) AT=845.025n

.meas tran vdout0_55ck1680 FIND v(dout0_55) AT=845.025n

.meas tran vdout0_56ck1680 FIND v(dout0_56) AT=845.025n

.meas tran vdout0_57ck1680 FIND v(dout0_57) AT=845.025n

.meas tran vdout0_58ck1680 FIND v(dout0_58) AT=845.025n

.meas tran vdout0_59ck1680 FIND v(dout0_59) AT=845.025n

.meas tran vdout0_60ck1680 FIND v(dout0_60) AT=845.025n

.meas tran vdout0_61ck1680 FIND v(dout0_61) AT=845.025n

.meas tran vdout0_62ck1680 FIND v(dout0_62) AT=845.025n

.meas tran vdout0_63ck1680 FIND v(dout0_63) AT=845.025n

.meas tran vdout0_64ck1680 FIND v(dout0_64) AT=845.025n

.meas tran vdout0_65ck1680 FIND v(dout0_65) AT=845.025n

.meas tran vdout0_66ck1680 FIND v(dout0_66) AT=845.025n

.meas tran vdout0_67ck1680 FIND v(dout0_67) AT=845.025n

.meas tran vdout0_68ck1680 FIND v(dout0_68) AT=845.025n

.meas tran vdout0_69ck1680 FIND v(dout0_69) AT=845.025n

.meas tran vdout0_70ck1680 FIND v(dout0_70) AT=845.025n

.meas tran vdout0_71ck1680 FIND v(dout0_71) AT=845.025n

.meas tran vdout0_72ck1680 FIND v(dout0_72) AT=845.025n

.meas tran vdout0_73ck1680 FIND v(dout0_73) AT=845.025n

.meas tran vdout0_74ck1680 FIND v(dout0_74) AT=845.025n

.meas tran vdout0_75ck1680 FIND v(dout0_75) AT=845.025n

.meas tran vdout0_76ck1680 FIND v(dout0_76) AT=845.025n

.meas tran vdout0_77ck1680 FIND v(dout0_77) AT=845.025n

.meas tran vdout0_78ck1680 FIND v(dout0_78) AT=845.025n

.meas tran vdout0_79ck1680 FIND v(dout0_79) AT=845.025n

.meas tran vdout0_80ck1680 FIND v(dout0_80) AT=845.025n

.meas tran vdout0_81ck1680 FIND v(dout0_81) AT=845.025n

.meas tran vdout0_82ck1680 FIND v(dout0_82) AT=845.025n

.meas tran vdout0_83ck1680 FIND v(dout0_83) AT=845.025n

.meas tran vdout0_84ck1680 FIND v(dout0_84) AT=845.025n

.meas tran vdout0_85ck1680 FIND v(dout0_85) AT=845.025n

.meas tran vdout0_86ck1680 FIND v(dout0_86) AT=845.025n

.meas tran vdout0_87ck1680 FIND v(dout0_87) AT=845.025n

.meas tran vdout0_88ck1680 FIND v(dout0_88) AT=845.025n

.meas tran vdout0_89ck1680 FIND v(dout0_89) AT=845.025n

.meas tran vdout0_90ck1680 FIND v(dout0_90) AT=845.025n

.meas tran vdout0_91ck1680 FIND v(dout0_91) AT=845.025n

.meas tran vdout0_92ck1680 FIND v(dout0_92) AT=845.025n

.meas tran vdout0_93ck1680 FIND v(dout0_93) AT=845.025n

.meas tran vdout0_94ck1680 FIND v(dout0_94) AT=845.025n

.meas tran vdout0_95ck1680 FIND v(dout0_95) AT=845.025n

.meas tran vdout0_96ck1680 FIND v(dout0_96) AT=845.025n

.meas tran vdout0_97ck1680 FIND v(dout0_97) AT=845.025n

.meas tran vdout0_98ck1680 FIND v(dout0_98) AT=845.025n

.meas tran vdout0_99ck1680 FIND v(dout0_99) AT=845.025n

.meas tran vdout0_100ck1680 FIND v(dout0_100) AT=845.025n

.meas tran vdout0_101ck1680 FIND v(dout0_101) AT=845.025n

.meas tran vdout0_102ck1680 FIND v(dout0_102) AT=845.025n

.meas tran vdout0_103ck1680 FIND v(dout0_103) AT=845.025n

.meas tran vdout0_104ck1680 FIND v(dout0_104) AT=845.025n

.meas tran vdout0_105ck1680 FIND v(dout0_105) AT=845.025n

.meas tran vdout0_106ck1680 FIND v(dout0_106) AT=845.025n

.meas tran vdout0_107ck1680 FIND v(dout0_107) AT=845.025n

.meas tran vdout0_108ck1680 FIND v(dout0_108) AT=845.025n

.meas tran vdout0_109ck1680 FIND v(dout0_109) AT=845.025n

.meas tran vdout0_110ck1680 FIND v(dout0_110) AT=845.025n

.meas tran vdout0_111ck1680 FIND v(dout0_111) AT=845.025n

.meas tran vdout0_112ck1680 FIND v(dout0_112) AT=845.025n

.meas tran vdout0_113ck1680 FIND v(dout0_113) AT=845.025n

.meas tran vdout0_114ck1680 FIND v(dout0_114) AT=845.025n

.meas tran vdout0_115ck1680 FIND v(dout0_115) AT=845.025n

.meas tran vdout0_116ck1680 FIND v(dout0_116) AT=845.025n

.meas tran vdout0_117ck1680 FIND v(dout0_117) AT=845.025n

.meas tran vdout0_118ck1680 FIND v(dout0_118) AT=845.025n

.meas tran vdout0_119ck1680 FIND v(dout0_119) AT=845.025n

.meas tran vdout0_120ck1680 FIND v(dout0_120) AT=845.025n

.meas tran vdout0_121ck1680 FIND v(dout0_121) AT=845.025n

.meas tran vdout0_122ck1680 FIND v(dout0_122) AT=845.025n

.meas tran vdout0_123ck1680 FIND v(dout0_123) AT=845.025n

.meas tran vdout0_124ck1680 FIND v(dout0_124) AT=845.025n

.meas tran vdout0_125ck1680 FIND v(dout0_125) AT=845.025n

.meas tran vdout0_126ck1680 FIND v(dout0_126) AT=845.025n

.meas tran vdout0_127ck1680 FIND v(dout0_127) AT=845.025n

.meas tran vdout0_128ck1680 FIND v(dout0_128) AT=845.025n

.meas tran vdout0_129ck1680 FIND v(dout0_129) AT=845.025n

.meas tran vdout0_130ck1680 FIND v(dout0_130) AT=845.025n

.meas tran vdout0_131ck1680 FIND v(dout0_131) AT=845.025n

.meas tran vdout0_132ck1680 FIND v(dout0_132) AT=845.025n

.meas tran vdout0_133ck1680 FIND v(dout0_133) AT=845.025n

.meas tran vdout0_134ck1680 FIND v(dout0_134) AT=845.025n

.meas tran vdout0_135ck1680 FIND v(dout0_135) AT=845.025n

.meas tran vdout0_136ck1680 FIND v(dout0_136) AT=845.025n

.meas tran vdout0_137ck1680 FIND v(dout0_137) AT=845.025n

.meas tran vdout0_138ck1680 FIND v(dout0_138) AT=845.025n

.meas tran vdout0_139ck1680 FIND v(dout0_139) AT=845.025n

.meas tran vdout0_140ck1680 FIND v(dout0_140) AT=845.025n

.meas tran vdout0_141ck1680 FIND v(dout0_141) AT=845.025n

.meas tran vdout0_142ck1680 FIND v(dout0_142) AT=845.025n

.meas tran vdout0_143ck1680 FIND v(dout0_143) AT=845.025n

.meas tran vdout0_144ck1680 FIND v(dout0_144) AT=845.025n

.meas tran vdout0_145ck1680 FIND v(dout0_145) AT=845.025n

.meas tran vdout0_146ck1680 FIND v(dout0_146) AT=845.025n

.meas tran vdout0_147ck1680 FIND v(dout0_147) AT=845.025n

.meas tran vdout0_148ck1680 FIND v(dout0_148) AT=845.025n

.meas tran vdout0_149ck1680 FIND v(dout0_149) AT=845.025n

.meas tran vdout0_150ck1680 FIND v(dout0_150) AT=845.025n

.meas tran vdout0_151ck1680 FIND v(dout0_151) AT=845.025n

.meas tran vdout0_152ck1680 FIND v(dout0_152) AT=845.025n

.meas tran vdout0_153ck1680 FIND v(dout0_153) AT=845.025n

.meas tran vdout0_154ck1680 FIND v(dout0_154) AT=845.025n

.meas tran vdout0_155ck1680 FIND v(dout0_155) AT=845.025n

.meas tran vdout0_156ck1680 FIND v(dout0_156) AT=845.025n

.meas tran vdout0_157ck1680 FIND v(dout0_157) AT=845.025n

.meas tran vdout0_158ck1680 FIND v(dout0_158) AT=845.025n

.meas tran vdout0_159ck1680 FIND v(dout0_159) AT=845.025n

.meas tran vdout0_160ck1680 FIND v(dout0_160) AT=845.025n

.meas tran vdout0_161ck1680 FIND v(dout0_161) AT=845.025n

.meas tran vdout0_162ck1680 FIND v(dout0_162) AT=845.025n

.meas tran vdout0_163ck1680 FIND v(dout0_163) AT=845.025n

.meas tran vdout0_164ck1680 FIND v(dout0_164) AT=845.025n

.meas tran vdout0_165ck1680 FIND v(dout0_165) AT=845.025n

.meas tran vdout0_166ck1680 FIND v(dout0_166) AT=845.025n

.meas tran vdout0_167ck1680 FIND v(dout0_167) AT=845.025n

.meas tran vdout0_168ck1680 FIND v(dout0_168) AT=845.025n

.meas tran vdout0_169ck1680 FIND v(dout0_169) AT=845.025n

.meas tran vdout0_170ck1680 FIND v(dout0_170) AT=845.025n

.meas tran vdout0_171ck1680 FIND v(dout0_171) AT=845.025n

.meas tran vdout0_172ck1680 FIND v(dout0_172) AT=845.025n

.meas tran vdout0_173ck1680 FIND v(dout0_173) AT=845.025n

.meas tran vdout0_174ck1680 FIND v(dout0_174) AT=845.025n

.meas tran vdout0_175ck1680 FIND v(dout0_175) AT=845.025n

.meas tran vdout0_176ck1680 FIND v(dout0_176) AT=845.025n

.meas tran vdout0_177ck1680 FIND v(dout0_177) AT=845.025n

.meas tran vdout0_178ck1680 FIND v(dout0_178) AT=845.025n

.meas tran vdout0_179ck1680 FIND v(dout0_179) AT=845.025n

.meas tran vdout0_180ck1680 FIND v(dout0_180) AT=845.025n

.meas tran vdout0_181ck1680 FIND v(dout0_181) AT=845.025n

.meas tran vdout0_182ck1680 FIND v(dout0_182) AT=845.025n

.meas tran vdout0_183ck1680 FIND v(dout0_183) AT=845.025n

.meas tran vdout0_184ck1680 FIND v(dout0_184) AT=845.025n

.meas tran vdout0_185ck1680 FIND v(dout0_185) AT=845.025n

.meas tran vdout0_186ck1680 FIND v(dout0_186) AT=845.025n

.meas tran vdout0_187ck1680 FIND v(dout0_187) AT=845.025n

.meas tran vdout0_188ck1680 FIND v(dout0_188) AT=845.025n

.meas tran vdout0_189ck1680 FIND v(dout0_189) AT=845.025n

.meas tran vdout0_190ck1680 FIND v(dout0_190) AT=845.025n

.meas tran vdout0_191ck1680 FIND v(dout0_191) AT=845.025n

.meas tran vdout0_192ck1680 FIND v(dout0_192) AT=845.025n

.meas tran vdout0_193ck1680 FIND v(dout0_193) AT=845.025n

.meas tran vdout0_194ck1680 FIND v(dout0_194) AT=845.025n

.meas tran vdout0_195ck1680 FIND v(dout0_195) AT=845.025n

.meas tran vdout0_196ck1680 FIND v(dout0_196) AT=845.025n

.meas tran vdout0_197ck1680 FIND v(dout0_197) AT=845.025n

.meas tran vdout0_198ck1680 FIND v(dout0_198) AT=845.025n

.meas tran vdout0_199ck1680 FIND v(dout0_199) AT=845.025n

.meas tran vdout0_200ck1680 FIND v(dout0_200) AT=845.025n

.meas tran vdout0_201ck1680 FIND v(dout0_201) AT=845.025n

.meas tran vdout0_202ck1680 FIND v(dout0_202) AT=845.025n

.meas tran vdout0_203ck1680 FIND v(dout0_203) AT=845.025n

.meas tran vdout0_204ck1680 FIND v(dout0_204) AT=845.025n

.meas tran vdout0_205ck1680 FIND v(dout0_205) AT=845.025n

.meas tran vdout0_206ck1680 FIND v(dout0_206) AT=845.025n

.meas tran vdout0_207ck1680 FIND v(dout0_207) AT=845.025n

.meas tran vdout0_208ck1680 FIND v(dout0_208) AT=845.025n

.meas tran vdout0_209ck1680 FIND v(dout0_209) AT=845.025n

.meas tran vdout0_210ck1680 FIND v(dout0_210) AT=845.025n

.meas tran vdout0_211ck1680 FIND v(dout0_211) AT=845.025n

.meas tran vdout0_212ck1680 FIND v(dout0_212) AT=845.025n

.meas tran vdout0_213ck1680 FIND v(dout0_213) AT=845.025n

.meas tran vdout0_214ck1680 FIND v(dout0_214) AT=845.025n

.meas tran vdout0_215ck1680 FIND v(dout0_215) AT=845.025n

.meas tran vdout0_216ck1680 FIND v(dout0_216) AT=845.025n

.meas tran vdout0_217ck1680 FIND v(dout0_217) AT=845.025n

.meas tran vdout0_218ck1680 FIND v(dout0_218) AT=845.025n

.meas tran vdout0_219ck1680 FIND v(dout0_219) AT=845.025n

.meas tran vdout0_220ck1680 FIND v(dout0_220) AT=845.025n

.meas tran vdout0_221ck1680 FIND v(dout0_221) AT=845.025n

.meas tran vdout0_222ck1680 FIND v(dout0_222) AT=845.025n

.meas tran vdout0_223ck1680 FIND v(dout0_223) AT=845.025n

.meas tran vdout0_224ck1680 FIND v(dout0_224) AT=845.025n

.meas tran vdout0_225ck1680 FIND v(dout0_225) AT=845.025n

.meas tran vdout0_226ck1680 FIND v(dout0_226) AT=845.025n

.meas tran vdout0_227ck1680 FIND v(dout0_227) AT=845.025n

.meas tran vdout0_228ck1680 FIND v(dout0_228) AT=845.025n

.meas tran vdout0_229ck1680 FIND v(dout0_229) AT=845.025n

.meas tran vdout0_230ck1680 FIND v(dout0_230) AT=845.025n

.meas tran vdout0_231ck1680 FIND v(dout0_231) AT=845.025n

.meas tran vdout0_232ck1680 FIND v(dout0_232) AT=845.025n

.meas tran vdout0_233ck1680 FIND v(dout0_233) AT=845.025n

.meas tran vdout0_234ck1680 FIND v(dout0_234) AT=845.025n

.meas tran vdout0_235ck1680 FIND v(dout0_235) AT=845.025n

.meas tran vdout0_236ck1680 FIND v(dout0_236) AT=845.025n

.meas tran vdout0_237ck1680 FIND v(dout0_237) AT=845.025n

.meas tran vdout0_238ck1680 FIND v(dout0_238) AT=845.025n

.meas tran vdout0_239ck1680 FIND v(dout0_239) AT=845.025n

.meas tran vdout0_240ck1680 FIND v(dout0_240) AT=845.025n

.meas tran vdout0_241ck1680 FIND v(dout0_241) AT=845.025n

.meas tran vdout0_242ck1680 FIND v(dout0_242) AT=845.025n

.meas tran vdout0_243ck1680 FIND v(dout0_243) AT=845.025n

.meas tran vdout0_244ck1680 FIND v(dout0_244) AT=845.025n

.meas tran vdout0_245ck1680 FIND v(dout0_245) AT=845.025n

.meas tran vdout0_246ck1680 FIND v(dout0_246) AT=845.025n

.meas tran vdout0_247ck1680 FIND v(dout0_247) AT=845.025n

.meas tran vdout0_248ck1680 FIND v(dout0_248) AT=845.025n

.meas tran vdout0_249ck1680 FIND v(dout0_249) AT=845.025n

.meas tran vdout0_250ck1680 FIND v(dout0_250) AT=845.025n

.meas tran vdout0_251ck1680 FIND v(dout0_251) AT=845.025n

.meas tran vdout0_252ck1680 FIND v(dout0_252) AT=845.025n

.meas tran vdout0_253ck1680 FIND v(dout0_253) AT=845.025n

.meas tran vdout0_254ck1680 FIND v(dout0_254) AT=845.025n

.meas tran vdout0_255ck1680 FIND v(dout0_255) AT=845.025n

.meas tran vdout0_0ck1690 FIND v(dout0_0) AT=850.025n

.meas tran vdout0_1ck1690 FIND v(dout0_1) AT=850.025n

.meas tran vdout0_2ck1690 FIND v(dout0_2) AT=850.025n

.meas tran vdout0_3ck1690 FIND v(dout0_3) AT=850.025n

.meas tran vdout0_4ck1690 FIND v(dout0_4) AT=850.025n

.meas tran vdout0_5ck1690 FIND v(dout0_5) AT=850.025n

.meas tran vdout0_6ck1690 FIND v(dout0_6) AT=850.025n

.meas tran vdout0_7ck1690 FIND v(dout0_7) AT=850.025n

.meas tran vdout0_8ck1690 FIND v(dout0_8) AT=850.025n

.meas tran vdout0_9ck1690 FIND v(dout0_9) AT=850.025n

.meas tran vdout0_10ck1690 FIND v(dout0_10) AT=850.025n

.meas tran vdout0_11ck1690 FIND v(dout0_11) AT=850.025n

.meas tran vdout0_12ck1690 FIND v(dout0_12) AT=850.025n

.meas tran vdout0_13ck1690 FIND v(dout0_13) AT=850.025n

.meas tran vdout0_14ck1690 FIND v(dout0_14) AT=850.025n

.meas tran vdout0_15ck1690 FIND v(dout0_15) AT=850.025n

.meas tran vdout0_16ck1690 FIND v(dout0_16) AT=850.025n

.meas tran vdout0_17ck1690 FIND v(dout0_17) AT=850.025n

.meas tran vdout0_18ck1690 FIND v(dout0_18) AT=850.025n

.meas tran vdout0_19ck1690 FIND v(dout0_19) AT=850.025n

.meas tran vdout0_20ck1690 FIND v(dout0_20) AT=850.025n

.meas tran vdout0_21ck1690 FIND v(dout0_21) AT=850.025n

.meas tran vdout0_22ck1690 FIND v(dout0_22) AT=850.025n

.meas tran vdout0_23ck1690 FIND v(dout0_23) AT=850.025n

.meas tran vdout0_24ck1690 FIND v(dout0_24) AT=850.025n

.meas tran vdout0_25ck1690 FIND v(dout0_25) AT=850.025n

.meas tran vdout0_26ck1690 FIND v(dout0_26) AT=850.025n

.meas tran vdout0_27ck1690 FIND v(dout0_27) AT=850.025n

.meas tran vdout0_28ck1690 FIND v(dout0_28) AT=850.025n

.meas tran vdout0_29ck1690 FIND v(dout0_29) AT=850.025n

.meas tran vdout0_30ck1690 FIND v(dout0_30) AT=850.025n

.meas tran vdout0_31ck1690 FIND v(dout0_31) AT=850.025n

.meas tran vdout0_32ck1690 FIND v(dout0_32) AT=850.025n

.meas tran vdout0_33ck1690 FIND v(dout0_33) AT=850.025n

.meas tran vdout0_34ck1690 FIND v(dout0_34) AT=850.025n

.meas tran vdout0_35ck1690 FIND v(dout0_35) AT=850.025n

.meas tran vdout0_36ck1690 FIND v(dout0_36) AT=850.025n

.meas tran vdout0_37ck1690 FIND v(dout0_37) AT=850.025n

.meas tran vdout0_38ck1690 FIND v(dout0_38) AT=850.025n

.meas tran vdout0_39ck1690 FIND v(dout0_39) AT=850.025n

.meas tran vdout0_40ck1690 FIND v(dout0_40) AT=850.025n

.meas tran vdout0_41ck1690 FIND v(dout0_41) AT=850.025n

.meas tran vdout0_42ck1690 FIND v(dout0_42) AT=850.025n

.meas tran vdout0_43ck1690 FIND v(dout0_43) AT=850.025n

.meas tran vdout0_44ck1690 FIND v(dout0_44) AT=850.025n

.meas tran vdout0_45ck1690 FIND v(dout0_45) AT=850.025n

.meas tran vdout0_46ck1690 FIND v(dout0_46) AT=850.025n

.meas tran vdout0_47ck1690 FIND v(dout0_47) AT=850.025n

.meas tran vdout0_48ck1690 FIND v(dout0_48) AT=850.025n

.meas tran vdout0_49ck1690 FIND v(dout0_49) AT=850.025n

.meas tran vdout0_50ck1690 FIND v(dout0_50) AT=850.025n

.meas tran vdout0_51ck1690 FIND v(dout0_51) AT=850.025n

.meas tran vdout0_52ck1690 FIND v(dout0_52) AT=850.025n

.meas tran vdout0_53ck1690 FIND v(dout0_53) AT=850.025n

.meas tran vdout0_54ck1690 FIND v(dout0_54) AT=850.025n

.meas tran vdout0_55ck1690 FIND v(dout0_55) AT=850.025n

.meas tran vdout0_56ck1690 FIND v(dout0_56) AT=850.025n

.meas tran vdout0_57ck1690 FIND v(dout0_57) AT=850.025n

.meas tran vdout0_58ck1690 FIND v(dout0_58) AT=850.025n

.meas tran vdout0_59ck1690 FIND v(dout0_59) AT=850.025n

.meas tran vdout0_60ck1690 FIND v(dout0_60) AT=850.025n

.meas tran vdout0_61ck1690 FIND v(dout0_61) AT=850.025n

.meas tran vdout0_62ck1690 FIND v(dout0_62) AT=850.025n

.meas tran vdout0_63ck1690 FIND v(dout0_63) AT=850.025n

.meas tran vdout0_64ck1690 FIND v(dout0_64) AT=850.025n

.meas tran vdout0_65ck1690 FIND v(dout0_65) AT=850.025n

.meas tran vdout0_66ck1690 FIND v(dout0_66) AT=850.025n

.meas tran vdout0_67ck1690 FIND v(dout0_67) AT=850.025n

.meas tran vdout0_68ck1690 FIND v(dout0_68) AT=850.025n

.meas tran vdout0_69ck1690 FIND v(dout0_69) AT=850.025n

.meas tran vdout0_70ck1690 FIND v(dout0_70) AT=850.025n

.meas tran vdout0_71ck1690 FIND v(dout0_71) AT=850.025n

.meas tran vdout0_72ck1690 FIND v(dout0_72) AT=850.025n

.meas tran vdout0_73ck1690 FIND v(dout0_73) AT=850.025n

.meas tran vdout0_74ck1690 FIND v(dout0_74) AT=850.025n

.meas tran vdout0_75ck1690 FIND v(dout0_75) AT=850.025n

.meas tran vdout0_76ck1690 FIND v(dout0_76) AT=850.025n

.meas tran vdout0_77ck1690 FIND v(dout0_77) AT=850.025n

.meas tran vdout0_78ck1690 FIND v(dout0_78) AT=850.025n

.meas tran vdout0_79ck1690 FIND v(dout0_79) AT=850.025n

.meas tran vdout0_80ck1690 FIND v(dout0_80) AT=850.025n

.meas tran vdout0_81ck1690 FIND v(dout0_81) AT=850.025n

.meas tran vdout0_82ck1690 FIND v(dout0_82) AT=850.025n

.meas tran vdout0_83ck1690 FIND v(dout0_83) AT=850.025n

.meas tran vdout0_84ck1690 FIND v(dout0_84) AT=850.025n

.meas tran vdout0_85ck1690 FIND v(dout0_85) AT=850.025n

.meas tran vdout0_86ck1690 FIND v(dout0_86) AT=850.025n

.meas tran vdout0_87ck1690 FIND v(dout0_87) AT=850.025n

.meas tran vdout0_88ck1690 FIND v(dout0_88) AT=850.025n

.meas tran vdout0_89ck1690 FIND v(dout0_89) AT=850.025n

.meas tran vdout0_90ck1690 FIND v(dout0_90) AT=850.025n

.meas tran vdout0_91ck1690 FIND v(dout0_91) AT=850.025n

.meas tran vdout0_92ck1690 FIND v(dout0_92) AT=850.025n

.meas tran vdout0_93ck1690 FIND v(dout0_93) AT=850.025n

.meas tran vdout0_94ck1690 FIND v(dout0_94) AT=850.025n

.meas tran vdout0_95ck1690 FIND v(dout0_95) AT=850.025n

.meas tran vdout0_96ck1690 FIND v(dout0_96) AT=850.025n

.meas tran vdout0_97ck1690 FIND v(dout0_97) AT=850.025n

.meas tran vdout0_98ck1690 FIND v(dout0_98) AT=850.025n

.meas tran vdout0_99ck1690 FIND v(dout0_99) AT=850.025n

.meas tran vdout0_100ck1690 FIND v(dout0_100) AT=850.025n

.meas tran vdout0_101ck1690 FIND v(dout0_101) AT=850.025n

.meas tran vdout0_102ck1690 FIND v(dout0_102) AT=850.025n

.meas tran vdout0_103ck1690 FIND v(dout0_103) AT=850.025n

.meas tran vdout0_104ck1690 FIND v(dout0_104) AT=850.025n

.meas tran vdout0_105ck1690 FIND v(dout0_105) AT=850.025n

.meas tran vdout0_106ck1690 FIND v(dout0_106) AT=850.025n

.meas tran vdout0_107ck1690 FIND v(dout0_107) AT=850.025n

.meas tran vdout0_108ck1690 FIND v(dout0_108) AT=850.025n

.meas tran vdout0_109ck1690 FIND v(dout0_109) AT=850.025n

.meas tran vdout0_110ck1690 FIND v(dout0_110) AT=850.025n

.meas tran vdout0_111ck1690 FIND v(dout0_111) AT=850.025n

.meas tran vdout0_112ck1690 FIND v(dout0_112) AT=850.025n

.meas tran vdout0_113ck1690 FIND v(dout0_113) AT=850.025n

.meas tran vdout0_114ck1690 FIND v(dout0_114) AT=850.025n

.meas tran vdout0_115ck1690 FIND v(dout0_115) AT=850.025n

.meas tran vdout0_116ck1690 FIND v(dout0_116) AT=850.025n

.meas tran vdout0_117ck1690 FIND v(dout0_117) AT=850.025n

.meas tran vdout0_118ck1690 FIND v(dout0_118) AT=850.025n

.meas tran vdout0_119ck1690 FIND v(dout0_119) AT=850.025n

.meas tran vdout0_120ck1690 FIND v(dout0_120) AT=850.025n

.meas tran vdout0_121ck1690 FIND v(dout0_121) AT=850.025n

.meas tran vdout0_122ck1690 FIND v(dout0_122) AT=850.025n

.meas tran vdout0_123ck1690 FIND v(dout0_123) AT=850.025n

.meas tran vdout0_124ck1690 FIND v(dout0_124) AT=850.025n

.meas tran vdout0_125ck1690 FIND v(dout0_125) AT=850.025n

.meas tran vdout0_126ck1690 FIND v(dout0_126) AT=850.025n

.meas tran vdout0_127ck1690 FIND v(dout0_127) AT=850.025n

.meas tran vdout0_128ck1690 FIND v(dout0_128) AT=850.025n

.meas tran vdout0_129ck1690 FIND v(dout0_129) AT=850.025n

.meas tran vdout0_130ck1690 FIND v(dout0_130) AT=850.025n

.meas tran vdout0_131ck1690 FIND v(dout0_131) AT=850.025n

.meas tran vdout0_132ck1690 FIND v(dout0_132) AT=850.025n

.meas tran vdout0_133ck1690 FIND v(dout0_133) AT=850.025n

.meas tran vdout0_134ck1690 FIND v(dout0_134) AT=850.025n

.meas tran vdout0_135ck1690 FIND v(dout0_135) AT=850.025n

.meas tran vdout0_136ck1690 FIND v(dout0_136) AT=850.025n

.meas tran vdout0_137ck1690 FIND v(dout0_137) AT=850.025n

.meas tran vdout0_138ck1690 FIND v(dout0_138) AT=850.025n

.meas tran vdout0_139ck1690 FIND v(dout0_139) AT=850.025n

.meas tran vdout0_140ck1690 FIND v(dout0_140) AT=850.025n

.meas tran vdout0_141ck1690 FIND v(dout0_141) AT=850.025n

.meas tran vdout0_142ck1690 FIND v(dout0_142) AT=850.025n

.meas tran vdout0_143ck1690 FIND v(dout0_143) AT=850.025n

.meas tran vdout0_144ck1690 FIND v(dout0_144) AT=850.025n

.meas tran vdout0_145ck1690 FIND v(dout0_145) AT=850.025n

.meas tran vdout0_146ck1690 FIND v(dout0_146) AT=850.025n

.meas tran vdout0_147ck1690 FIND v(dout0_147) AT=850.025n

.meas tran vdout0_148ck1690 FIND v(dout0_148) AT=850.025n

.meas tran vdout0_149ck1690 FIND v(dout0_149) AT=850.025n

.meas tran vdout0_150ck1690 FIND v(dout0_150) AT=850.025n

.meas tran vdout0_151ck1690 FIND v(dout0_151) AT=850.025n

.meas tran vdout0_152ck1690 FIND v(dout0_152) AT=850.025n

.meas tran vdout0_153ck1690 FIND v(dout0_153) AT=850.025n

.meas tran vdout0_154ck1690 FIND v(dout0_154) AT=850.025n

.meas tran vdout0_155ck1690 FIND v(dout0_155) AT=850.025n

.meas tran vdout0_156ck1690 FIND v(dout0_156) AT=850.025n

.meas tran vdout0_157ck1690 FIND v(dout0_157) AT=850.025n

.meas tran vdout0_158ck1690 FIND v(dout0_158) AT=850.025n

.meas tran vdout0_159ck1690 FIND v(dout0_159) AT=850.025n

.meas tran vdout0_160ck1690 FIND v(dout0_160) AT=850.025n

.meas tran vdout0_161ck1690 FIND v(dout0_161) AT=850.025n

.meas tran vdout0_162ck1690 FIND v(dout0_162) AT=850.025n

.meas tran vdout0_163ck1690 FIND v(dout0_163) AT=850.025n

.meas tran vdout0_164ck1690 FIND v(dout0_164) AT=850.025n

.meas tran vdout0_165ck1690 FIND v(dout0_165) AT=850.025n

.meas tran vdout0_166ck1690 FIND v(dout0_166) AT=850.025n

.meas tran vdout0_167ck1690 FIND v(dout0_167) AT=850.025n

.meas tran vdout0_168ck1690 FIND v(dout0_168) AT=850.025n

.meas tran vdout0_169ck1690 FIND v(dout0_169) AT=850.025n

.meas tran vdout0_170ck1690 FIND v(dout0_170) AT=850.025n

.meas tran vdout0_171ck1690 FIND v(dout0_171) AT=850.025n

.meas tran vdout0_172ck1690 FIND v(dout0_172) AT=850.025n

.meas tran vdout0_173ck1690 FIND v(dout0_173) AT=850.025n

.meas tran vdout0_174ck1690 FIND v(dout0_174) AT=850.025n

.meas tran vdout0_175ck1690 FIND v(dout0_175) AT=850.025n

.meas tran vdout0_176ck1690 FIND v(dout0_176) AT=850.025n

.meas tran vdout0_177ck1690 FIND v(dout0_177) AT=850.025n

.meas tran vdout0_178ck1690 FIND v(dout0_178) AT=850.025n

.meas tran vdout0_179ck1690 FIND v(dout0_179) AT=850.025n

.meas tran vdout0_180ck1690 FIND v(dout0_180) AT=850.025n

.meas tran vdout0_181ck1690 FIND v(dout0_181) AT=850.025n

.meas tran vdout0_182ck1690 FIND v(dout0_182) AT=850.025n

.meas tran vdout0_183ck1690 FIND v(dout0_183) AT=850.025n

.meas tran vdout0_184ck1690 FIND v(dout0_184) AT=850.025n

.meas tran vdout0_185ck1690 FIND v(dout0_185) AT=850.025n

.meas tran vdout0_186ck1690 FIND v(dout0_186) AT=850.025n

.meas tran vdout0_187ck1690 FIND v(dout0_187) AT=850.025n

.meas tran vdout0_188ck1690 FIND v(dout0_188) AT=850.025n

.meas tran vdout0_189ck1690 FIND v(dout0_189) AT=850.025n

.meas tran vdout0_190ck1690 FIND v(dout0_190) AT=850.025n

.meas tran vdout0_191ck1690 FIND v(dout0_191) AT=850.025n

.meas tran vdout0_192ck1690 FIND v(dout0_192) AT=850.025n

.meas tran vdout0_193ck1690 FIND v(dout0_193) AT=850.025n

.meas tran vdout0_194ck1690 FIND v(dout0_194) AT=850.025n

.meas tran vdout0_195ck1690 FIND v(dout0_195) AT=850.025n

.meas tran vdout0_196ck1690 FIND v(dout0_196) AT=850.025n

.meas tran vdout0_197ck1690 FIND v(dout0_197) AT=850.025n

.meas tran vdout0_198ck1690 FIND v(dout0_198) AT=850.025n

.meas tran vdout0_199ck1690 FIND v(dout0_199) AT=850.025n

.meas tran vdout0_200ck1690 FIND v(dout0_200) AT=850.025n

.meas tran vdout0_201ck1690 FIND v(dout0_201) AT=850.025n

.meas tran vdout0_202ck1690 FIND v(dout0_202) AT=850.025n

.meas tran vdout0_203ck1690 FIND v(dout0_203) AT=850.025n

.meas tran vdout0_204ck1690 FIND v(dout0_204) AT=850.025n

.meas tran vdout0_205ck1690 FIND v(dout0_205) AT=850.025n

.meas tran vdout0_206ck1690 FIND v(dout0_206) AT=850.025n

.meas tran vdout0_207ck1690 FIND v(dout0_207) AT=850.025n

.meas tran vdout0_208ck1690 FIND v(dout0_208) AT=850.025n

.meas tran vdout0_209ck1690 FIND v(dout0_209) AT=850.025n

.meas tran vdout0_210ck1690 FIND v(dout0_210) AT=850.025n

.meas tran vdout0_211ck1690 FIND v(dout0_211) AT=850.025n

.meas tran vdout0_212ck1690 FIND v(dout0_212) AT=850.025n

.meas tran vdout0_213ck1690 FIND v(dout0_213) AT=850.025n

.meas tran vdout0_214ck1690 FIND v(dout0_214) AT=850.025n

.meas tran vdout0_215ck1690 FIND v(dout0_215) AT=850.025n

.meas tran vdout0_216ck1690 FIND v(dout0_216) AT=850.025n

.meas tran vdout0_217ck1690 FIND v(dout0_217) AT=850.025n

.meas tran vdout0_218ck1690 FIND v(dout0_218) AT=850.025n

.meas tran vdout0_219ck1690 FIND v(dout0_219) AT=850.025n

.meas tran vdout0_220ck1690 FIND v(dout0_220) AT=850.025n

.meas tran vdout0_221ck1690 FIND v(dout0_221) AT=850.025n

.meas tran vdout0_222ck1690 FIND v(dout0_222) AT=850.025n

.meas tran vdout0_223ck1690 FIND v(dout0_223) AT=850.025n

.meas tran vdout0_224ck1690 FIND v(dout0_224) AT=850.025n

.meas tran vdout0_225ck1690 FIND v(dout0_225) AT=850.025n

.meas tran vdout0_226ck1690 FIND v(dout0_226) AT=850.025n

.meas tran vdout0_227ck1690 FIND v(dout0_227) AT=850.025n

.meas tran vdout0_228ck1690 FIND v(dout0_228) AT=850.025n

.meas tran vdout0_229ck1690 FIND v(dout0_229) AT=850.025n

.meas tran vdout0_230ck1690 FIND v(dout0_230) AT=850.025n

.meas tran vdout0_231ck1690 FIND v(dout0_231) AT=850.025n

.meas tran vdout0_232ck1690 FIND v(dout0_232) AT=850.025n

.meas tran vdout0_233ck1690 FIND v(dout0_233) AT=850.025n

.meas tran vdout0_234ck1690 FIND v(dout0_234) AT=850.025n

.meas tran vdout0_235ck1690 FIND v(dout0_235) AT=850.025n

.meas tran vdout0_236ck1690 FIND v(dout0_236) AT=850.025n

.meas tran vdout0_237ck1690 FIND v(dout0_237) AT=850.025n

.meas tran vdout0_238ck1690 FIND v(dout0_238) AT=850.025n

.meas tran vdout0_239ck1690 FIND v(dout0_239) AT=850.025n

.meas tran vdout0_240ck1690 FIND v(dout0_240) AT=850.025n

.meas tran vdout0_241ck1690 FIND v(dout0_241) AT=850.025n

.meas tran vdout0_242ck1690 FIND v(dout0_242) AT=850.025n

.meas tran vdout0_243ck1690 FIND v(dout0_243) AT=850.025n

.meas tran vdout0_244ck1690 FIND v(dout0_244) AT=850.025n

.meas tran vdout0_245ck1690 FIND v(dout0_245) AT=850.025n

.meas tran vdout0_246ck1690 FIND v(dout0_246) AT=850.025n

.meas tran vdout0_247ck1690 FIND v(dout0_247) AT=850.025n

.meas tran vdout0_248ck1690 FIND v(dout0_248) AT=850.025n

.meas tran vdout0_249ck1690 FIND v(dout0_249) AT=850.025n

.meas tran vdout0_250ck1690 FIND v(dout0_250) AT=850.025n

.meas tran vdout0_251ck1690 FIND v(dout0_251) AT=850.025n

.meas tran vdout0_252ck1690 FIND v(dout0_252) AT=850.025n

.meas tran vdout0_253ck1690 FIND v(dout0_253) AT=850.025n

.meas tran vdout0_254ck1690 FIND v(dout0_254) AT=850.025n

.meas tran vdout0_255ck1690 FIND v(dout0_255) AT=850.025n

.meas tran vdout0_0ck1740 FIND v(dout0_0) AT=875.025n

.meas tran vdout0_1ck1740 FIND v(dout0_1) AT=875.025n

.meas tran vdout0_2ck1740 FIND v(dout0_2) AT=875.025n

.meas tran vdout0_3ck1740 FIND v(dout0_3) AT=875.025n

.meas tran vdout0_4ck1740 FIND v(dout0_4) AT=875.025n

.meas tran vdout0_5ck1740 FIND v(dout0_5) AT=875.025n

.meas tran vdout0_6ck1740 FIND v(dout0_6) AT=875.025n

.meas tran vdout0_7ck1740 FIND v(dout0_7) AT=875.025n

.meas tran vdout0_8ck1740 FIND v(dout0_8) AT=875.025n

.meas tran vdout0_9ck1740 FIND v(dout0_9) AT=875.025n

.meas tran vdout0_10ck1740 FIND v(dout0_10) AT=875.025n

.meas tran vdout0_11ck1740 FIND v(dout0_11) AT=875.025n

.meas tran vdout0_12ck1740 FIND v(dout0_12) AT=875.025n

.meas tran vdout0_13ck1740 FIND v(dout0_13) AT=875.025n

.meas tran vdout0_14ck1740 FIND v(dout0_14) AT=875.025n

.meas tran vdout0_15ck1740 FIND v(dout0_15) AT=875.025n

.meas tran vdout0_16ck1740 FIND v(dout0_16) AT=875.025n

.meas tran vdout0_17ck1740 FIND v(dout0_17) AT=875.025n

.meas tran vdout0_18ck1740 FIND v(dout0_18) AT=875.025n

.meas tran vdout0_19ck1740 FIND v(dout0_19) AT=875.025n

.meas tran vdout0_20ck1740 FIND v(dout0_20) AT=875.025n

.meas tran vdout0_21ck1740 FIND v(dout0_21) AT=875.025n

.meas tran vdout0_22ck1740 FIND v(dout0_22) AT=875.025n

.meas tran vdout0_23ck1740 FIND v(dout0_23) AT=875.025n

.meas tran vdout0_24ck1740 FIND v(dout0_24) AT=875.025n

.meas tran vdout0_25ck1740 FIND v(dout0_25) AT=875.025n

.meas tran vdout0_26ck1740 FIND v(dout0_26) AT=875.025n

.meas tran vdout0_27ck1740 FIND v(dout0_27) AT=875.025n

.meas tran vdout0_28ck1740 FIND v(dout0_28) AT=875.025n

.meas tran vdout0_29ck1740 FIND v(dout0_29) AT=875.025n

.meas tran vdout0_30ck1740 FIND v(dout0_30) AT=875.025n

.meas tran vdout0_31ck1740 FIND v(dout0_31) AT=875.025n

.meas tran vdout0_32ck1740 FIND v(dout0_32) AT=875.025n

.meas tran vdout0_33ck1740 FIND v(dout0_33) AT=875.025n

.meas tran vdout0_34ck1740 FIND v(dout0_34) AT=875.025n

.meas tran vdout0_35ck1740 FIND v(dout0_35) AT=875.025n

.meas tran vdout0_36ck1740 FIND v(dout0_36) AT=875.025n

.meas tran vdout0_37ck1740 FIND v(dout0_37) AT=875.025n

.meas tran vdout0_38ck1740 FIND v(dout0_38) AT=875.025n

.meas tran vdout0_39ck1740 FIND v(dout0_39) AT=875.025n

.meas tran vdout0_40ck1740 FIND v(dout0_40) AT=875.025n

.meas tran vdout0_41ck1740 FIND v(dout0_41) AT=875.025n

.meas tran vdout0_42ck1740 FIND v(dout0_42) AT=875.025n

.meas tran vdout0_43ck1740 FIND v(dout0_43) AT=875.025n

.meas tran vdout0_44ck1740 FIND v(dout0_44) AT=875.025n

.meas tran vdout0_45ck1740 FIND v(dout0_45) AT=875.025n

.meas tran vdout0_46ck1740 FIND v(dout0_46) AT=875.025n

.meas tran vdout0_47ck1740 FIND v(dout0_47) AT=875.025n

.meas tran vdout0_48ck1740 FIND v(dout0_48) AT=875.025n

.meas tran vdout0_49ck1740 FIND v(dout0_49) AT=875.025n

.meas tran vdout0_50ck1740 FIND v(dout0_50) AT=875.025n

.meas tran vdout0_51ck1740 FIND v(dout0_51) AT=875.025n

.meas tran vdout0_52ck1740 FIND v(dout0_52) AT=875.025n

.meas tran vdout0_53ck1740 FIND v(dout0_53) AT=875.025n

.meas tran vdout0_54ck1740 FIND v(dout0_54) AT=875.025n

.meas tran vdout0_55ck1740 FIND v(dout0_55) AT=875.025n

.meas tran vdout0_56ck1740 FIND v(dout0_56) AT=875.025n

.meas tran vdout0_57ck1740 FIND v(dout0_57) AT=875.025n

.meas tran vdout0_58ck1740 FIND v(dout0_58) AT=875.025n

.meas tran vdout0_59ck1740 FIND v(dout0_59) AT=875.025n

.meas tran vdout0_60ck1740 FIND v(dout0_60) AT=875.025n

.meas tran vdout0_61ck1740 FIND v(dout0_61) AT=875.025n

.meas tran vdout0_62ck1740 FIND v(dout0_62) AT=875.025n

.meas tran vdout0_63ck1740 FIND v(dout0_63) AT=875.025n

.meas tran vdout0_64ck1740 FIND v(dout0_64) AT=875.025n

.meas tran vdout0_65ck1740 FIND v(dout0_65) AT=875.025n

.meas tran vdout0_66ck1740 FIND v(dout0_66) AT=875.025n

.meas tran vdout0_67ck1740 FIND v(dout0_67) AT=875.025n

.meas tran vdout0_68ck1740 FIND v(dout0_68) AT=875.025n

.meas tran vdout0_69ck1740 FIND v(dout0_69) AT=875.025n

.meas tran vdout0_70ck1740 FIND v(dout0_70) AT=875.025n

.meas tran vdout0_71ck1740 FIND v(dout0_71) AT=875.025n

.meas tran vdout0_72ck1740 FIND v(dout0_72) AT=875.025n

.meas tran vdout0_73ck1740 FIND v(dout0_73) AT=875.025n

.meas tran vdout0_74ck1740 FIND v(dout0_74) AT=875.025n

.meas tran vdout0_75ck1740 FIND v(dout0_75) AT=875.025n

.meas tran vdout0_76ck1740 FIND v(dout0_76) AT=875.025n

.meas tran vdout0_77ck1740 FIND v(dout0_77) AT=875.025n

.meas tran vdout0_78ck1740 FIND v(dout0_78) AT=875.025n

.meas tran vdout0_79ck1740 FIND v(dout0_79) AT=875.025n

.meas tran vdout0_80ck1740 FIND v(dout0_80) AT=875.025n

.meas tran vdout0_81ck1740 FIND v(dout0_81) AT=875.025n

.meas tran vdout0_82ck1740 FIND v(dout0_82) AT=875.025n

.meas tran vdout0_83ck1740 FIND v(dout0_83) AT=875.025n

.meas tran vdout0_84ck1740 FIND v(dout0_84) AT=875.025n

.meas tran vdout0_85ck1740 FIND v(dout0_85) AT=875.025n

.meas tran vdout0_86ck1740 FIND v(dout0_86) AT=875.025n

.meas tran vdout0_87ck1740 FIND v(dout0_87) AT=875.025n

.meas tran vdout0_88ck1740 FIND v(dout0_88) AT=875.025n

.meas tran vdout0_89ck1740 FIND v(dout0_89) AT=875.025n

.meas tran vdout0_90ck1740 FIND v(dout0_90) AT=875.025n

.meas tran vdout0_91ck1740 FIND v(dout0_91) AT=875.025n

.meas tran vdout0_92ck1740 FIND v(dout0_92) AT=875.025n

.meas tran vdout0_93ck1740 FIND v(dout0_93) AT=875.025n

.meas tran vdout0_94ck1740 FIND v(dout0_94) AT=875.025n

.meas tran vdout0_95ck1740 FIND v(dout0_95) AT=875.025n

.meas tran vdout0_96ck1740 FIND v(dout0_96) AT=875.025n

.meas tran vdout0_97ck1740 FIND v(dout0_97) AT=875.025n

.meas tran vdout0_98ck1740 FIND v(dout0_98) AT=875.025n

.meas tran vdout0_99ck1740 FIND v(dout0_99) AT=875.025n

.meas tran vdout0_100ck1740 FIND v(dout0_100) AT=875.025n

.meas tran vdout0_101ck1740 FIND v(dout0_101) AT=875.025n

.meas tran vdout0_102ck1740 FIND v(dout0_102) AT=875.025n

.meas tran vdout0_103ck1740 FIND v(dout0_103) AT=875.025n

.meas tran vdout0_104ck1740 FIND v(dout0_104) AT=875.025n

.meas tran vdout0_105ck1740 FIND v(dout0_105) AT=875.025n

.meas tran vdout0_106ck1740 FIND v(dout0_106) AT=875.025n

.meas tran vdout0_107ck1740 FIND v(dout0_107) AT=875.025n

.meas tran vdout0_108ck1740 FIND v(dout0_108) AT=875.025n

.meas tran vdout0_109ck1740 FIND v(dout0_109) AT=875.025n

.meas tran vdout0_110ck1740 FIND v(dout0_110) AT=875.025n

.meas tran vdout0_111ck1740 FIND v(dout0_111) AT=875.025n

.meas tran vdout0_112ck1740 FIND v(dout0_112) AT=875.025n

.meas tran vdout0_113ck1740 FIND v(dout0_113) AT=875.025n

.meas tran vdout0_114ck1740 FIND v(dout0_114) AT=875.025n

.meas tran vdout0_115ck1740 FIND v(dout0_115) AT=875.025n

.meas tran vdout0_116ck1740 FIND v(dout0_116) AT=875.025n

.meas tran vdout0_117ck1740 FIND v(dout0_117) AT=875.025n

.meas tran vdout0_118ck1740 FIND v(dout0_118) AT=875.025n

.meas tran vdout0_119ck1740 FIND v(dout0_119) AT=875.025n

.meas tran vdout0_120ck1740 FIND v(dout0_120) AT=875.025n

.meas tran vdout0_121ck1740 FIND v(dout0_121) AT=875.025n

.meas tran vdout0_122ck1740 FIND v(dout0_122) AT=875.025n

.meas tran vdout0_123ck1740 FIND v(dout0_123) AT=875.025n

.meas tran vdout0_124ck1740 FIND v(dout0_124) AT=875.025n

.meas tran vdout0_125ck1740 FIND v(dout0_125) AT=875.025n

.meas tran vdout0_126ck1740 FIND v(dout0_126) AT=875.025n

.meas tran vdout0_127ck1740 FIND v(dout0_127) AT=875.025n

.meas tran vdout0_128ck1740 FIND v(dout0_128) AT=875.025n

.meas tran vdout0_129ck1740 FIND v(dout0_129) AT=875.025n

.meas tran vdout0_130ck1740 FIND v(dout0_130) AT=875.025n

.meas tran vdout0_131ck1740 FIND v(dout0_131) AT=875.025n

.meas tran vdout0_132ck1740 FIND v(dout0_132) AT=875.025n

.meas tran vdout0_133ck1740 FIND v(dout0_133) AT=875.025n

.meas tran vdout0_134ck1740 FIND v(dout0_134) AT=875.025n

.meas tran vdout0_135ck1740 FIND v(dout0_135) AT=875.025n

.meas tran vdout0_136ck1740 FIND v(dout0_136) AT=875.025n

.meas tran vdout0_137ck1740 FIND v(dout0_137) AT=875.025n

.meas tran vdout0_138ck1740 FIND v(dout0_138) AT=875.025n

.meas tran vdout0_139ck1740 FIND v(dout0_139) AT=875.025n

.meas tran vdout0_140ck1740 FIND v(dout0_140) AT=875.025n

.meas tran vdout0_141ck1740 FIND v(dout0_141) AT=875.025n

.meas tran vdout0_142ck1740 FIND v(dout0_142) AT=875.025n

.meas tran vdout0_143ck1740 FIND v(dout0_143) AT=875.025n

.meas tran vdout0_144ck1740 FIND v(dout0_144) AT=875.025n

.meas tran vdout0_145ck1740 FIND v(dout0_145) AT=875.025n

.meas tran vdout0_146ck1740 FIND v(dout0_146) AT=875.025n

.meas tran vdout0_147ck1740 FIND v(dout0_147) AT=875.025n

.meas tran vdout0_148ck1740 FIND v(dout0_148) AT=875.025n

.meas tran vdout0_149ck1740 FIND v(dout0_149) AT=875.025n

.meas tran vdout0_150ck1740 FIND v(dout0_150) AT=875.025n

.meas tran vdout0_151ck1740 FIND v(dout0_151) AT=875.025n

.meas tran vdout0_152ck1740 FIND v(dout0_152) AT=875.025n

.meas tran vdout0_153ck1740 FIND v(dout0_153) AT=875.025n

.meas tran vdout0_154ck1740 FIND v(dout0_154) AT=875.025n

.meas tran vdout0_155ck1740 FIND v(dout0_155) AT=875.025n

.meas tran vdout0_156ck1740 FIND v(dout0_156) AT=875.025n

.meas tran vdout0_157ck1740 FIND v(dout0_157) AT=875.025n

.meas tran vdout0_158ck1740 FIND v(dout0_158) AT=875.025n

.meas tran vdout0_159ck1740 FIND v(dout0_159) AT=875.025n

.meas tran vdout0_160ck1740 FIND v(dout0_160) AT=875.025n

.meas tran vdout0_161ck1740 FIND v(dout0_161) AT=875.025n

.meas tran vdout0_162ck1740 FIND v(dout0_162) AT=875.025n

.meas tran vdout0_163ck1740 FIND v(dout0_163) AT=875.025n

.meas tran vdout0_164ck1740 FIND v(dout0_164) AT=875.025n

.meas tran vdout0_165ck1740 FIND v(dout0_165) AT=875.025n

.meas tran vdout0_166ck1740 FIND v(dout0_166) AT=875.025n

.meas tran vdout0_167ck1740 FIND v(dout0_167) AT=875.025n

.meas tran vdout0_168ck1740 FIND v(dout0_168) AT=875.025n

.meas tran vdout0_169ck1740 FIND v(dout0_169) AT=875.025n

.meas tran vdout0_170ck1740 FIND v(dout0_170) AT=875.025n

.meas tran vdout0_171ck1740 FIND v(dout0_171) AT=875.025n

.meas tran vdout0_172ck1740 FIND v(dout0_172) AT=875.025n

.meas tran vdout0_173ck1740 FIND v(dout0_173) AT=875.025n

.meas tran vdout0_174ck1740 FIND v(dout0_174) AT=875.025n

.meas tran vdout0_175ck1740 FIND v(dout0_175) AT=875.025n

.meas tran vdout0_176ck1740 FIND v(dout0_176) AT=875.025n

.meas tran vdout0_177ck1740 FIND v(dout0_177) AT=875.025n

.meas tran vdout0_178ck1740 FIND v(dout0_178) AT=875.025n

.meas tran vdout0_179ck1740 FIND v(dout0_179) AT=875.025n

.meas tran vdout0_180ck1740 FIND v(dout0_180) AT=875.025n

.meas tran vdout0_181ck1740 FIND v(dout0_181) AT=875.025n

.meas tran vdout0_182ck1740 FIND v(dout0_182) AT=875.025n

.meas tran vdout0_183ck1740 FIND v(dout0_183) AT=875.025n

.meas tran vdout0_184ck1740 FIND v(dout0_184) AT=875.025n

.meas tran vdout0_185ck1740 FIND v(dout0_185) AT=875.025n

.meas tran vdout0_186ck1740 FIND v(dout0_186) AT=875.025n

.meas tran vdout0_187ck1740 FIND v(dout0_187) AT=875.025n

.meas tran vdout0_188ck1740 FIND v(dout0_188) AT=875.025n

.meas tran vdout0_189ck1740 FIND v(dout0_189) AT=875.025n

.meas tran vdout0_190ck1740 FIND v(dout0_190) AT=875.025n

.meas tran vdout0_191ck1740 FIND v(dout0_191) AT=875.025n

.meas tran vdout0_192ck1740 FIND v(dout0_192) AT=875.025n

.meas tran vdout0_193ck1740 FIND v(dout0_193) AT=875.025n

.meas tran vdout0_194ck1740 FIND v(dout0_194) AT=875.025n

.meas tran vdout0_195ck1740 FIND v(dout0_195) AT=875.025n

.meas tran vdout0_196ck1740 FIND v(dout0_196) AT=875.025n

.meas tran vdout0_197ck1740 FIND v(dout0_197) AT=875.025n

.meas tran vdout0_198ck1740 FIND v(dout0_198) AT=875.025n

.meas tran vdout0_199ck1740 FIND v(dout0_199) AT=875.025n

.meas tran vdout0_200ck1740 FIND v(dout0_200) AT=875.025n

.meas tran vdout0_201ck1740 FIND v(dout0_201) AT=875.025n

.meas tran vdout0_202ck1740 FIND v(dout0_202) AT=875.025n

.meas tran vdout0_203ck1740 FIND v(dout0_203) AT=875.025n

.meas tran vdout0_204ck1740 FIND v(dout0_204) AT=875.025n

.meas tran vdout0_205ck1740 FIND v(dout0_205) AT=875.025n

.meas tran vdout0_206ck1740 FIND v(dout0_206) AT=875.025n

.meas tran vdout0_207ck1740 FIND v(dout0_207) AT=875.025n

.meas tran vdout0_208ck1740 FIND v(dout0_208) AT=875.025n

.meas tran vdout0_209ck1740 FIND v(dout0_209) AT=875.025n

.meas tran vdout0_210ck1740 FIND v(dout0_210) AT=875.025n

.meas tran vdout0_211ck1740 FIND v(dout0_211) AT=875.025n

.meas tran vdout0_212ck1740 FIND v(dout0_212) AT=875.025n

.meas tran vdout0_213ck1740 FIND v(dout0_213) AT=875.025n

.meas tran vdout0_214ck1740 FIND v(dout0_214) AT=875.025n

.meas tran vdout0_215ck1740 FIND v(dout0_215) AT=875.025n

.meas tran vdout0_216ck1740 FIND v(dout0_216) AT=875.025n

.meas tran vdout0_217ck1740 FIND v(dout0_217) AT=875.025n

.meas tran vdout0_218ck1740 FIND v(dout0_218) AT=875.025n

.meas tran vdout0_219ck1740 FIND v(dout0_219) AT=875.025n

.meas tran vdout0_220ck1740 FIND v(dout0_220) AT=875.025n

.meas tran vdout0_221ck1740 FIND v(dout0_221) AT=875.025n

.meas tran vdout0_222ck1740 FIND v(dout0_222) AT=875.025n

.meas tran vdout0_223ck1740 FIND v(dout0_223) AT=875.025n

.meas tran vdout0_224ck1740 FIND v(dout0_224) AT=875.025n

.meas tran vdout0_225ck1740 FIND v(dout0_225) AT=875.025n

.meas tran vdout0_226ck1740 FIND v(dout0_226) AT=875.025n

.meas tran vdout0_227ck1740 FIND v(dout0_227) AT=875.025n

.meas tran vdout0_228ck1740 FIND v(dout0_228) AT=875.025n

.meas tran vdout0_229ck1740 FIND v(dout0_229) AT=875.025n

.meas tran vdout0_230ck1740 FIND v(dout0_230) AT=875.025n

.meas tran vdout0_231ck1740 FIND v(dout0_231) AT=875.025n

.meas tran vdout0_232ck1740 FIND v(dout0_232) AT=875.025n

.meas tran vdout0_233ck1740 FIND v(dout0_233) AT=875.025n

.meas tran vdout0_234ck1740 FIND v(dout0_234) AT=875.025n

.meas tran vdout0_235ck1740 FIND v(dout0_235) AT=875.025n

.meas tran vdout0_236ck1740 FIND v(dout0_236) AT=875.025n

.meas tran vdout0_237ck1740 FIND v(dout0_237) AT=875.025n

.meas tran vdout0_238ck1740 FIND v(dout0_238) AT=875.025n

.meas tran vdout0_239ck1740 FIND v(dout0_239) AT=875.025n

.meas tran vdout0_240ck1740 FIND v(dout0_240) AT=875.025n

.meas tran vdout0_241ck1740 FIND v(dout0_241) AT=875.025n

.meas tran vdout0_242ck1740 FIND v(dout0_242) AT=875.025n

.meas tran vdout0_243ck1740 FIND v(dout0_243) AT=875.025n

.meas tran vdout0_244ck1740 FIND v(dout0_244) AT=875.025n

.meas tran vdout0_245ck1740 FIND v(dout0_245) AT=875.025n

.meas tran vdout0_246ck1740 FIND v(dout0_246) AT=875.025n

.meas tran vdout0_247ck1740 FIND v(dout0_247) AT=875.025n

.meas tran vdout0_248ck1740 FIND v(dout0_248) AT=875.025n

.meas tran vdout0_249ck1740 FIND v(dout0_249) AT=875.025n

.meas tran vdout0_250ck1740 FIND v(dout0_250) AT=875.025n

.meas tran vdout0_251ck1740 FIND v(dout0_251) AT=875.025n

.meas tran vdout0_252ck1740 FIND v(dout0_252) AT=875.025n

.meas tran vdout0_253ck1740 FIND v(dout0_253) AT=875.025n

.meas tran vdout0_254ck1740 FIND v(dout0_254) AT=875.025n

.meas tran vdout0_255ck1740 FIND v(dout0_255) AT=875.025n

.meas tran vdout0_0ck1780 FIND v(dout0_0) AT=895.025n

.meas tran vdout0_1ck1780 FIND v(dout0_1) AT=895.025n

.meas tran vdout0_2ck1780 FIND v(dout0_2) AT=895.025n

.meas tran vdout0_3ck1780 FIND v(dout0_3) AT=895.025n

.meas tran vdout0_4ck1780 FIND v(dout0_4) AT=895.025n

.meas tran vdout0_5ck1780 FIND v(dout0_5) AT=895.025n

.meas tran vdout0_6ck1780 FIND v(dout0_6) AT=895.025n

.meas tran vdout0_7ck1780 FIND v(dout0_7) AT=895.025n

.meas tran vdout0_8ck1780 FIND v(dout0_8) AT=895.025n

.meas tran vdout0_9ck1780 FIND v(dout0_9) AT=895.025n

.meas tran vdout0_10ck1780 FIND v(dout0_10) AT=895.025n

.meas tran vdout0_11ck1780 FIND v(dout0_11) AT=895.025n

.meas tran vdout0_12ck1780 FIND v(dout0_12) AT=895.025n

.meas tran vdout0_13ck1780 FIND v(dout0_13) AT=895.025n

.meas tran vdout0_14ck1780 FIND v(dout0_14) AT=895.025n

.meas tran vdout0_15ck1780 FIND v(dout0_15) AT=895.025n

.meas tran vdout0_16ck1780 FIND v(dout0_16) AT=895.025n

.meas tran vdout0_17ck1780 FIND v(dout0_17) AT=895.025n

.meas tran vdout0_18ck1780 FIND v(dout0_18) AT=895.025n

.meas tran vdout0_19ck1780 FIND v(dout0_19) AT=895.025n

.meas tran vdout0_20ck1780 FIND v(dout0_20) AT=895.025n

.meas tran vdout0_21ck1780 FIND v(dout0_21) AT=895.025n

.meas tran vdout0_22ck1780 FIND v(dout0_22) AT=895.025n

.meas tran vdout0_23ck1780 FIND v(dout0_23) AT=895.025n

.meas tran vdout0_24ck1780 FIND v(dout0_24) AT=895.025n

.meas tran vdout0_25ck1780 FIND v(dout0_25) AT=895.025n

.meas tran vdout0_26ck1780 FIND v(dout0_26) AT=895.025n

.meas tran vdout0_27ck1780 FIND v(dout0_27) AT=895.025n

.meas tran vdout0_28ck1780 FIND v(dout0_28) AT=895.025n

.meas tran vdout0_29ck1780 FIND v(dout0_29) AT=895.025n

.meas tran vdout0_30ck1780 FIND v(dout0_30) AT=895.025n

.meas tran vdout0_31ck1780 FIND v(dout0_31) AT=895.025n

.meas tran vdout0_32ck1780 FIND v(dout0_32) AT=895.025n

.meas tran vdout0_33ck1780 FIND v(dout0_33) AT=895.025n

.meas tran vdout0_34ck1780 FIND v(dout0_34) AT=895.025n

.meas tran vdout0_35ck1780 FIND v(dout0_35) AT=895.025n

.meas tran vdout0_36ck1780 FIND v(dout0_36) AT=895.025n

.meas tran vdout0_37ck1780 FIND v(dout0_37) AT=895.025n

.meas tran vdout0_38ck1780 FIND v(dout0_38) AT=895.025n

.meas tran vdout0_39ck1780 FIND v(dout0_39) AT=895.025n

.meas tran vdout0_40ck1780 FIND v(dout0_40) AT=895.025n

.meas tran vdout0_41ck1780 FIND v(dout0_41) AT=895.025n

.meas tran vdout0_42ck1780 FIND v(dout0_42) AT=895.025n

.meas tran vdout0_43ck1780 FIND v(dout0_43) AT=895.025n

.meas tran vdout0_44ck1780 FIND v(dout0_44) AT=895.025n

.meas tran vdout0_45ck1780 FIND v(dout0_45) AT=895.025n

.meas tran vdout0_46ck1780 FIND v(dout0_46) AT=895.025n

.meas tran vdout0_47ck1780 FIND v(dout0_47) AT=895.025n

.meas tran vdout0_48ck1780 FIND v(dout0_48) AT=895.025n

.meas tran vdout0_49ck1780 FIND v(dout0_49) AT=895.025n

.meas tran vdout0_50ck1780 FIND v(dout0_50) AT=895.025n

.meas tran vdout0_51ck1780 FIND v(dout0_51) AT=895.025n

.meas tran vdout0_52ck1780 FIND v(dout0_52) AT=895.025n

.meas tran vdout0_53ck1780 FIND v(dout0_53) AT=895.025n

.meas tran vdout0_54ck1780 FIND v(dout0_54) AT=895.025n

.meas tran vdout0_55ck1780 FIND v(dout0_55) AT=895.025n

.meas tran vdout0_56ck1780 FIND v(dout0_56) AT=895.025n

.meas tran vdout0_57ck1780 FIND v(dout0_57) AT=895.025n

.meas tran vdout0_58ck1780 FIND v(dout0_58) AT=895.025n

.meas tran vdout0_59ck1780 FIND v(dout0_59) AT=895.025n

.meas tran vdout0_60ck1780 FIND v(dout0_60) AT=895.025n

.meas tran vdout0_61ck1780 FIND v(dout0_61) AT=895.025n

.meas tran vdout0_62ck1780 FIND v(dout0_62) AT=895.025n

.meas tran vdout0_63ck1780 FIND v(dout0_63) AT=895.025n

.meas tran vdout0_64ck1780 FIND v(dout0_64) AT=895.025n

.meas tran vdout0_65ck1780 FIND v(dout0_65) AT=895.025n

.meas tran vdout0_66ck1780 FIND v(dout0_66) AT=895.025n

.meas tran vdout0_67ck1780 FIND v(dout0_67) AT=895.025n

.meas tran vdout0_68ck1780 FIND v(dout0_68) AT=895.025n

.meas tran vdout0_69ck1780 FIND v(dout0_69) AT=895.025n

.meas tran vdout0_70ck1780 FIND v(dout0_70) AT=895.025n

.meas tran vdout0_71ck1780 FIND v(dout0_71) AT=895.025n

.meas tran vdout0_72ck1780 FIND v(dout0_72) AT=895.025n

.meas tran vdout0_73ck1780 FIND v(dout0_73) AT=895.025n

.meas tran vdout0_74ck1780 FIND v(dout0_74) AT=895.025n

.meas tran vdout0_75ck1780 FIND v(dout0_75) AT=895.025n

.meas tran vdout0_76ck1780 FIND v(dout0_76) AT=895.025n

.meas tran vdout0_77ck1780 FIND v(dout0_77) AT=895.025n

.meas tran vdout0_78ck1780 FIND v(dout0_78) AT=895.025n

.meas tran vdout0_79ck1780 FIND v(dout0_79) AT=895.025n

.meas tran vdout0_80ck1780 FIND v(dout0_80) AT=895.025n

.meas tran vdout0_81ck1780 FIND v(dout0_81) AT=895.025n

.meas tran vdout0_82ck1780 FIND v(dout0_82) AT=895.025n

.meas tran vdout0_83ck1780 FIND v(dout0_83) AT=895.025n

.meas tran vdout0_84ck1780 FIND v(dout0_84) AT=895.025n

.meas tran vdout0_85ck1780 FIND v(dout0_85) AT=895.025n

.meas tran vdout0_86ck1780 FIND v(dout0_86) AT=895.025n

.meas tran vdout0_87ck1780 FIND v(dout0_87) AT=895.025n

.meas tran vdout0_88ck1780 FIND v(dout0_88) AT=895.025n

.meas tran vdout0_89ck1780 FIND v(dout0_89) AT=895.025n

.meas tran vdout0_90ck1780 FIND v(dout0_90) AT=895.025n

.meas tran vdout0_91ck1780 FIND v(dout0_91) AT=895.025n

.meas tran vdout0_92ck1780 FIND v(dout0_92) AT=895.025n

.meas tran vdout0_93ck1780 FIND v(dout0_93) AT=895.025n

.meas tran vdout0_94ck1780 FIND v(dout0_94) AT=895.025n

.meas tran vdout0_95ck1780 FIND v(dout0_95) AT=895.025n

.meas tran vdout0_96ck1780 FIND v(dout0_96) AT=895.025n

.meas tran vdout0_97ck1780 FIND v(dout0_97) AT=895.025n

.meas tran vdout0_98ck1780 FIND v(dout0_98) AT=895.025n

.meas tran vdout0_99ck1780 FIND v(dout0_99) AT=895.025n

.meas tran vdout0_100ck1780 FIND v(dout0_100) AT=895.025n

.meas tran vdout0_101ck1780 FIND v(dout0_101) AT=895.025n

.meas tran vdout0_102ck1780 FIND v(dout0_102) AT=895.025n

.meas tran vdout0_103ck1780 FIND v(dout0_103) AT=895.025n

.meas tran vdout0_104ck1780 FIND v(dout0_104) AT=895.025n

.meas tran vdout0_105ck1780 FIND v(dout0_105) AT=895.025n

.meas tran vdout0_106ck1780 FIND v(dout0_106) AT=895.025n

.meas tran vdout0_107ck1780 FIND v(dout0_107) AT=895.025n

.meas tran vdout0_108ck1780 FIND v(dout0_108) AT=895.025n

.meas tran vdout0_109ck1780 FIND v(dout0_109) AT=895.025n

.meas tran vdout0_110ck1780 FIND v(dout0_110) AT=895.025n

.meas tran vdout0_111ck1780 FIND v(dout0_111) AT=895.025n

.meas tran vdout0_112ck1780 FIND v(dout0_112) AT=895.025n

.meas tran vdout0_113ck1780 FIND v(dout0_113) AT=895.025n

.meas tran vdout0_114ck1780 FIND v(dout0_114) AT=895.025n

.meas tran vdout0_115ck1780 FIND v(dout0_115) AT=895.025n

.meas tran vdout0_116ck1780 FIND v(dout0_116) AT=895.025n

.meas tran vdout0_117ck1780 FIND v(dout0_117) AT=895.025n

.meas tran vdout0_118ck1780 FIND v(dout0_118) AT=895.025n

.meas tran vdout0_119ck1780 FIND v(dout0_119) AT=895.025n

.meas tran vdout0_120ck1780 FIND v(dout0_120) AT=895.025n

.meas tran vdout0_121ck1780 FIND v(dout0_121) AT=895.025n

.meas tran vdout0_122ck1780 FIND v(dout0_122) AT=895.025n

.meas tran vdout0_123ck1780 FIND v(dout0_123) AT=895.025n

.meas tran vdout0_124ck1780 FIND v(dout0_124) AT=895.025n

.meas tran vdout0_125ck1780 FIND v(dout0_125) AT=895.025n

.meas tran vdout0_126ck1780 FIND v(dout0_126) AT=895.025n

.meas tran vdout0_127ck1780 FIND v(dout0_127) AT=895.025n

.meas tran vdout0_128ck1780 FIND v(dout0_128) AT=895.025n

.meas tran vdout0_129ck1780 FIND v(dout0_129) AT=895.025n

.meas tran vdout0_130ck1780 FIND v(dout0_130) AT=895.025n

.meas tran vdout0_131ck1780 FIND v(dout0_131) AT=895.025n

.meas tran vdout0_132ck1780 FIND v(dout0_132) AT=895.025n

.meas tran vdout0_133ck1780 FIND v(dout0_133) AT=895.025n

.meas tran vdout0_134ck1780 FIND v(dout0_134) AT=895.025n

.meas tran vdout0_135ck1780 FIND v(dout0_135) AT=895.025n

.meas tran vdout0_136ck1780 FIND v(dout0_136) AT=895.025n

.meas tran vdout0_137ck1780 FIND v(dout0_137) AT=895.025n

.meas tran vdout0_138ck1780 FIND v(dout0_138) AT=895.025n

.meas tran vdout0_139ck1780 FIND v(dout0_139) AT=895.025n

.meas tran vdout0_140ck1780 FIND v(dout0_140) AT=895.025n

.meas tran vdout0_141ck1780 FIND v(dout0_141) AT=895.025n

.meas tran vdout0_142ck1780 FIND v(dout0_142) AT=895.025n

.meas tran vdout0_143ck1780 FIND v(dout0_143) AT=895.025n

.meas tran vdout0_144ck1780 FIND v(dout0_144) AT=895.025n

.meas tran vdout0_145ck1780 FIND v(dout0_145) AT=895.025n

.meas tran vdout0_146ck1780 FIND v(dout0_146) AT=895.025n

.meas tran vdout0_147ck1780 FIND v(dout0_147) AT=895.025n

.meas tran vdout0_148ck1780 FIND v(dout0_148) AT=895.025n

.meas tran vdout0_149ck1780 FIND v(dout0_149) AT=895.025n

.meas tran vdout0_150ck1780 FIND v(dout0_150) AT=895.025n

.meas tran vdout0_151ck1780 FIND v(dout0_151) AT=895.025n

.meas tran vdout0_152ck1780 FIND v(dout0_152) AT=895.025n

.meas tran vdout0_153ck1780 FIND v(dout0_153) AT=895.025n

.meas tran vdout0_154ck1780 FIND v(dout0_154) AT=895.025n

.meas tran vdout0_155ck1780 FIND v(dout0_155) AT=895.025n

.meas tran vdout0_156ck1780 FIND v(dout0_156) AT=895.025n

.meas tran vdout0_157ck1780 FIND v(dout0_157) AT=895.025n

.meas tran vdout0_158ck1780 FIND v(dout0_158) AT=895.025n

.meas tran vdout0_159ck1780 FIND v(dout0_159) AT=895.025n

.meas tran vdout0_160ck1780 FIND v(dout0_160) AT=895.025n

.meas tran vdout0_161ck1780 FIND v(dout0_161) AT=895.025n

.meas tran vdout0_162ck1780 FIND v(dout0_162) AT=895.025n

.meas tran vdout0_163ck1780 FIND v(dout0_163) AT=895.025n

.meas tran vdout0_164ck1780 FIND v(dout0_164) AT=895.025n

.meas tran vdout0_165ck1780 FIND v(dout0_165) AT=895.025n

.meas tran vdout0_166ck1780 FIND v(dout0_166) AT=895.025n

.meas tran vdout0_167ck1780 FIND v(dout0_167) AT=895.025n

.meas tran vdout0_168ck1780 FIND v(dout0_168) AT=895.025n

.meas tran vdout0_169ck1780 FIND v(dout0_169) AT=895.025n

.meas tran vdout0_170ck1780 FIND v(dout0_170) AT=895.025n

.meas tran vdout0_171ck1780 FIND v(dout0_171) AT=895.025n

.meas tran vdout0_172ck1780 FIND v(dout0_172) AT=895.025n

.meas tran vdout0_173ck1780 FIND v(dout0_173) AT=895.025n

.meas tran vdout0_174ck1780 FIND v(dout0_174) AT=895.025n

.meas tran vdout0_175ck1780 FIND v(dout0_175) AT=895.025n

.meas tran vdout0_176ck1780 FIND v(dout0_176) AT=895.025n

.meas tran vdout0_177ck1780 FIND v(dout0_177) AT=895.025n

.meas tran vdout0_178ck1780 FIND v(dout0_178) AT=895.025n

.meas tran vdout0_179ck1780 FIND v(dout0_179) AT=895.025n

.meas tran vdout0_180ck1780 FIND v(dout0_180) AT=895.025n

.meas tran vdout0_181ck1780 FIND v(dout0_181) AT=895.025n

.meas tran vdout0_182ck1780 FIND v(dout0_182) AT=895.025n

.meas tran vdout0_183ck1780 FIND v(dout0_183) AT=895.025n

.meas tran vdout0_184ck1780 FIND v(dout0_184) AT=895.025n

.meas tran vdout0_185ck1780 FIND v(dout0_185) AT=895.025n

.meas tran vdout0_186ck1780 FIND v(dout0_186) AT=895.025n

.meas tran vdout0_187ck1780 FIND v(dout0_187) AT=895.025n

.meas tran vdout0_188ck1780 FIND v(dout0_188) AT=895.025n

.meas tran vdout0_189ck1780 FIND v(dout0_189) AT=895.025n

.meas tran vdout0_190ck1780 FIND v(dout0_190) AT=895.025n

.meas tran vdout0_191ck1780 FIND v(dout0_191) AT=895.025n

.meas tran vdout0_192ck1780 FIND v(dout0_192) AT=895.025n

.meas tran vdout0_193ck1780 FIND v(dout0_193) AT=895.025n

.meas tran vdout0_194ck1780 FIND v(dout0_194) AT=895.025n

.meas tran vdout0_195ck1780 FIND v(dout0_195) AT=895.025n

.meas tran vdout0_196ck1780 FIND v(dout0_196) AT=895.025n

.meas tran vdout0_197ck1780 FIND v(dout0_197) AT=895.025n

.meas tran vdout0_198ck1780 FIND v(dout0_198) AT=895.025n

.meas tran vdout0_199ck1780 FIND v(dout0_199) AT=895.025n

.meas tran vdout0_200ck1780 FIND v(dout0_200) AT=895.025n

.meas tran vdout0_201ck1780 FIND v(dout0_201) AT=895.025n

.meas tran vdout0_202ck1780 FIND v(dout0_202) AT=895.025n

.meas tran vdout0_203ck1780 FIND v(dout0_203) AT=895.025n

.meas tran vdout0_204ck1780 FIND v(dout0_204) AT=895.025n

.meas tran vdout0_205ck1780 FIND v(dout0_205) AT=895.025n

.meas tran vdout0_206ck1780 FIND v(dout0_206) AT=895.025n

.meas tran vdout0_207ck1780 FIND v(dout0_207) AT=895.025n

.meas tran vdout0_208ck1780 FIND v(dout0_208) AT=895.025n

.meas tran vdout0_209ck1780 FIND v(dout0_209) AT=895.025n

.meas tran vdout0_210ck1780 FIND v(dout0_210) AT=895.025n

.meas tran vdout0_211ck1780 FIND v(dout0_211) AT=895.025n

.meas tran vdout0_212ck1780 FIND v(dout0_212) AT=895.025n

.meas tran vdout0_213ck1780 FIND v(dout0_213) AT=895.025n

.meas tran vdout0_214ck1780 FIND v(dout0_214) AT=895.025n

.meas tran vdout0_215ck1780 FIND v(dout0_215) AT=895.025n

.meas tran vdout0_216ck1780 FIND v(dout0_216) AT=895.025n

.meas tran vdout0_217ck1780 FIND v(dout0_217) AT=895.025n

.meas tran vdout0_218ck1780 FIND v(dout0_218) AT=895.025n

.meas tran vdout0_219ck1780 FIND v(dout0_219) AT=895.025n

.meas tran vdout0_220ck1780 FIND v(dout0_220) AT=895.025n

.meas tran vdout0_221ck1780 FIND v(dout0_221) AT=895.025n

.meas tran vdout0_222ck1780 FIND v(dout0_222) AT=895.025n

.meas tran vdout0_223ck1780 FIND v(dout0_223) AT=895.025n

.meas tran vdout0_224ck1780 FIND v(dout0_224) AT=895.025n

.meas tran vdout0_225ck1780 FIND v(dout0_225) AT=895.025n

.meas tran vdout0_226ck1780 FIND v(dout0_226) AT=895.025n

.meas tran vdout0_227ck1780 FIND v(dout0_227) AT=895.025n

.meas tran vdout0_228ck1780 FIND v(dout0_228) AT=895.025n

.meas tran vdout0_229ck1780 FIND v(dout0_229) AT=895.025n

.meas tran vdout0_230ck1780 FIND v(dout0_230) AT=895.025n

.meas tran vdout0_231ck1780 FIND v(dout0_231) AT=895.025n

.meas tran vdout0_232ck1780 FIND v(dout0_232) AT=895.025n

.meas tran vdout0_233ck1780 FIND v(dout0_233) AT=895.025n

.meas tran vdout0_234ck1780 FIND v(dout0_234) AT=895.025n

.meas tran vdout0_235ck1780 FIND v(dout0_235) AT=895.025n

.meas tran vdout0_236ck1780 FIND v(dout0_236) AT=895.025n

.meas tran vdout0_237ck1780 FIND v(dout0_237) AT=895.025n

.meas tran vdout0_238ck1780 FIND v(dout0_238) AT=895.025n

.meas tran vdout0_239ck1780 FIND v(dout0_239) AT=895.025n

.meas tran vdout0_240ck1780 FIND v(dout0_240) AT=895.025n

.meas tran vdout0_241ck1780 FIND v(dout0_241) AT=895.025n

.meas tran vdout0_242ck1780 FIND v(dout0_242) AT=895.025n

.meas tran vdout0_243ck1780 FIND v(dout0_243) AT=895.025n

.meas tran vdout0_244ck1780 FIND v(dout0_244) AT=895.025n

.meas tran vdout0_245ck1780 FIND v(dout0_245) AT=895.025n

.meas tran vdout0_246ck1780 FIND v(dout0_246) AT=895.025n

.meas tran vdout0_247ck1780 FIND v(dout0_247) AT=895.025n

.meas tran vdout0_248ck1780 FIND v(dout0_248) AT=895.025n

.meas tran vdout0_249ck1780 FIND v(dout0_249) AT=895.025n

.meas tran vdout0_250ck1780 FIND v(dout0_250) AT=895.025n

.meas tran vdout0_251ck1780 FIND v(dout0_251) AT=895.025n

.meas tran vdout0_252ck1780 FIND v(dout0_252) AT=895.025n

.meas tran vdout0_253ck1780 FIND v(dout0_253) AT=895.025n

.meas tran vdout0_254ck1780 FIND v(dout0_254) AT=895.025n

.meas tran vdout0_255ck1780 FIND v(dout0_255) AT=895.025n

.meas tran vdout0_0ck1810 FIND v(dout0_0) AT=910.025n

.meas tran vdout0_1ck1810 FIND v(dout0_1) AT=910.025n

.meas tran vdout0_2ck1810 FIND v(dout0_2) AT=910.025n

.meas tran vdout0_3ck1810 FIND v(dout0_3) AT=910.025n

.meas tran vdout0_4ck1810 FIND v(dout0_4) AT=910.025n

.meas tran vdout0_5ck1810 FIND v(dout0_5) AT=910.025n

.meas tran vdout0_6ck1810 FIND v(dout0_6) AT=910.025n

.meas tran vdout0_7ck1810 FIND v(dout0_7) AT=910.025n

.meas tran vdout0_8ck1810 FIND v(dout0_8) AT=910.025n

.meas tran vdout0_9ck1810 FIND v(dout0_9) AT=910.025n

.meas tran vdout0_10ck1810 FIND v(dout0_10) AT=910.025n

.meas tran vdout0_11ck1810 FIND v(dout0_11) AT=910.025n

.meas tran vdout0_12ck1810 FIND v(dout0_12) AT=910.025n

.meas tran vdout0_13ck1810 FIND v(dout0_13) AT=910.025n

.meas tran vdout0_14ck1810 FIND v(dout0_14) AT=910.025n

.meas tran vdout0_15ck1810 FIND v(dout0_15) AT=910.025n

.meas tran vdout0_16ck1810 FIND v(dout0_16) AT=910.025n

.meas tran vdout0_17ck1810 FIND v(dout0_17) AT=910.025n

.meas tran vdout0_18ck1810 FIND v(dout0_18) AT=910.025n

.meas tran vdout0_19ck1810 FIND v(dout0_19) AT=910.025n

.meas tran vdout0_20ck1810 FIND v(dout0_20) AT=910.025n

.meas tran vdout0_21ck1810 FIND v(dout0_21) AT=910.025n

.meas tran vdout0_22ck1810 FIND v(dout0_22) AT=910.025n

.meas tran vdout0_23ck1810 FIND v(dout0_23) AT=910.025n

.meas tran vdout0_24ck1810 FIND v(dout0_24) AT=910.025n

.meas tran vdout0_25ck1810 FIND v(dout0_25) AT=910.025n

.meas tran vdout0_26ck1810 FIND v(dout0_26) AT=910.025n

.meas tran vdout0_27ck1810 FIND v(dout0_27) AT=910.025n

.meas tran vdout0_28ck1810 FIND v(dout0_28) AT=910.025n

.meas tran vdout0_29ck1810 FIND v(dout0_29) AT=910.025n

.meas tran vdout0_30ck1810 FIND v(dout0_30) AT=910.025n

.meas tran vdout0_31ck1810 FIND v(dout0_31) AT=910.025n

.meas tran vdout0_32ck1810 FIND v(dout0_32) AT=910.025n

.meas tran vdout0_33ck1810 FIND v(dout0_33) AT=910.025n

.meas tran vdout0_34ck1810 FIND v(dout0_34) AT=910.025n

.meas tran vdout0_35ck1810 FIND v(dout0_35) AT=910.025n

.meas tran vdout0_36ck1810 FIND v(dout0_36) AT=910.025n

.meas tran vdout0_37ck1810 FIND v(dout0_37) AT=910.025n

.meas tran vdout0_38ck1810 FIND v(dout0_38) AT=910.025n

.meas tran vdout0_39ck1810 FIND v(dout0_39) AT=910.025n

.meas tran vdout0_40ck1810 FIND v(dout0_40) AT=910.025n

.meas tran vdout0_41ck1810 FIND v(dout0_41) AT=910.025n

.meas tran vdout0_42ck1810 FIND v(dout0_42) AT=910.025n

.meas tran vdout0_43ck1810 FIND v(dout0_43) AT=910.025n

.meas tran vdout0_44ck1810 FIND v(dout0_44) AT=910.025n

.meas tran vdout0_45ck1810 FIND v(dout0_45) AT=910.025n

.meas tran vdout0_46ck1810 FIND v(dout0_46) AT=910.025n

.meas tran vdout0_47ck1810 FIND v(dout0_47) AT=910.025n

.meas tran vdout0_48ck1810 FIND v(dout0_48) AT=910.025n

.meas tran vdout0_49ck1810 FIND v(dout0_49) AT=910.025n

.meas tran vdout0_50ck1810 FIND v(dout0_50) AT=910.025n

.meas tran vdout0_51ck1810 FIND v(dout0_51) AT=910.025n

.meas tran vdout0_52ck1810 FIND v(dout0_52) AT=910.025n

.meas tran vdout0_53ck1810 FIND v(dout0_53) AT=910.025n

.meas tran vdout0_54ck1810 FIND v(dout0_54) AT=910.025n

.meas tran vdout0_55ck1810 FIND v(dout0_55) AT=910.025n

.meas tran vdout0_56ck1810 FIND v(dout0_56) AT=910.025n

.meas tran vdout0_57ck1810 FIND v(dout0_57) AT=910.025n

.meas tran vdout0_58ck1810 FIND v(dout0_58) AT=910.025n

.meas tran vdout0_59ck1810 FIND v(dout0_59) AT=910.025n

.meas tran vdout0_60ck1810 FIND v(dout0_60) AT=910.025n

.meas tran vdout0_61ck1810 FIND v(dout0_61) AT=910.025n

.meas tran vdout0_62ck1810 FIND v(dout0_62) AT=910.025n

.meas tran vdout0_63ck1810 FIND v(dout0_63) AT=910.025n

.meas tran vdout0_64ck1810 FIND v(dout0_64) AT=910.025n

.meas tran vdout0_65ck1810 FIND v(dout0_65) AT=910.025n

.meas tran vdout0_66ck1810 FIND v(dout0_66) AT=910.025n

.meas tran vdout0_67ck1810 FIND v(dout0_67) AT=910.025n

.meas tran vdout0_68ck1810 FIND v(dout0_68) AT=910.025n

.meas tran vdout0_69ck1810 FIND v(dout0_69) AT=910.025n

.meas tran vdout0_70ck1810 FIND v(dout0_70) AT=910.025n

.meas tran vdout0_71ck1810 FIND v(dout0_71) AT=910.025n

.meas tran vdout0_72ck1810 FIND v(dout0_72) AT=910.025n

.meas tran vdout0_73ck1810 FIND v(dout0_73) AT=910.025n

.meas tran vdout0_74ck1810 FIND v(dout0_74) AT=910.025n

.meas tran vdout0_75ck1810 FIND v(dout0_75) AT=910.025n

.meas tran vdout0_76ck1810 FIND v(dout0_76) AT=910.025n

.meas tran vdout0_77ck1810 FIND v(dout0_77) AT=910.025n

.meas tran vdout0_78ck1810 FIND v(dout0_78) AT=910.025n

.meas tran vdout0_79ck1810 FIND v(dout0_79) AT=910.025n

.meas tran vdout0_80ck1810 FIND v(dout0_80) AT=910.025n

.meas tran vdout0_81ck1810 FIND v(dout0_81) AT=910.025n

.meas tran vdout0_82ck1810 FIND v(dout0_82) AT=910.025n

.meas tran vdout0_83ck1810 FIND v(dout0_83) AT=910.025n

.meas tran vdout0_84ck1810 FIND v(dout0_84) AT=910.025n

.meas tran vdout0_85ck1810 FIND v(dout0_85) AT=910.025n

.meas tran vdout0_86ck1810 FIND v(dout0_86) AT=910.025n

.meas tran vdout0_87ck1810 FIND v(dout0_87) AT=910.025n

.meas tran vdout0_88ck1810 FIND v(dout0_88) AT=910.025n

.meas tran vdout0_89ck1810 FIND v(dout0_89) AT=910.025n

.meas tran vdout0_90ck1810 FIND v(dout0_90) AT=910.025n

.meas tran vdout0_91ck1810 FIND v(dout0_91) AT=910.025n

.meas tran vdout0_92ck1810 FIND v(dout0_92) AT=910.025n

.meas tran vdout0_93ck1810 FIND v(dout0_93) AT=910.025n

.meas tran vdout0_94ck1810 FIND v(dout0_94) AT=910.025n

.meas tran vdout0_95ck1810 FIND v(dout0_95) AT=910.025n

.meas tran vdout0_96ck1810 FIND v(dout0_96) AT=910.025n

.meas tran vdout0_97ck1810 FIND v(dout0_97) AT=910.025n

.meas tran vdout0_98ck1810 FIND v(dout0_98) AT=910.025n

.meas tran vdout0_99ck1810 FIND v(dout0_99) AT=910.025n

.meas tran vdout0_100ck1810 FIND v(dout0_100) AT=910.025n

.meas tran vdout0_101ck1810 FIND v(dout0_101) AT=910.025n

.meas tran vdout0_102ck1810 FIND v(dout0_102) AT=910.025n

.meas tran vdout0_103ck1810 FIND v(dout0_103) AT=910.025n

.meas tran vdout0_104ck1810 FIND v(dout0_104) AT=910.025n

.meas tran vdout0_105ck1810 FIND v(dout0_105) AT=910.025n

.meas tran vdout0_106ck1810 FIND v(dout0_106) AT=910.025n

.meas tran vdout0_107ck1810 FIND v(dout0_107) AT=910.025n

.meas tran vdout0_108ck1810 FIND v(dout0_108) AT=910.025n

.meas tran vdout0_109ck1810 FIND v(dout0_109) AT=910.025n

.meas tran vdout0_110ck1810 FIND v(dout0_110) AT=910.025n

.meas tran vdout0_111ck1810 FIND v(dout0_111) AT=910.025n

.meas tran vdout0_112ck1810 FIND v(dout0_112) AT=910.025n

.meas tran vdout0_113ck1810 FIND v(dout0_113) AT=910.025n

.meas tran vdout0_114ck1810 FIND v(dout0_114) AT=910.025n

.meas tran vdout0_115ck1810 FIND v(dout0_115) AT=910.025n

.meas tran vdout0_116ck1810 FIND v(dout0_116) AT=910.025n

.meas tran vdout0_117ck1810 FIND v(dout0_117) AT=910.025n

.meas tran vdout0_118ck1810 FIND v(dout0_118) AT=910.025n

.meas tran vdout0_119ck1810 FIND v(dout0_119) AT=910.025n

.meas tran vdout0_120ck1810 FIND v(dout0_120) AT=910.025n

.meas tran vdout0_121ck1810 FIND v(dout0_121) AT=910.025n

.meas tran vdout0_122ck1810 FIND v(dout0_122) AT=910.025n

.meas tran vdout0_123ck1810 FIND v(dout0_123) AT=910.025n

.meas tran vdout0_124ck1810 FIND v(dout0_124) AT=910.025n

.meas tran vdout0_125ck1810 FIND v(dout0_125) AT=910.025n

.meas tran vdout0_126ck1810 FIND v(dout0_126) AT=910.025n

.meas tran vdout0_127ck1810 FIND v(dout0_127) AT=910.025n

.meas tran vdout0_128ck1810 FIND v(dout0_128) AT=910.025n

.meas tran vdout0_129ck1810 FIND v(dout0_129) AT=910.025n

.meas tran vdout0_130ck1810 FIND v(dout0_130) AT=910.025n

.meas tran vdout0_131ck1810 FIND v(dout0_131) AT=910.025n

.meas tran vdout0_132ck1810 FIND v(dout0_132) AT=910.025n

.meas tran vdout0_133ck1810 FIND v(dout0_133) AT=910.025n

.meas tran vdout0_134ck1810 FIND v(dout0_134) AT=910.025n

.meas tran vdout0_135ck1810 FIND v(dout0_135) AT=910.025n

.meas tran vdout0_136ck1810 FIND v(dout0_136) AT=910.025n

.meas tran vdout0_137ck1810 FIND v(dout0_137) AT=910.025n

.meas tran vdout0_138ck1810 FIND v(dout0_138) AT=910.025n

.meas tran vdout0_139ck1810 FIND v(dout0_139) AT=910.025n

.meas tran vdout0_140ck1810 FIND v(dout0_140) AT=910.025n

.meas tran vdout0_141ck1810 FIND v(dout0_141) AT=910.025n

.meas tran vdout0_142ck1810 FIND v(dout0_142) AT=910.025n

.meas tran vdout0_143ck1810 FIND v(dout0_143) AT=910.025n

.meas tran vdout0_144ck1810 FIND v(dout0_144) AT=910.025n

.meas tran vdout0_145ck1810 FIND v(dout0_145) AT=910.025n

.meas tran vdout0_146ck1810 FIND v(dout0_146) AT=910.025n

.meas tran vdout0_147ck1810 FIND v(dout0_147) AT=910.025n

.meas tran vdout0_148ck1810 FIND v(dout0_148) AT=910.025n

.meas tran vdout0_149ck1810 FIND v(dout0_149) AT=910.025n

.meas tran vdout0_150ck1810 FIND v(dout0_150) AT=910.025n

.meas tran vdout0_151ck1810 FIND v(dout0_151) AT=910.025n

.meas tran vdout0_152ck1810 FIND v(dout0_152) AT=910.025n

.meas tran vdout0_153ck1810 FIND v(dout0_153) AT=910.025n

.meas tran vdout0_154ck1810 FIND v(dout0_154) AT=910.025n

.meas tran vdout0_155ck1810 FIND v(dout0_155) AT=910.025n

.meas tran vdout0_156ck1810 FIND v(dout0_156) AT=910.025n

.meas tran vdout0_157ck1810 FIND v(dout0_157) AT=910.025n

.meas tran vdout0_158ck1810 FIND v(dout0_158) AT=910.025n

.meas tran vdout0_159ck1810 FIND v(dout0_159) AT=910.025n

.meas tran vdout0_160ck1810 FIND v(dout0_160) AT=910.025n

.meas tran vdout0_161ck1810 FIND v(dout0_161) AT=910.025n

.meas tran vdout0_162ck1810 FIND v(dout0_162) AT=910.025n

.meas tran vdout0_163ck1810 FIND v(dout0_163) AT=910.025n

.meas tran vdout0_164ck1810 FIND v(dout0_164) AT=910.025n

.meas tran vdout0_165ck1810 FIND v(dout0_165) AT=910.025n

.meas tran vdout0_166ck1810 FIND v(dout0_166) AT=910.025n

.meas tran vdout0_167ck1810 FIND v(dout0_167) AT=910.025n

.meas tran vdout0_168ck1810 FIND v(dout0_168) AT=910.025n

.meas tran vdout0_169ck1810 FIND v(dout0_169) AT=910.025n

.meas tran vdout0_170ck1810 FIND v(dout0_170) AT=910.025n

.meas tran vdout0_171ck1810 FIND v(dout0_171) AT=910.025n

.meas tran vdout0_172ck1810 FIND v(dout0_172) AT=910.025n

.meas tran vdout0_173ck1810 FIND v(dout0_173) AT=910.025n

.meas tran vdout0_174ck1810 FIND v(dout0_174) AT=910.025n

.meas tran vdout0_175ck1810 FIND v(dout0_175) AT=910.025n

.meas tran vdout0_176ck1810 FIND v(dout0_176) AT=910.025n

.meas tran vdout0_177ck1810 FIND v(dout0_177) AT=910.025n

.meas tran vdout0_178ck1810 FIND v(dout0_178) AT=910.025n

.meas tran vdout0_179ck1810 FIND v(dout0_179) AT=910.025n

.meas tran vdout0_180ck1810 FIND v(dout0_180) AT=910.025n

.meas tran vdout0_181ck1810 FIND v(dout0_181) AT=910.025n

.meas tran vdout0_182ck1810 FIND v(dout0_182) AT=910.025n

.meas tran vdout0_183ck1810 FIND v(dout0_183) AT=910.025n

.meas tran vdout0_184ck1810 FIND v(dout0_184) AT=910.025n

.meas tran vdout0_185ck1810 FIND v(dout0_185) AT=910.025n

.meas tran vdout0_186ck1810 FIND v(dout0_186) AT=910.025n

.meas tran vdout0_187ck1810 FIND v(dout0_187) AT=910.025n

.meas tran vdout0_188ck1810 FIND v(dout0_188) AT=910.025n

.meas tran vdout0_189ck1810 FIND v(dout0_189) AT=910.025n

.meas tran vdout0_190ck1810 FIND v(dout0_190) AT=910.025n

.meas tran vdout0_191ck1810 FIND v(dout0_191) AT=910.025n

.meas tran vdout0_192ck1810 FIND v(dout0_192) AT=910.025n

.meas tran vdout0_193ck1810 FIND v(dout0_193) AT=910.025n

.meas tran vdout0_194ck1810 FIND v(dout0_194) AT=910.025n

.meas tran vdout0_195ck1810 FIND v(dout0_195) AT=910.025n

.meas tran vdout0_196ck1810 FIND v(dout0_196) AT=910.025n

.meas tran vdout0_197ck1810 FIND v(dout0_197) AT=910.025n

.meas tran vdout0_198ck1810 FIND v(dout0_198) AT=910.025n

.meas tran vdout0_199ck1810 FIND v(dout0_199) AT=910.025n

.meas tran vdout0_200ck1810 FIND v(dout0_200) AT=910.025n

.meas tran vdout0_201ck1810 FIND v(dout0_201) AT=910.025n

.meas tran vdout0_202ck1810 FIND v(dout0_202) AT=910.025n

.meas tran vdout0_203ck1810 FIND v(dout0_203) AT=910.025n

.meas tran vdout0_204ck1810 FIND v(dout0_204) AT=910.025n

.meas tran vdout0_205ck1810 FIND v(dout0_205) AT=910.025n

.meas tran vdout0_206ck1810 FIND v(dout0_206) AT=910.025n

.meas tran vdout0_207ck1810 FIND v(dout0_207) AT=910.025n

.meas tran vdout0_208ck1810 FIND v(dout0_208) AT=910.025n

.meas tran vdout0_209ck1810 FIND v(dout0_209) AT=910.025n

.meas tran vdout0_210ck1810 FIND v(dout0_210) AT=910.025n

.meas tran vdout0_211ck1810 FIND v(dout0_211) AT=910.025n

.meas tran vdout0_212ck1810 FIND v(dout0_212) AT=910.025n

.meas tran vdout0_213ck1810 FIND v(dout0_213) AT=910.025n

.meas tran vdout0_214ck1810 FIND v(dout0_214) AT=910.025n

.meas tran vdout0_215ck1810 FIND v(dout0_215) AT=910.025n

.meas tran vdout0_216ck1810 FIND v(dout0_216) AT=910.025n

.meas tran vdout0_217ck1810 FIND v(dout0_217) AT=910.025n

.meas tran vdout0_218ck1810 FIND v(dout0_218) AT=910.025n

.meas tran vdout0_219ck1810 FIND v(dout0_219) AT=910.025n

.meas tran vdout0_220ck1810 FIND v(dout0_220) AT=910.025n

.meas tran vdout0_221ck1810 FIND v(dout0_221) AT=910.025n

.meas tran vdout0_222ck1810 FIND v(dout0_222) AT=910.025n

.meas tran vdout0_223ck1810 FIND v(dout0_223) AT=910.025n

.meas tran vdout0_224ck1810 FIND v(dout0_224) AT=910.025n

.meas tran vdout0_225ck1810 FIND v(dout0_225) AT=910.025n

.meas tran vdout0_226ck1810 FIND v(dout0_226) AT=910.025n

.meas tran vdout0_227ck1810 FIND v(dout0_227) AT=910.025n

.meas tran vdout0_228ck1810 FIND v(dout0_228) AT=910.025n

.meas tran vdout0_229ck1810 FIND v(dout0_229) AT=910.025n

.meas tran vdout0_230ck1810 FIND v(dout0_230) AT=910.025n

.meas tran vdout0_231ck1810 FIND v(dout0_231) AT=910.025n

.meas tran vdout0_232ck1810 FIND v(dout0_232) AT=910.025n

.meas tran vdout0_233ck1810 FIND v(dout0_233) AT=910.025n

.meas tran vdout0_234ck1810 FIND v(dout0_234) AT=910.025n

.meas tran vdout0_235ck1810 FIND v(dout0_235) AT=910.025n

.meas tran vdout0_236ck1810 FIND v(dout0_236) AT=910.025n

.meas tran vdout0_237ck1810 FIND v(dout0_237) AT=910.025n

.meas tran vdout0_238ck1810 FIND v(dout0_238) AT=910.025n

.meas tran vdout0_239ck1810 FIND v(dout0_239) AT=910.025n

.meas tran vdout0_240ck1810 FIND v(dout0_240) AT=910.025n

.meas tran vdout0_241ck1810 FIND v(dout0_241) AT=910.025n

.meas tran vdout0_242ck1810 FIND v(dout0_242) AT=910.025n

.meas tran vdout0_243ck1810 FIND v(dout0_243) AT=910.025n

.meas tran vdout0_244ck1810 FIND v(dout0_244) AT=910.025n

.meas tran vdout0_245ck1810 FIND v(dout0_245) AT=910.025n

.meas tran vdout0_246ck1810 FIND v(dout0_246) AT=910.025n

.meas tran vdout0_247ck1810 FIND v(dout0_247) AT=910.025n

.meas tran vdout0_248ck1810 FIND v(dout0_248) AT=910.025n

.meas tran vdout0_249ck1810 FIND v(dout0_249) AT=910.025n

.meas tran vdout0_250ck1810 FIND v(dout0_250) AT=910.025n

.meas tran vdout0_251ck1810 FIND v(dout0_251) AT=910.025n

.meas tran vdout0_252ck1810 FIND v(dout0_252) AT=910.025n

.meas tran vdout0_253ck1810 FIND v(dout0_253) AT=910.025n

.meas tran vdout0_254ck1810 FIND v(dout0_254) AT=910.025n

.meas tran vdout0_255ck1810 FIND v(dout0_255) AT=910.025n

.meas tran vdout0_0ck1860 FIND v(dout0_0) AT=935.025n

.meas tran vdout0_1ck1860 FIND v(dout0_1) AT=935.025n

.meas tran vdout0_2ck1860 FIND v(dout0_2) AT=935.025n

.meas tran vdout0_3ck1860 FIND v(dout0_3) AT=935.025n

.meas tran vdout0_4ck1860 FIND v(dout0_4) AT=935.025n

.meas tran vdout0_5ck1860 FIND v(dout0_5) AT=935.025n

.meas tran vdout0_6ck1860 FIND v(dout0_6) AT=935.025n

.meas tran vdout0_7ck1860 FIND v(dout0_7) AT=935.025n

.meas tran vdout0_8ck1860 FIND v(dout0_8) AT=935.025n

.meas tran vdout0_9ck1860 FIND v(dout0_9) AT=935.025n

.meas tran vdout0_10ck1860 FIND v(dout0_10) AT=935.025n

.meas tran vdout0_11ck1860 FIND v(dout0_11) AT=935.025n

.meas tran vdout0_12ck1860 FIND v(dout0_12) AT=935.025n

.meas tran vdout0_13ck1860 FIND v(dout0_13) AT=935.025n

.meas tran vdout0_14ck1860 FIND v(dout0_14) AT=935.025n

.meas tran vdout0_15ck1860 FIND v(dout0_15) AT=935.025n

.meas tran vdout0_16ck1860 FIND v(dout0_16) AT=935.025n

.meas tran vdout0_17ck1860 FIND v(dout0_17) AT=935.025n

.meas tran vdout0_18ck1860 FIND v(dout0_18) AT=935.025n

.meas tran vdout0_19ck1860 FIND v(dout0_19) AT=935.025n

.meas tran vdout0_20ck1860 FIND v(dout0_20) AT=935.025n

.meas tran vdout0_21ck1860 FIND v(dout0_21) AT=935.025n

.meas tran vdout0_22ck1860 FIND v(dout0_22) AT=935.025n

.meas tran vdout0_23ck1860 FIND v(dout0_23) AT=935.025n

.meas tran vdout0_24ck1860 FIND v(dout0_24) AT=935.025n

.meas tran vdout0_25ck1860 FIND v(dout0_25) AT=935.025n

.meas tran vdout0_26ck1860 FIND v(dout0_26) AT=935.025n

.meas tran vdout0_27ck1860 FIND v(dout0_27) AT=935.025n

.meas tran vdout0_28ck1860 FIND v(dout0_28) AT=935.025n

.meas tran vdout0_29ck1860 FIND v(dout0_29) AT=935.025n

.meas tran vdout0_30ck1860 FIND v(dout0_30) AT=935.025n

.meas tran vdout0_31ck1860 FIND v(dout0_31) AT=935.025n

.meas tran vdout0_32ck1860 FIND v(dout0_32) AT=935.025n

.meas tran vdout0_33ck1860 FIND v(dout0_33) AT=935.025n

.meas tran vdout0_34ck1860 FIND v(dout0_34) AT=935.025n

.meas tran vdout0_35ck1860 FIND v(dout0_35) AT=935.025n

.meas tran vdout0_36ck1860 FIND v(dout0_36) AT=935.025n

.meas tran vdout0_37ck1860 FIND v(dout0_37) AT=935.025n

.meas tran vdout0_38ck1860 FIND v(dout0_38) AT=935.025n

.meas tran vdout0_39ck1860 FIND v(dout0_39) AT=935.025n

.meas tran vdout0_40ck1860 FIND v(dout0_40) AT=935.025n

.meas tran vdout0_41ck1860 FIND v(dout0_41) AT=935.025n

.meas tran vdout0_42ck1860 FIND v(dout0_42) AT=935.025n

.meas tran vdout0_43ck1860 FIND v(dout0_43) AT=935.025n

.meas tran vdout0_44ck1860 FIND v(dout0_44) AT=935.025n

.meas tran vdout0_45ck1860 FIND v(dout0_45) AT=935.025n

.meas tran vdout0_46ck1860 FIND v(dout0_46) AT=935.025n

.meas tran vdout0_47ck1860 FIND v(dout0_47) AT=935.025n

.meas tran vdout0_48ck1860 FIND v(dout0_48) AT=935.025n

.meas tran vdout0_49ck1860 FIND v(dout0_49) AT=935.025n

.meas tran vdout0_50ck1860 FIND v(dout0_50) AT=935.025n

.meas tran vdout0_51ck1860 FIND v(dout0_51) AT=935.025n

.meas tran vdout0_52ck1860 FIND v(dout0_52) AT=935.025n

.meas tran vdout0_53ck1860 FIND v(dout0_53) AT=935.025n

.meas tran vdout0_54ck1860 FIND v(dout0_54) AT=935.025n

.meas tran vdout0_55ck1860 FIND v(dout0_55) AT=935.025n

.meas tran vdout0_56ck1860 FIND v(dout0_56) AT=935.025n

.meas tran vdout0_57ck1860 FIND v(dout0_57) AT=935.025n

.meas tran vdout0_58ck1860 FIND v(dout0_58) AT=935.025n

.meas tran vdout0_59ck1860 FIND v(dout0_59) AT=935.025n

.meas tran vdout0_60ck1860 FIND v(dout0_60) AT=935.025n

.meas tran vdout0_61ck1860 FIND v(dout0_61) AT=935.025n

.meas tran vdout0_62ck1860 FIND v(dout0_62) AT=935.025n

.meas tran vdout0_63ck1860 FIND v(dout0_63) AT=935.025n

.meas tran vdout0_64ck1860 FIND v(dout0_64) AT=935.025n

.meas tran vdout0_65ck1860 FIND v(dout0_65) AT=935.025n

.meas tran vdout0_66ck1860 FIND v(dout0_66) AT=935.025n

.meas tran vdout0_67ck1860 FIND v(dout0_67) AT=935.025n

.meas tran vdout0_68ck1860 FIND v(dout0_68) AT=935.025n

.meas tran vdout0_69ck1860 FIND v(dout0_69) AT=935.025n

.meas tran vdout0_70ck1860 FIND v(dout0_70) AT=935.025n

.meas tran vdout0_71ck1860 FIND v(dout0_71) AT=935.025n

.meas tran vdout0_72ck1860 FIND v(dout0_72) AT=935.025n

.meas tran vdout0_73ck1860 FIND v(dout0_73) AT=935.025n

.meas tran vdout0_74ck1860 FIND v(dout0_74) AT=935.025n

.meas tran vdout0_75ck1860 FIND v(dout0_75) AT=935.025n

.meas tran vdout0_76ck1860 FIND v(dout0_76) AT=935.025n

.meas tran vdout0_77ck1860 FIND v(dout0_77) AT=935.025n

.meas tran vdout0_78ck1860 FIND v(dout0_78) AT=935.025n

.meas tran vdout0_79ck1860 FIND v(dout0_79) AT=935.025n

.meas tran vdout0_80ck1860 FIND v(dout0_80) AT=935.025n

.meas tran vdout0_81ck1860 FIND v(dout0_81) AT=935.025n

.meas tran vdout0_82ck1860 FIND v(dout0_82) AT=935.025n

.meas tran vdout0_83ck1860 FIND v(dout0_83) AT=935.025n

.meas tran vdout0_84ck1860 FIND v(dout0_84) AT=935.025n

.meas tran vdout0_85ck1860 FIND v(dout0_85) AT=935.025n

.meas tran vdout0_86ck1860 FIND v(dout0_86) AT=935.025n

.meas tran vdout0_87ck1860 FIND v(dout0_87) AT=935.025n

.meas tran vdout0_88ck1860 FIND v(dout0_88) AT=935.025n

.meas tran vdout0_89ck1860 FIND v(dout0_89) AT=935.025n

.meas tran vdout0_90ck1860 FIND v(dout0_90) AT=935.025n

.meas tran vdout0_91ck1860 FIND v(dout0_91) AT=935.025n

.meas tran vdout0_92ck1860 FIND v(dout0_92) AT=935.025n

.meas tran vdout0_93ck1860 FIND v(dout0_93) AT=935.025n

.meas tran vdout0_94ck1860 FIND v(dout0_94) AT=935.025n

.meas tran vdout0_95ck1860 FIND v(dout0_95) AT=935.025n

.meas tran vdout0_96ck1860 FIND v(dout0_96) AT=935.025n

.meas tran vdout0_97ck1860 FIND v(dout0_97) AT=935.025n

.meas tran vdout0_98ck1860 FIND v(dout0_98) AT=935.025n

.meas tran vdout0_99ck1860 FIND v(dout0_99) AT=935.025n

.meas tran vdout0_100ck1860 FIND v(dout0_100) AT=935.025n

.meas tran vdout0_101ck1860 FIND v(dout0_101) AT=935.025n

.meas tran vdout0_102ck1860 FIND v(dout0_102) AT=935.025n

.meas tran vdout0_103ck1860 FIND v(dout0_103) AT=935.025n

.meas tran vdout0_104ck1860 FIND v(dout0_104) AT=935.025n

.meas tran vdout0_105ck1860 FIND v(dout0_105) AT=935.025n

.meas tran vdout0_106ck1860 FIND v(dout0_106) AT=935.025n

.meas tran vdout0_107ck1860 FIND v(dout0_107) AT=935.025n

.meas tran vdout0_108ck1860 FIND v(dout0_108) AT=935.025n

.meas tran vdout0_109ck1860 FIND v(dout0_109) AT=935.025n

.meas tran vdout0_110ck1860 FIND v(dout0_110) AT=935.025n

.meas tran vdout0_111ck1860 FIND v(dout0_111) AT=935.025n

.meas tran vdout0_112ck1860 FIND v(dout0_112) AT=935.025n

.meas tran vdout0_113ck1860 FIND v(dout0_113) AT=935.025n

.meas tran vdout0_114ck1860 FIND v(dout0_114) AT=935.025n

.meas tran vdout0_115ck1860 FIND v(dout0_115) AT=935.025n

.meas tran vdout0_116ck1860 FIND v(dout0_116) AT=935.025n

.meas tran vdout0_117ck1860 FIND v(dout0_117) AT=935.025n

.meas tran vdout0_118ck1860 FIND v(dout0_118) AT=935.025n

.meas tran vdout0_119ck1860 FIND v(dout0_119) AT=935.025n

.meas tran vdout0_120ck1860 FIND v(dout0_120) AT=935.025n

.meas tran vdout0_121ck1860 FIND v(dout0_121) AT=935.025n

.meas tran vdout0_122ck1860 FIND v(dout0_122) AT=935.025n

.meas tran vdout0_123ck1860 FIND v(dout0_123) AT=935.025n

.meas tran vdout0_124ck1860 FIND v(dout0_124) AT=935.025n

.meas tran vdout0_125ck1860 FIND v(dout0_125) AT=935.025n

.meas tran vdout0_126ck1860 FIND v(dout0_126) AT=935.025n

.meas tran vdout0_127ck1860 FIND v(dout0_127) AT=935.025n

.meas tran vdout0_128ck1860 FIND v(dout0_128) AT=935.025n

.meas tran vdout0_129ck1860 FIND v(dout0_129) AT=935.025n

.meas tran vdout0_130ck1860 FIND v(dout0_130) AT=935.025n

.meas tran vdout0_131ck1860 FIND v(dout0_131) AT=935.025n

.meas tran vdout0_132ck1860 FIND v(dout0_132) AT=935.025n

.meas tran vdout0_133ck1860 FIND v(dout0_133) AT=935.025n

.meas tran vdout0_134ck1860 FIND v(dout0_134) AT=935.025n

.meas tran vdout0_135ck1860 FIND v(dout0_135) AT=935.025n

.meas tran vdout0_136ck1860 FIND v(dout0_136) AT=935.025n

.meas tran vdout0_137ck1860 FIND v(dout0_137) AT=935.025n

.meas tran vdout0_138ck1860 FIND v(dout0_138) AT=935.025n

.meas tran vdout0_139ck1860 FIND v(dout0_139) AT=935.025n

.meas tran vdout0_140ck1860 FIND v(dout0_140) AT=935.025n

.meas tran vdout0_141ck1860 FIND v(dout0_141) AT=935.025n

.meas tran vdout0_142ck1860 FIND v(dout0_142) AT=935.025n

.meas tran vdout0_143ck1860 FIND v(dout0_143) AT=935.025n

.meas tran vdout0_144ck1860 FIND v(dout0_144) AT=935.025n

.meas tran vdout0_145ck1860 FIND v(dout0_145) AT=935.025n

.meas tran vdout0_146ck1860 FIND v(dout0_146) AT=935.025n

.meas tran vdout0_147ck1860 FIND v(dout0_147) AT=935.025n

.meas tran vdout0_148ck1860 FIND v(dout0_148) AT=935.025n

.meas tran vdout0_149ck1860 FIND v(dout0_149) AT=935.025n

.meas tran vdout0_150ck1860 FIND v(dout0_150) AT=935.025n

.meas tran vdout0_151ck1860 FIND v(dout0_151) AT=935.025n

.meas tran vdout0_152ck1860 FIND v(dout0_152) AT=935.025n

.meas tran vdout0_153ck1860 FIND v(dout0_153) AT=935.025n

.meas tran vdout0_154ck1860 FIND v(dout0_154) AT=935.025n

.meas tran vdout0_155ck1860 FIND v(dout0_155) AT=935.025n

.meas tran vdout0_156ck1860 FIND v(dout0_156) AT=935.025n

.meas tran vdout0_157ck1860 FIND v(dout0_157) AT=935.025n

.meas tran vdout0_158ck1860 FIND v(dout0_158) AT=935.025n

.meas tran vdout0_159ck1860 FIND v(dout0_159) AT=935.025n

.meas tran vdout0_160ck1860 FIND v(dout0_160) AT=935.025n

.meas tran vdout0_161ck1860 FIND v(dout0_161) AT=935.025n

.meas tran vdout0_162ck1860 FIND v(dout0_162) AT=935.025n

.meas tran vdout0_163ck1860 FIND v(dout0_163) AT=935.025n

.meas tran vdout0_164ck1860 FIND v(dout0_164) AT=935.025n

.meas tran vdout0_165ck1860 FIND v(dout0_165) AT=935.025n

.meas tran vdout0_166ck1860 FIND v(dout0_166) AT=935.025n

.meas tran vdout0_167ck1860 FIND v(dout0_167) AT=935.025n

.meas tran vdout0_168ck1860 FIND v(dout0_168) AT=935.025n

.meas tran vdout0_169ck1860 FIND v(dout0_169) AT=935.025n

.meas tran vdout0_170ck1860 FIND v(dout0_170) AT=935.025n

.meas tran vdout0_171ck1860 FIND v(dout0_171) AT=935.025n

.meas tran vdout0_172ck1860 FIND v(dout0_172) AT=935.025n

.meas tran vdout0_173ck1860 FIND v(dout0_173) AT=935.025n

.meas tran vdout0_174ck1860 FIND v(dout0_174) AT=935.025n

.meas tran vdout0_175ck1860 FIND v(dout0_175) AT=935.025n

.meas tran vdout0_176ck1860 FIND v(dout0_176) AT=935.025n

.meas tran vdout0_177ck1860 FIND v(dout0_177) AT=935.025n

.meas tran vdout0_178ck1860 FIND v(dout0_178) AT=935.025n

.meas tran vdout0_179ck1860 FIND v(dout0_179) AT=935.025n

.meas tran vdout0_180ck1860 FIND v(dout0_180) AT=935.025n

.meas tran vdout0_181ck1860 FIND v(dout0_181) AT=935.025n

.meas tran vdout0_182ck1860 FIND v(dout0_182) AT=935.025n

.meas tran vdout0_183ck1860 FIND v(dout0_183) AT=935.025n

.meas tran vdout0_184ck1860 FIND v(dout0_184) AT=935.025n

.meas tran vdout0_185ck1860 FIND v(dout0_185) AT=935.025n

.meas tran vdout0_186ck1860 FIND v(dout0_186) AT=935.025n

.meas tran vdout0_187ck1860 FIND v(dout0_187) AT=935.025n

.meas tran vdout0_188ck1860 FIND v(dout0_188) AT=935.025n

.meas tran vdout0_189ck1860 FIND v(dout0_189) AT=935.025n

.meas tran vdout0_190ck1860 FIND v(dout0_190) AT=935.025n

.meas tran vdout0_191ck1860 FIND v(dout0_191) AT=935.025n

.meas tran vdout0_192ck1860 FIND v(dout0_192) AT=935.025n

.meas tran vdout0_193ck1860 FIND v(dout0_193) AT=935.025n

.meas tran vdout0_194ck1860 FIND v(dout0_194) AT=935.025n

.meas tran vdout0_195ck1860 FIND v(dout0_195) AT=935.025n

.meas tran vdout0_196ck1860 FIND v(dout0_196) AT=935.025n

.meas tran vdout0_197ck1860 FIND v(dout0_197) AT=935.025n

.meas tran vdout0_198ck1860 FIND v(dout0_198) AT=935.025n

.meas tran vdout0_199ck1860 FIND v(dout0_199) AT=935.025n

.meas tran vdout0_200ck1860 FIND v(dout0_200) AT=935.025n

.meas tran vdout0_201ck1860 FIND v(dout0_201) AT=935.025n

.meas tran vdout0_202ck1860 FIND v(dout0_202) AT=935.025n

.meas tran vdout0_203ck1860 FIND v(dout0_203) AT=935.025n

.meas tran vdout0_204ck1860 FIND v(dout0_204) AT=935.025n

.meas tran vdout0_205ck1860 FIND v(dout0_205) AT=935.025n

.meas tran vdout0_206ck1860 FIND v(dout0_206) AT=935.025n

.meas tran vdout0_207ck1860 FIND v(dout0_207) AT=935.025n

.meas tran vdout0_208ck1860 FIND v(dout0_208) AT=935.025n

.meas tran vdout0_209ck1860 FIND v(dout0_209) AT=935.025n

.meas tran vdout0_210ck1860 FIND v(dout0_210) AT=935.025n

.meas tran vdout0_211ck1860 FIND v(dout0_211) AT=935.025n

.meas tran vdout0_212ck1860 FIND v(dout0_212) AT=935.025n

.meas tran vdout0_213ck1860 FIND v(dout0_213) AT=935.025n

.meas tran vdout0_214ck1860 FIND v(dout0_214) AT=935.025n

.meas tran vdout0_215ck1860 FIND v(dout0_215) AT=935.025n

.meas tran vdout0_216ck1860 FIND v(dout0_216) AT=935.025n

.meas tran vdout0_217ck1860 FIND v(dout0_217) AT=935.025n

.meas tran vdout0_218ck1860 FIND v(dout0_218) AT=935.025n

.meas tran vdout0_219ck1860 FIND v(dout0_219) AT=935.025n

.meas tran vdout0_220ck1860 FIND v(dout0_220) AT=935.025n

.meas tran vdout0_221ck1860 FIND v(dout0_221) AT=935.025n

.meas tran vdout0_222ck1860 FIND v(dout0_222) AT=935.025n

.meas tran vdout0_223ck1860 FIND v(dout0_223) AT=935.025n

.meas tran vdout0_224ck1860 FIND v(dout0_224) AT=935.025n

.meas tran vdout0_225ck1860 FIND v(dout0_225) AT=935.025n

.meas tran vdout0_226ck1860 FIND v(dout0_226) AT=935.025n

.meas tran vdout0_227ck1860 FIND v(dout0_227) AT=935.025n

.meas tran vdout0_228ck1860 FIND v(dout0_228) AT=935.025n

.meas tran vdout0_229ck1860 FIND v(dout0_229) AT=935.025n

.meas tran vdout0_230ck1860 FIND v(dout0_230) AT=935.025n

.meas tran vdout0_231ck1860 FIND v(dout0_231) AT=935.025n

.meas tran vdout0_232ck1860 FIND v(dout0_232) AT=935.025n

.meas tran vdout0_233ck1860 FIND v(dout0_233) AT=935.025n

.meas tran vdout0_234ck1860 FIND v(dout0_234) AT=935.025n

.meas tran vdout0_235ck1860 FIND v(dout0_235) AT=935.025n

.meas tran vdout0_236ck1860 FIND v(dout0_236) AT=935.025n

.meas tran vdout0_237ck1860 FIND v(dout0_237) AT=935.025n

.meas tran vdout0_238ck1860 FIND v(dout0_238) AT=935.025n

.meas tran vdout0_239ck1860 FIND v(dout0_239) AT=935.025n

.meas tran vdout0_240ck1860 FIND v(dout0_240) AT=935.025n

.meas tran vdout0_241ck1860 FIND v(dout0_241) AT=935.025n

.meas tran vdout0_242ck1860 FIND v(dout0_242) AT=935.025n

.meas tran vdout0_243ck1860 FIND v(dout0_243) AT=935.025n

.meas tran vdout0_244ck1860 FIND v(dout0_244) AT=935.025n

.meas tran vdout0_245ck1860 FIND v(dout0_245) AT=935.025n

.meas tran vdout0_246ck1860 FIND v(dout0_246) AT=935.025n

.meas tran vdout0_247ck1860 FIND v(dout0_247) AT=935.025n

.meas tran vdout0_248ck1860 FIND v(dout0_248) AT=935.025n

.meas tran vdout0_249ck1860 FIND v(dout0_249) AT=935.025n

.meas tran vdout0_250ck1860 FIND v(dout0_250) AT=935.025n

.meas tran vdout0_251ck1860 FIND v(dout0_251) AT=935.025n

.meas tran vdout0_252ck1860 FIND v(dout0_252) AT=935.025n

.meas tran vdout0_253ck1860 FIND v(dout0_253) AT=935.025n

.meas tran vdout0_254ck1860 FIND v(dout0_254) AT=935.025n

.meas tran vdout0_255ck1860 FIND v(dout0_255) AT=935.025n

.meas tran vdout0_0ck1890 FIND v(dout0_0) AT=950.025n

.meas tran vdout0_1ck1890 FIND v(dout0_1) AT=950.025n

.meas tran vdout0_2ck1890 FIND v(dout0_2) AT=950.025n

.meas tran vdout0_3ck1890 FIND v(dout0_3) AT=950.025n

.meas tran vdout0_4ck1890 FIND v(dout0_4) AT=950.025n

.meas tran vdout0_5ck1890 FIND v(dout0_5) AT=950.025n

.meas tran vdout0_6ck1890 FIND v(dout0_6) AT=950.025n

.meas tran vdout0_7ck1890 FIND v(dout0_7) AT=950.025n

.meas tran vdout0_8ck1890 FIND v(dout0_8) AT=950.025n

.meas tran vdout0_9ck1890 FIND v(dout0_9) AT=950.025n

.meas tran vdout0_10ck1890 FIND v(dout0_10) AT=950.025n

.meas tran vdout0_11ck1890 FIND v(dout0_11) AT=950.025n

.meas tran vdout0_12ck1890 FIND v(dout0_12) AT=950.025n

.meas tran vdout0_13ck1890 FIND v(dout0_13) AT=950.025n

.meas tran vdout0_14ck1890 FIND v(dout0_14) AT=950.025n

.meas tran vdout0_15ck1890 FIND v(dout0_15) AT=950.025n

.meas tran vdout0_16ck1890 FIND v(dout0_16) AT=950.025n

.meas tran vdout0_17ck1890 FIND v(dout0_17) AT=950.025n

.meas tran vdout0_18ck1890 FIND v(dout0_18) AT=950.025n

.meas tran vdout0_19ck1890 FIND v(dout0_19) AT=950.025n

.meas tran vdout0_20ck1890 FIND v(dout0_20) AT=950.025n

.meas tran vdout0_21ck1890 FIND v(dout0_21) AT=950.025n

.meas tran vdout0_22ck1890 FIND v(dout0_22) AT=950.025n

.meas tran vdout0_23ck1890 FIND v(dout0_23) AT=950.025n

.meas tran vdout0_24ck1890 FIND v(dout0_24) AT=950.025n

.meas tran vdout0_25ck1890 FIND v(dout0_25) AT=950.025n

.meas tran vdout0_26ck1890 FIND v(dout0_26) AT=950.025n

.meas tran vdout0_27ck1890 FIND v(dout0_27) AT=950.025n

.meas tran vdout0_28ck1890 FIND v(dout0_28) AT=950.025n

.meas tran vdout0_29ck1890 FIND v(dout0_29) AT=950.025n

.meas tran vdout0_30ck1890 FIND v(dout0_30) AT=950.025n

.meas tran vdout0_31ck1890 FIND v(dout0_31) AT=950.025n

.meas tran vdout0_32ck1890 FIND v(dout0_32) AT=950.025n

.meas tran vdout0_33ck1890 FIND v(dout0_33) AT=950.025n

.meas tran vdout0_34ck1890 FIND v(dout0_34) AT=950.025n

.meas tran vdout0_35ck1890 FIND v(dout0_35) AT=950.025n

.meas tran vdout0_36ck1890 FIND v(dout0_36) AT=950.025n

.meas tran vdout0_37ck1890 FIND v(dout0_37) AT=950.025n

.meas tran vdout0_38ck1890 FIND v(dout0_38) AT=950.025n

.meas tran vdout0_39ck1890 FIND v(dout0_39) AT=950.025n

.meas tran vdout0_40ck1890 FIND v(dout0_40) AT=950.025n

.meas tran vdout0_41ck1890 FIND v(dout0_41) AT=950.025n

.meas tran vdout0_42ck1890 FIND v(dout0_42) AT=950.025n

.meas tran vdout0_43ck1890 FIND v(dout0_43) AT=950.025n

.meas tran vdout0_44ck1890 FIND v(dout0_44) AT=950.025n

.meas tran vdout0_45ck1890 FIND v(dout0_45) AT=950.025n

.meas tran vdout0_46ck1890 FIND v(dout0_46) AT=950.025n

.meas tran vdout0_47ck1890 FIND v(dout0_47) AT=950.025n

.meas tran vdout0_48ck1890 FIND v(dout0_48) AT=950.025n

.meas tran vdout0_49ck1890 FIND v(dout0_49) AT=950.025n

.meas tran vdout0_50ck1890 FIND v(dout0_50) AT=950.025n

.meas tran vdout0_51ck1890 FIND v(dout0_51) AT=950.025n

.meas tran vdout0_52ck1890 FIND v(dout0_52) AT=950.025n

.meas tran vdout0_53ck1890 FIND v(dout0_53) AT=950.025n

.meas tran vdout0_54ck1890 FIND v(dout0_54) AT=950.025n

.meas tran vdout0_55ck1890 FIND v(dout0_55) AT=950.025n

.meas tran vdout0_56ck1890 FIND v(dout0_56) AT=950.025n

.meas tran vdout0_57ck1890 FIND v(dout0_57) AT=950.025n

.meas tran vdout0_58ck1890 FIND v(dout0_58) AT=950.025n

.meas tran vdout0_59ck1890 FIND v(dout0_59) AT=950.025n

.meas tran vdout0_60ck1890 FIND v(dout0_60) AT=950.025n

.meas tran vdout0_61ck1890 FIND v(dout0_61) AT=950.025n

.meas tran vdout0_62ck1890 FIND v(dout0_62) AT=950.025n

.meas tran vdout0_63ck1890 FIND v(dout0_63) AT=950.025n

.meas tran vdout0_64ck1890 FIND v(dout0_64) AT=950.025n

.meas tran vdout0_65ck1890 FIND v(dout0_65) AT=950.025n

.meas tran vdout0_66ck1890 FIND v(dout0_66) AT=950.025n

.meas tran vdout0_67ck1890 FIND v(dout0_67) AT=950.025n

.meas tran vdout0_68ck1890 FIND v(dout0_68) AT=950.025n

.meas tran vdout0_69ck1890 FIND v(dout0_69) AT=950.025n

.meas tran vdout0_70ck1890 FIND v(dout0_70) AT=950.025n

.meas tran vdout0_71ck1890 FIND v(dout0_71) AT=950.025n

.meas tran vdout0_72ck1890 FIND v(dout0_72) AT=950.025n

.meas tran vdout0_73ck1890 FIND v(dout0_73) AT=950.025n

.meas tran vdout0_74ck1890 FIND v(dout0_74) AT=950.025n

.meas tran vdout0_75ck1890 FIND v(dout0_75) AT=950.025n

.meas tran vdout0_76ck1890 FIND v(dout0_76) AT=950.025n

.meas tran vdout0_77ck1890 FIND v(dout0_77) AT=950.025n

.meas tran vdout0_78ck1890 FIND v(dout0_78) AT=950.025n

.meas tran vdout0_79ck1890 FIND v(dout0_79) AT=950.025n

.meas tran vdout0_80ck1890 FIND v(dout0_80) AT=950.025n

.meas tran vdout0_81ck1890 FIND v(dout0_81) AT=950.025n

.meas tran vdout0_82ck1890 FIND v(dout0_82) AT=950.025n

.meas tran vdout0_83ck1890 FIND v(dout0_83) AT=950.025n

.meas tran vdout0_84ck1890 FIND v(dout0_84) AT=950.025n

.meas tran vdout0_85ck1890 FIND v(dout0_85) AT=950.025n

.meas tran vdout0_86ck1890 FIND v(dout0_86) AT=950.025n

.meas tran vdout0_87ck1890 FIND v(dout0_87) AT=950.025n

.meas tran vdout0_88ck1890 FIND v(dout0_88) AT=950.025n

.meas tran vdout0_89ck1890 FIND v(dout0_89) AT=950.025n

.meas tran vdout0_90ck1890 FIND v(dout0_90) AT=950.025n

.meas tran vdout0_91ck1890 FIND v(dout0_91) AT=950.025n

.meas tran vdout0_92ck1890 FIND v(dout0_92) AT=950.025n

.meas tran vdout0_93ck1890 FIND v(dout0_93) AT=950.025n

.meas tran vdout0_94ck1890 FIND v(dout0_94) AT=950.025n

.meas tran vdout0_95ck1890 FIND v(dout0_95) AT=950.025n

.meas tran vdout0_96ck1890 FIND v(dout0_96) AT=950.025n

.meas tran vdout0_97ck1890 FIND v(dout0_97) AT=950.025n

.meas tran vdout0_98ck1890 FIND v(dout0_98) AT=950.025n

.meas tran vdout0_99ck1890 FIND v(dout0_99) AT=950.025n

.meas tran vdout0_100ck1890 FIND v(dout0_100) AT=950.025n

.meas tran vdout0_101ck1890 FIND v(dout0_101) AT=950.025n

.meas tran vdout0_102ck1890 FIND v(dout0_102) AT=950.025n

.meas tran vdout0_103ck1890 FIND v(dout0_103) AT=950.025n

.meas tran vdout0_104ck1890 FIND v(dout0_104) AT=950.025n

.meas tran vdout0_105ck1890 FIND v(dout0_105) AT=950.025n

.meas tran vdout0_106ck1890 FIND v(dout0_106) AT=950.025n

.meas tran vdout0_107ck1890 FIND v(dout0_107) AT=950.025n

.meas tran vdout0_108ck1890 FIND v(dout0_108) AT=950.025n

.meas tran vdout0_109ck1890 FIND v(dout0_109) AT=950.025n

.meas tran vdout0_110ck1890 FIND v(dout0_110) AT=950.025n

.meas tran vdout0_111ck1890 FIND v(dout0_111) AT=950.025n

.meas tran vdout0_112ck1890 FIND v(dout0_112) AT=950.025n

.meas tran vdout0_113ck1890 FIND v(dout0_113) AT=950.025n

.meas tran vdout0_114ck1890 FIND v(dout0_114) AT=950.025n

.meas tran vdout0_115ck1890 FIND v(dout0_115) AT=950.025n

.meas tran vdout0_116ck1890 FIND v(dout0_116) AT=950.025n

.meas tran vdout0_117ck1890 FIND v(dout0_117) AT=950.025n

.meas tran vdout0_118ck1890 FIND v(dout0_118) AT=950.025n

.meas tran vdout0_119ck1890 FIND v(dout0_119) AT=950.025n

.meas tran vdout0_120ck1890 FIND v(dout0_120) AT=950.025n

.meas tran vdout0_121ck1890 FIND v(dout0_121) AT=950.025n

.meas tran vdout0_122ck1890 FIND v(dout0_122) AT=950.025n

.meas tran vdout0_123ck1890 FIND v(dout0_123) AT=950.025n

.meas tran vdout0_124ck1890 FIND v(dout0_124) AT=950.025n

.meas tran vdout0_125ck1890 FIND v(dout0_125) AT=950.025n

.meas tran vdout0_126ck1890 FIND v(dout0_126) AT=950.025n

.meas tran vdout0_127ck1890 FIND v(dout0_127) AT=950.025n

.meas tran vdout0_128ck1890 FIND v(dout0_128) AT=950.025n

.meas tran vdout0_129ck1890 FIND v(dout0_129) AT=950.025n

.meas tran vdout0_130ck1890 FIND v(dout0_130) AT=950.025n

.meas tran vdout0_131ck1890 FIND v(dout0_131) AT=950.025n

.meas tran vdout0_132ck1890 FIND v(dout0_132) AT=950.025n

.meas tran vdout0_133ck1890 FIND v(dout0_133) AT=950.025n

.meas tran vdout0_134ck1890 FIND v(dout0_134) AT=950.025n

.meas tran vdout0_135ck1890 FIND v(dout0_135) AT=950.025n

.meas tran vdout0_136ck1890 FIND v(dout0_136) AT=950.025n

.meas tran vdout0_137ck1890 FIND v(dout0_137) AT=950.025n

.meas tran vdout0_138ck1890 FIND v(dout0_138) AT=950.025n

.meas tran vdout0_139ck1890 FIND v(dout0_139) AT=950.025n

.meas tran vdout0_140ck1890 FIND v(dout0_140) AT=950.025n

.meas tran vdout0_141ck1890 FIND v(dout0_141) AT=950.025n

.meas tran vdout0_142ck1890 FIND v(dout0_142) AT=950.025n

.meas tran vdout0_143ck1890 FIND v(dout0_143) AT=950.025n

.meas tran vdout0_144ck1890 FIND v(dout0_144) AT=950.025n

.meas tran vdout0_145ck1890 FIND v(dout0_145) AT=950.025n

.meas tran vdout0_146ck1890 FIND v(dout0_146) AT=950.025n

.meas tran vdout0_147ck1890 FIND v(dout0_147) AT=950.025n

.meas tran vdout0_148ck1890 FIND v(dout0_148) AT=950.025n

.meas tran vdout0_149ck1890 FIND v(dout0_149) AT=950.025n

.meas tran vdout0_150ck1890 FIND v(dout0_150) AT=950.025n

.meas tran vdout0_151ck1890 FIND v(dout0_151) AT=950.025n

.meas tran vdout0_152ck1890 FIND v(dout0_152) AT=950.025n

.meas tran vdout0_153ck1890 FIND v(dout0_153) AT=950.025n

.meas tran vdout0_154ck1890 FIND v(dout0_154) AT=950.025n

.meas tran vdout0_155ck1890 FIND v(dout0_155) AT=950.025n

.meas tran vdout0_156ck1890 FIND v(dout0_156) AT=950.025n

.meas tran vdout0_157ck1890 FIND v(dout0_157) AT=950.025n

.meas tran vdout0_158ck1890 FIND v(dout0_158) AT=950.025n

.meas tran vdout0_159ck1890 FIND v(dout0_159) AT=950.025n

.meas tran vdout0_160ck1890 FIND v(dout0_160) AT=950.025n

.meas tran vdout0_161ck1890 FIND v(dout0_161) AT=950.025n

.meas tran vdout0_162ck1890 FIND v(dout0_162) AT=950.025n

.meas tran vdout0_163ck1890 FIND v(dout0_163) AT=950.025n

.meas tran vdout0_164ck1890 FIND v(dout0_164) AT=950.025n

.meas tran vdout0_165ck1890 FIND v(dout0_165) AT=950.025n

.meas tran vdout0_166ck1890 FIND v(dout0_166) AT=950.025n

.meas tran vdout0_167ck1890 FIND v(dout0_167) AT=950.025n

.meas tran vdout0_168ck1890 FIND v(dout0_168) AT=950.025n

.meas tran vdout0_169ck1890 FIND v(dout0_169) AT=950.025n

.meas tran vdout0_170ck1890 FIND v(dout0_170) AT=950.025n

.meas tran vdout0_171ck1890 FIND v(dout0_171) AT=950.025n

.meas tran vdout0_172ck1890 FIND v(dout0_172) AT=950.025n

.meas tran vdout0_173ck1890 FIND v(dout0_173) AT=950.025n

.meas tran vdout0_174ck1890 FIND v(dout0_174) AT=950.025n

.meas tran vdout0_175ck1890 FIND v(dout0_175) AT=950.025n

.meas tran vdout0_176ck1890 FIND v(dout0_176) AT=950.025n

.meas tran vdout0_177ck1890 FIND v(dout0_177) AT=950.025n

.meas tran vdout0_178ck1890 FIND v(dout0_178) AT=950.025n

.meas tran vdout0_179ck1890 FIND v(dout0_179) AT=950.025n

.meas tran vdout0_180ck1890 FIND v(dout0_180) AT=950.025n

.meas tran vdout0_181ck1890 FIND v(dout0_181) AT=950.025n

.meas tran vdout0_182ck1890 FIND v(dout0_182) AT=950.025n

.meas tran vdout0_183ck1890 FIND v(dout0_183) AT=950.025n

.meas tran vdout0_184ck1890 FIND v(dout0_184) AT=950.025n

.meas tran vdout0_185ck1890 FIND v(dout0_185) AT=950.025n

.meas tran vdout0_186ck1890 FIND v(dout0_186) AT=950.025n

.meas tran vdout0_187ck1890 FIND v(dout0_187) AT=950.025n

.meas tran vdout0_188ck1890 FIND v(dout0_188) AT=950.025n

.meas tran vdout0_189ck1890 FIND v(dout0_189) AT=950.025n

.meas tran vdout0_190ck1890 FIND v(dout0_190) AT=950.025n

.meas tran vdout0_191ck1890 FIND v(dout0_191) AT=950.025n

.meas tran vdout0_192ck1890 FIND v(dout0_192) AT=950.025n

.meas tran vdout0_193ck1890 FIND v(dout0_193) AT=950.025n

.meas tran vdout0_194ck1890 FIND v(dout0_194) AT=950.025n

.meas tran vdout0_195ck1890 FIND v(dout0_195) AT=950.025n

.meas tran vdout0_196ck1890 FIND v(dout0_196) AT=950.025n

.meas tran vdout0_197ck1890 FIND v(dout0_197) AT=950.025n

.meas tran vdout0_198ck1890 FIND v(dout0_198) AT=950.025n

.meas tran vdout0_199ck1890 FIND v(dout0_199) AT=950.025n

.meas tran vdout0_200ck1890 FIND v(dout0_200) AT=950.025n

.meas tran vdout0_201ck1890 FIND v(dout0_201) AT=950.025n

.meas tran vdout0_202ck1890 FIND v(dout0_202) AT=950.025n

.meas tran vdout0_203ck1890 FIND v(dout0_203) AT=950.025n

.meas tran vdout0_204ck1890 FIND v(dout0_204) AT=950.025n

.meas tran vdout0_205ck1890 FIND v(dout0_205) AT=950.025n

.meas tran vdout0_206ck1890 FIND v(dout0_206) AT=950.025n

.meas tran vdout0_207ck1890 FIND v(dout0_207) AT=950.025n

.meas tran vdout0_208ck1890 FIND v(dout0_208) AT=950.025n

.meas tran vdout0_209ck1890 FIND v(dout0_209) AT=950.025n

.meas tran vdout0_210ck1890 FIND v(dout0_210) AT=950.025n

.meas tran vdout0_211ck1890 FIND v(dout0_211) AT=950.025n

.meas tran vdout0_212ck1890 FIND v(dout0_212) AT=950.025n

.meas tran vdout0_213ck1890 FIND v(dout0_213) AT=950.025n

.meas tran vdout0_214ck1890 FIND v(dout0_214) AT=950.025n

.meas tran vdout0_215ck1890 FIND v(dout0_215) AT=950.025n

.meas tran vdout0_216ck1890 FIND v(dout0_216) AT=950.025n

.meas tran vdout0_217ck1890 FIND v(dout0_217) AT=950.025n

.meas tran vdout0_218ck1890 FIND v(dout0_218) AT=950.025n

.meas tran vdout0_219ck1890 FIND v(dout0_219) AT=950.025n

.meas tran vdout0_220ck1890 FIND v(dout0_220) AT=950.025n

.meas tran vdout0_221ck1890 FIND v(dout0_221) AT=950.025n

.meas tran vdout0_222ck1890 FIND v(dout0_222) AT=950.025n

.meas tran vdout0_223ck1890 FIND v(dout0_223) AT=950.025n

.meas tran vdout0_224ck1890 FIND v(dout0_224) AT=950.025n

.meas tran vdout0_225ck1890 FIND v(dout0_225) AT=950.025n

.meas tran vdout0_226ck1890 FIND v(dout0_226) AT=950.025n

.meas tran vdout0_227ck1890 FIND v(dout0_227) AT=950.025n

.meas tran vdout0_228ck1890 FIND v(dout0_228) AT=950.025n

.meas tran vdout0_229ck1890 FIND v(dout0_229) AT=950.025n

.meas tran vdout0_230ck1890 FIND v(dout0_230) AT=950.025n

.meas tran vdout0_231ck1890 FIND v(dout0_231) AT=950.025n

.meas tran vdout0_232ck1890 FIND v(dout0_232) AT=950.025n

.meas tran vdout0_233ck1890 FIND v(dout0_233) AT=950.025n

.meas tran vdout0_234ck1890 FIND v(dout0_234) AT=950.025n

.meas tran vdout0_235ck1890 FIND v(dout0_235) AT=950.025n

.meas tran vdout0_236ck1890 FIND v(dout0_236) AT=950.025n

.meas tran vdout0_237ck1890 FIND v(dout0_237) AT=950.025n

.meas tran vdout0_238ck1890 FIND v(dout0_238) AT=950.025n

.meas tran vdout0_239ck1890 FIND v(dout0_239) AT=950.025n

.meas tran vdout0_240ck1890 FIND v(dout0_240) AT=950.025n

.meas tran vdout0_241ck1890 FIND v(dout0_241) AT=950.025n

.meas tran vdout0_242ck1890 FIND v(dout0_242) AT=950.025n

.meas tran vdout0_243ck1890 FIND v(dout0_243) AT=950.025n

.meas tran vdout0_244ck1890 FIND v(dout0_244) AT=950.025n

.meas tran vdout0_245ck1890 FIND v(dout0_245) AT=950.025n

.meas tran vdout0_246ck1890 FIND v(dout0_246) AT=950.025n

.meas tran vdout0_247ck1890 FIND v(dout0_247) AT=950.025n

.meas tran vdout0_248ck1890 FIND v(dout0_248) AT=950.025n

.meas tran vdout0_249ck1890 FIND v(dout0_249) AT=950.025n

.meas tran vdout0_250ck1890 FIND v(dout0_250) AT=950.025n

.meas tran vdout0_251ck1890 FIND v(dout0_251) AT=950.025n

.meas tran vdout0_252ck1890 FIND v(dout0_252) AT=950.025n

.meas tran vdout0_253ck1890 FIND v(dout0_253) AT=950.025n

.meas tran vdout0_254ck1890 FIND v(dout0_254) AT=950.025n

.meas tran vdout0_255ck1890 FIND v(dout0_255) AT=950.025n

.meas tran vdout0_0ck1900 FIND v(dout0_0) AT=955.025n

.meas tran vdout0_1ck1900 FIND v(dout0_1) AT=955.025n

.meas tran vdout0_2ck1900 FIND v(dout0_2) AT=955.025n

.meas tran vdout0_3ck1900 FIND v(dout0_3) AT=955.025n

.meas tran vdout0_4ck1900 FIND v(dout0_4) AT=955.025n

.meas tran vdout0_5ck1900 FIND v(dout0_5) AT=955.025n

.meas tran vdout0_6ck1900 FIND v(dout0_6) AT=955.025n

.meas tran vdout0_7ck1900 FIND v(dout0_7) AT=955.025n

.meas tran vdout0_8ck1900 FIND v(dout0_8) AT=955.025n

.meas tran vdout0_9ck1900 FIND v(dout0_9) AT=955.025n

.meas tran vdout0_10ck1900 FIND v(dout0_10) AT=955.025n

.meas tran vdout0_11ck1900 FIND v(dout0_11) AT=955.025n

.meas tran vdout0_12ck1900 FIND v(dout0_12) AT=955.025n

.meas tran vdout0_13ck1900 FIND v(dout0_13) AT=955.025n

.meas tran vdout0_14ck1900 FIND v(dout0_14) AT=955.025n

.meas tran vdout0_15ck1900 FIND v(dout0_15) AT=955.025n

.meas tran vdout0_16ck1900 FIND v(dout0_16) AT=955.025n

.meas tran vdout0_17ck1900 FIND v(dout0_17) AT=955.025n

.meas tran vdout0_18ck1900 FIND v(dout0_18) AT=955.025n

.meas tran vdout0_19ck1900 FIND v(dout0_19) AT=955.025n

.meas tran vdout0_20ck1900 FIND v(dout0_20) AT=955.025n

.meas tran vdout0_21ck1900 FIND v(dout0_21) AT=955.025n

.meas tran vdout0_22ck1900 FIND v(dout0_22) AT=955.025n

.meas tran vdout0_23ck1900 FIND v(dout0_23) AT=955.025n

.meas tran vdout0_24ck1900 FIND v(dout0_24) AT=955.025n

.meas tran vdout0_25ck1900 FIND v(dout0_25) AT=955.025n

.meas tran vdout0_26ck1900 FIND v(dout0_26) AT=955.025n

.meas tran vdout0_27ck1900 FIND v(dout0_27) AT=955.025n

.meas tran vdout0_28ck1900 FIND v(dout0_28) AT=955.025n

.meas tran vdout0_29ck1900 FIND v(dout0_29) AT=955.025n

.meas tran vdout0_30ck1900 FIND v(dout0_30) AT=955.025n

.meas tran vdout0_31ck1900 FIND v(dout0_31) AT=955.025n

.meas tran vdout0_32ck1900 FIND v(dout0_32) AT=955.025n

.meas tran vdout0_33ck1900 FIND v(dout0_33) AT=955.025n

.meas tran vdout0_34ck1900 FIND v(dout0_34) AT=955.025n

.meas tran vdout0_35ck1900 FIND v(dout0_35) AT=955.025n

.meas tran vdout0_36ck1900 FIND v(dout0_36) AT=955.025n

.meas tran vdout0_37ck1900 FIND v(dout0_37) AT=955.025n

.meas tran vdout0_38ck1900 FIND v(dout0_38) AT=955.025n

.meas tran vdout0_39ck1900 FIND v(dout0_39) AT=955.025n

.meas tran vdout0_40ck1900 FIND v(dout0_40) AT=955.025n

.meas tran vdout0_41ck1900 FIND v(dout0_41) AT=955.025n

.meas tran vdout0_42ck1900 FIND v(dout0_42) AT=955.025n

.meas tran vdout0_43ck1900 FIND v(dout0_43) AT=955.025n

.meas tran vdout0_44ck1900 FIND v(dout0_44) AT=955.025n

.meas tran vdout0_45ck1900 FIND v(dout0_45) AT=955.025n

.meas tran vdout0_46ck1900 FIND v(dout0_46) AT=955.025n

.meas tran vdout0_47ck1900 FIND v(dout0_47) AT=955.025n

.meas tran vdout0_48ck1900 FIND v(dout0_48) AT=955.025n

.meas tran vdout0_49ck1900 FIND v(dout0_49) AT=955.025n

.meas tran vdout0_50ck1900 FIND v(dout0_50) AT=955.025n

.meas tran vdout0_51ck1900 FIND v(dout0_51) AT=955.025n

.meas tran vdout0_52ck1900 FIND v(dout0_52) AT=955.025n

.meas tran vdout0_53ck1900 FIND v(dout0_53) AT=955.025n

.meas tran vdout0_54ck1900 FIND v(dout0_54) AT=955.025n

.meas tran vdout0_55ck1900 FIND v(dout0_55) AT=955.025n

.meas tran vdout0_56ck1900 FIND v(dout0_56) AT=955.025n

.meas tran vdout0_57ck1900 FIND v(dout0_57) AT=955.025n

.meas tran vdout0_58ck1900 FIND v(dout0_58) AT=955.025n

.meas tran vdout0_59ck1900 FIND v(dout0_59) AT=955.025n

.meas tran vdout0_60ck1900 FIND v(dout0_60) AT=955.025n

.meas tran vdout0_61ck1900 FIND v(dout0_61) AT=955.025n

.meas tran vdout0_62ck1900 FIND v(dout0_62) AT=955.025n

.meas tran vdout0_63ck1900 FIND v(dout0_63) AT=955.025n

.meas tran vdout0_64ck1900 FIND v(dout0_64) AT=955.025n

.meas tran vdout0_65ck1900 FIND v(dout0_65) AT=955.025n

.meas tran vdout0_66ck1900 FIND v(dout0_66) AT=955.025n

.meas tran vdout0_67ck1900 FIND v(dout0_67) AT=955.025n

.meas tran vdout0_68ck1900 FIND v(dout0_68) AT=955.025n

.meas tran vdout0_69ck1900 FIND v(dout0_69) AT=955.025n

.meas tran vdout0_70ck1900 FIND v(dout0_70) AT=955.025n

.meas tran vdout0_71ck1900 FIND v(dout0_71) AT=955.025n

.meas tran vdout0_72ck1900 FIND v(dout0_72) AT=955.025n

.meas tran vdout0_73ck1900 FIND v(dout0_73) AT=955.025n

.meas tran vdout0_74ck1900 FIND v(dout0_74) AT=955.025n

.meas tran vdout0_75ck1900 FIND v(dout0_75) AT=955.025n

.meas tran vdout0_76ck1900 FIND v(dout0_76) AT=955.025n

.meas tran vdout0_77ck1900 FIND v(dout0_77) AT=955.025n

.meas tran vdout0_78ck1900 FIND v(dout0_78) AT=955.025n

.meas tran vdout0_79ck1900 FIND v(dout0_79) AT=955.025n

.meas tran vdout0_80ck1900 FIND v(dout0_80) AT=955.025n

.meas tran vdout0_81ck1900 FIND v(dout0_81) AT=955.025n

.meas tran vdout0_82ck1900 FIND v(dout0_82) AT=955.025n

.meas tran vdout0_83ck1900 FIND v(dout0_83) AT=955.025n

.meas tran vdout0_84ck1900 FIND v(dout0_84) AT=955.025n

.meas tran vdout0_85ck1900 FIND v(dout0_85) AT=955.025n

.meas tran vdout0_86ck1900 FIND v(dout0_86) AT=955.025n

.meas tran vdout0_87ck1900 FIND v(dout0_87) AT=955.025n

.meas tran vdout0_88ck1900 FIND v(dout0_88) AT=955.025n

.meas tran vdout0_89ck1900 FIND v(dout0_89) AT=955.025n

.meas tran vdout0_90ck1900 FIND v(dout0_90) AT=955.025n

.meas tran vdout0_91ck1900 FIND v(dout0_91) AT=955.025n

.meas tran vdout0_92ck1900 FIND v(dout0_92) AT=955.025n

.meas tran vdout0_93ck1900 FIND v(dout0_93) AT=955.025n

.meas tran vdout0_94ck1900 FIND v(dout0_94) AT=955.025n

.meas tran vdout0_95ck1900 FIND v(dout0_95) AT=955.025n

.meas tran vdout0_96ck1900 FIND v(dout0_96) AT=955.025n

.meas tran vdout0_97ck1900 FIND v(dout0_97) AT=955.025n

.meas tran vdout0_98ck1900 FIND v(dout0_98) AT=955.025n

.meas tran vdout0_99ck1900 FIND v(dout0_99) AT=955.025n

.meas tran vdout0_100ck1900 FIND v(dout0_100) AT=955.025n

.meas tran vdout0_101ck1900 FIND v(dout0_101) AT=955.025n

.meas tran vdout0_102ck1900 FIND v(dout0_102) AT=955.025n

.meas tran vdout0_103ck1900 FIND v(dout0_103) AT=955.025n

.meas tran vdout0_104ck1900 FIND v(dout0_104) AT=955.025n

.meas tran vdout0_105ck1900 FIND v(dout0_105) AT=955.025n

.meas tran vdout0_106ck1900 FIND v(dout0_106) AT=955.025n

.meas tran vdout0_107ck1900 FIND v(dout0_107) AT=955.025n

.meas tran vdout0_108ck1900 FIND v(dout0_108) AT=955.025n

.meas tran vdout0_109ck1900 FIND v(dout0_109) AT=955.025n

.meas tran vdout0_110ck1900 FIND v(dout0_110) AT=955.025n

.meas tran vdout0_111ck1900 FIND v(dout0_111) AT=955.025n

.meas tran vdout0_112ck1900 FIND v(dout0_112) AT=955.025n

.meas tran vdout0_113ck1900 FIND v(dout0_113) AT=955.025n

.meas tran vdout0_114ck1900 FIND v(dout0_114) AT=955.025n

.meas tran vdout0_115ck1900 FIND v(dout0_115) AT=955.025n

.meas tran vdout0_116ck1900 FIND v(dout0_116) AT=955.025n

.meas tran vdout0_117ck1900 FIND v(dout0_117) AT=955.025n

.meas tran vdout0_118ck1900 FIND v(dout0_118) AT=955.025n

.meas tran vdout0_119ck1900 FIND v(dout0_119) AT=955.025n

.meas tran vdout0_120ck1900 FIND v(dout0_120) AT=955.025n

.meas tran vdout0_121ck1900 FIND v(dout0_121) AT=955.025n

.meas tran vdout0_122ck1900 FIND v(dout0_122) AT=955.025n

.meas tran vdout0_123ck1900 FIND v(dout0_123) AT=955.025n

.meas tran vdout0_124ck1900 FIND v(dout0_124) AT=955.025n

.meas tran vdout0_125ck1900 FIND v(dout0_125) AT=955.025n

.meas tran vdout0_126ck1900 FIND v(dout0_126) AT=955.025n

.meas tran vdout0_127ck1900 FIND v(dout0_127) AT=955.025n

.meas tran vdout0_128ck1900 FIND v(dout0_128) AT=955.025n

.meas tran vdout0_129ck1900 FIND v(dout0_129) AT=955.025n

.meas tran vdout0_130ck1900 FIND v(dout0_130) AT=955.025n

.meas tran vdout0_131ck1900 FIND v(dout0_131) AT=955.025n

.meas tran vdout0_132ck1900 FIND v(dout0_132) AT=955.025n

.meas tran vdout0_133ck1900 FIND v(dout0_133) AT=955.025n

.meas tran vdout0_134ck1900 FIND v(dout0_134) AT=955.025n

.meas tran vdout0_135ck1900 FIND v(dout0_135) AT=955.025n

.meas tran vdout0_136ck1900 FIND v(dout0_136) AT=955.025n

.meas tran vdout0_137ck1900 FIND v(dout0_137) AT=955.025n

.meas tran vdout0_138ck1900 FIND v(dout0_138) AT=955.025n

.meas tran vdout0_139ck1900 FIND v(dout0_139) AT=955.025n

.meas tran vdout0_140ck1900 FIND v(dout0_140) AT=955.025n

.meas tran vdout0_141ck1900 FIND v(dout0_141) AT=955.025n

.meas tran vdout0_142ck1900 FIND v(dout0_142) AT=955.025n

.meas tran vdout0_143ck1900 FIND v(dout0_143) AT=955.025n

.meas tran vdout0_144ck1900 FIND v(dout0_144) AT=955.025n

.meas tran vdout0_145ck1900 FIND v(dout0_145) AT=955.025n

.meas tran vdout0_146ck1900 FIND v(dout0_146) AT=955.025n

.meas tran vdout0_147ck1900 FIND v(dout0_147) AT=955.025n

.meas tran vdout0_148ck1900 FIND v(dout0_148) AT=955.025n

.meas tran vdout0_149ck1900 FIND v(dout0_149) AT=955.025n

.meas tran vdout0_150ck1900 FIND v(dout0_150) AT=955.025n

.meas tran vdout0_151ck1900 FIND v(dout0_151) AT=955.025n

.meas tran vdout0_152ck1900 FIND v(dout0_152) AT=955.025n

.meas tran vdout0_153ck1900 FIND v(dout0_153) AT=955.025n

.meas tran vdout0_154ck1900 FIND v(dout0_154) AT=955.025n

.meas tran vdout0_155ck1900 FIND v(dout0_155) AT=955.025n

.meas tran vdout0_156ck1900 FIND v(dout0_156) AT=955.025n

.meas tran vdout0_157ck1900 FIND v(dout0_157) AT=955.025n

.meas tran vdout0_158ck1900 FIND v(dout0_158) AT=955.025n

.meas tran vdout0_159ck1900 FIND v(dout0_159) AT=955.025n

.meas tran vdout0_160ck1900 FIND v(dout0_160) AT=955.025n

.meas tran vdout0_161ck1900 FIND v(dout0_161) AT=955.025n

.meas tran vdout0_162ck1900 FIND v(dout0_162) AT=955.025n

.meas tran vdout0_163ck1900 FIND v(dout0_163) AT=955.025n

.meas tran vdout0_164ck1900 FIND v(dout0_164) AT=955.025n

.meas tran vdout0_165ck1900 FIND v(dout0_165) AT=955.025n

.meas tran vdout0_166ck1900 FIND v(dout0_166) AT=955.025n

.meas tran vdout0_167ck1900 FIND v(dout0_167) AT=955.025n

.meas tran vdout0_168ck1900 FIND v(dout0_168) AT=955.025n

.meas tran vdout0_169ck1900 FIND v(dout0_169) AT=955.025n

.meas tran vdout0_170ck1900 FIND v(dout0_170) AT=955.025n

.meas tran vdout0_171ck1900 FIND v(dout0_171) AT=955.025n

.meas tran vdout0_172ck1900 FIND v(dout0_172) AT=955.025n

.meas tran vdout0_173ck1900 FIND v(dout0_173) AT=955.025n

.meas tran vdout0_174ck1900 FIND v(dout0_174) AT=955.025n

.meas tran vdout0_175ck1900 FIND v(dout0_175) AT=955.025n

.meas tran vdout0_176ck1900 FIND v(dout0_176) AT=955.025n

.meas tran vdout0_177ck1900 FIND v(dout0_177) AT=955.025n

.meas tran vdout0_178ck1900 FIND v(dout0_178) AT=955.025n

.meas tran vdout0_179ck1900 FIND v(dout0_179) AT=955.025n

.meas tran vdout0_180ck1900 FIND v(dout0_180) AT=955.025n

.meas tran vdout0_181ck1900 FIND v(dout0_181) AT=955.025n

.meas tran vdout0_182ck1900 FIND v(dout0_182) AT=955.025n

.meas tran vdout0_183ck1900 FIND v(dout0_183) AT=955.025n

.meas tran vdout0_184ck1900 FIND v(dout0_184) AT=955.025n

.meas tran vdout0_185ck1900 FIND v(dout0_185) AT=955.025n

.meas tran vdout0_186ck1900 FIND v(dout0_186) AT=955.025n

.meas tran vdout0_187ck1900 FIND v(dout0_187) AT=955.025n

.meas tran vdout0_188ck1900 FIND v(dout0_188) AT=955.025n

.meas tran vdout0_189ck1900 FIND v(dout0_189) AT=955.025n

.meas tran vdout0_190ck1900 FIND v(dout0_190) AT=955.025n

.meas tran vdout0_191ck1900 FIND v(dout0_191) AT=955.025n

.meas tran vdout0_192ck1900 FIND v(dout0_192) AT=955.025n

.meas tran vdout0_193ck1900 FIND v(dout0_193) AT=955.025n

.meas tran vdout0_194ck1900 FIND v(dout0_194) AT=955.025n

.meas tran vdout0_195ck1900 FIND v(dout0_195) AT=955.025n

.meas tran vdout0_196ck1900 FIND v(dout0_196) AT=955.025n

.meas tran vdout0_197ck1900 FIND v(dout0_197) AT=955.025n

.meas tran vdout0_198ck1900 FIND v(dout0_198) AT=955.025n

.meas tran vdout0_199ck1900 FIND v(dout0_199) AT=955.025n

.meas tran vdout0_200ck1900 FIND v(dout0_200) AT=955.025n

.meas tran vdout0_201ck1900 FIND v(dout0_201) AT=955.025n

.meas tran vdout0_202ck1900 FIND v(dout0_202) AT=955.025n

.meas tran vdout0_203ck1900 FIND v(dout0_203) AT=955.025n

.meas tran vdout0_204ck1900 FIND v(dout0_204) AT=955.025n

.meas tran vdout0_205ck1900 FIND v(dout0_205) AT=955.025n

.meas tran vdout0_206ck1900 FIND v(dout0_206) AT=955.025n

.meas tran vdout0_207ck1900 FIND v(dout0_207) AT=955.025n

.meas tran vdout0_208ck1900 FIND v(dout0_208) AT=955.025n

.meas tran vdout0_209ck1900 FIND v(dout0_209) AT=955.025n

.meas tran vdout0_210ck1900 FIND v(dout0_210) AT=955.025n

.meas tran vdout0_211ck1900 FIND v(dout0_211) AT=955.025n

.meas tran vdout0_212ck1900 FIND v(dout0_212) AT=955.025n

.meas tran vdout0_213ck1900 FIND v(dout0_213) AT=955.025n

.meas tran vdout0_214ck1900 FIND v(dout0_214) AT=955.025n

.meas tran vdout0_215ck1900 FIND v(dout0_215) AT=955.025n

.meas tran vdout0_216ck1900 FIND v(dout0_216) AT=955.025n

.meas tran vdout0_217ck1900 FIND v(dout0_217) AT=955.025n

.meas tran vdout0_218ck1900 FIND v(dout0_218) AT=955.025n

.meas tran vdout0_219ck1900 FIND v(dout0_219) AT=955.025n

.meas tran vdout0_220ck1900 FIND v(dout0_220) AT=955.025n

.meas tran vdout0_221ck1900 FIND v(dout0_221) AT=955.025n

.meas tran vdout0_222ck1900 FIND v(dout0_222) AT=955.025n

.meas tran vdout0_223ck1900 FIND v(dout0_223) AT=955.025n

.meas tran vdout0_224ck1900 FIND v(dout0_224) AT=955.025n

.meas tran vdout0_225ck1900 FIND v(dout0_225) AT=955.025n

.meas tran vdout0_226ck1900 FIND v(dout0_226) AT=955.025n

.meas tran vdout0_227ck1900 FIND v(dout0_227) AT=955.025n

.meas tran vdout0_228ck1900 FIND v(dout0_228) AT=955.025n

.meas tran vdout0_229ck1900 FIND v(dout0_229) AT=955.025n

.meas tran vdout0_230ck1900 FIND v(dout0_230) AT=955.025n

.meas tran vdout0_231ck1900 FIND v(dout0_231) AT=955.025n

.meas tran vdout0_232ck1900 FIND v(dout0_232) AT=955.025n

.meas tran vdout0_233ck1900 FIND v(dout0_233) AT=955.025n

.meas tran vdout0_234ck1900 FIND v(dout0_234) AT=955.025n

.meas tran vdout0_235ck1900 FIND v(dout0_235) AT=955.025n

.meas tran vdout0_236ck1900 FIND v(dout0_236) AT=955.025n

.meas tran vdout0_237ck1900 FIND v(dout0_237) AT=955.025n

.meas tran vdout0_238ck1900 FIND v(dout0_238) AT=955.025n

.meas tran vdout0_239ck1900 FIND v(dout0_239) AT=955.025n

.meas tran vdout0_240ck1900 FIND v(dout0_240) AT=955.025n

.meas tran vdout0_241ck1900 FIND v(dout0_241) AT=955.025n

.meas tran vdout0_242ck1900 FIND v(dout0_242) AT=955.025n

.meas tran vdout0_243ck1900 FIND v(dout0_243) AT=955.025n

.meas tran vdout0_244ck1900 FIND v(dout0_244) AT=955.025n

.meas tran vdout0_245ck1900 FIND v(dout0_245) AT=955.025n

.meas tran vdout0_246ck1900 FIND v(dout0_246) AT=955.025n

.meas tran vdout0_247ck1900 FIND v(dout0_247) AT=955.025n

.meas tran vdout0_248ck1900 FIND v(dout0_248) AT=955.025n

.meas tran vdout0_249ck1900 FIND v(dout0_249) AT=955.025n

.meas tran vdout0_250ck1900 FIND v(dout0_250) AT=955.025n

.meas tran vdout0_251ck1900 FIND v(dout0_251) AT=955.025n

.meas tran vdout0_252ck1900 FIND v(dout0_252) AT=955.025n

.meas tran vdout0_253ck1900 FIND v(dout0_253) AT=955.025n

.meas tran vdout0_254ck1900 FIND v(dout0_254) AT=955.025n

.meas tran vdout0_255ck1900 FIND v(dout0_255) AT=955.025n

.meas tran vdout0_0ck1910 FIND v(dout0_0) AT=960.025n

.meas tran vdout0_1ck1910 FIND v(dout0_1) AT=960.025n

.meas tran vdout0_2ck1910 FIND v(dout0_2) AT=960.025n

.meas tran vdout0_3ck1910 FIND v(dout0_3) AT=960.025n

.meas tran vdout0_4ck1910 FIND v(dout0_4) AT=960.025n

.meas tran vdout0_5ck1910 FIND v(dout0_5) AT=960.025n

.meas tran vdout0_6ck1910 FIND v(dout0_6) AT=960.025n

.meas tran vdout0_7ck1910 FIND v(dout0_7) AT=960.025n

.meas tran vdout0_8ck1910 FIND v(dout0_8) AT=960.025n

.meas tran vdout0_9ck1910 FIND v(dout0_9) AT=960.025n

.meas tran vdout0_10ck1910 FIND v(dout0_10) AT=960.025n

.meas tran vdout0_11ck1910 FIND v(dout0_11) AT=960.025n

.meas tran vdout0_12ck1910 FIND v(dout0_12) AT=960.025n

.meas tran vdout0_13ck1910 FIND v(dout0_13) AT=960.025n

.meas tran vdout0_14ck1910 FIND v(dout0_14) AT=960.025n

.meas tran vdout0_15ck1910 FIND v(dout0_15) AT=960.025n

.meas tran vdout0_16ck1910 FIND v(dout0_16) AT=960.025n

.meas tran vdout0_17ck1910 FIND v(dout0_17) AT=960.025n

.meas tran vdout0_18ck1910 FIND v(dout0_18) AT=960.025n

.meas tran vdout0_19ck1910 FIND v(dout0_19) AT=960.025n

.meas tran vdout0_20ck1910 FIND v(dout0_20) AT=960.025n

.meas tran vdout0_21ck1910 FIND v(dout0_21) AT=960.025n

.meas tran vdout0_22ck1910 FIND v(dout0_22) AT=960.025n

.meas tran vdout0_23ck1910 FIND v(dout0_23) AT=960.025n

.meas tran vdout0_24ck1910 FIND v(dout0_24) AT=960.025n

.meas tran vdout0_25ck1910 FIND v(dout0_25) AT=960.025n

.meas tran vdout0_26ck1910 FIND v(dout0_26) AT=960.025n

.meas tran vdout0_27ck1910 FIND v(dout0_27) AT=960.025n

.meas tran vdout0_28ck1910 FIND v(dout0_28) AT=960.025n

.meas tran vdout0_29ck1910 FIND v(dout0_29) AT=960.025n

.meas tran vdout0_30ck1910 FIND v(dout0_30) AT=960.025n

.meas tran vdout0_31ck1910 FIND v(dout0_31) AT=960.025n

.meas tran vdout0_32ck1910 FIND v(dout0_32) AT=960.025n

.meas tran vdout0_33ck1910 FIND v(dout0_33) AT=960.025n

.meas tran vdout0_34ck1910 FIND v(dout0_34) AT=960.025n

.meas tran vdout0_35ck1910 FIND v(dout0_35) AT=960.025n

.meas tran vdout0_36ck1910 FIND v(dout0_36) AT=960.025n

.meas tran vdout0_37ck1910 FIND v(dout0_37) AT=960.025n

.meas tran vdout0_38ck1910 FIND v(dout0_38) AT=960.025n

.meas tran vdout0_39ck1910 FIND v(dout0_39) AT=960.025n

.meas tran vdout0_40ck1910 FIND v(dout0_40) AT=960.025n

.meas tran vdout0_41ck1910 FIND v(dout0_41) AT=960.025n

.meas tran vdout0_42ck1910 FIND v(dout0_42) AT=960.025n

.meas tran vdout0_43ck1910 FIND v(dout0_43) AT=960.025n

.meas tran vdout0_44ck1910 FIND v(dout0_44) AT=960.025n

.meas tran vdout0_45ck1910 FIND v(dout0_45) AT=960.025n

.meas tran vdout0_46ck1910 FIND v(dout0_46) AT=960.025n

.meas tran vdout0_47ck1910 FIND v(dout0_47) AT=960.025n

.meas tran vdout0_48ck1910 FIND v(dout0_48) AT=960.025n

.meas tran vdout0_49ck1910 FIND v(dout0_49) AT=960.025n

.meas tran vdout0_50ck1910 FIND v(dout0_50) AT=960.025n

.meas tran vdout0_51ck1910 FIND v(dout0_51) AT=960.025n

.meas tran vdout0_52ck1910 FIND v(dout0_52) AT=960.025n

.meas tran vdout0_53ck1910 FIND v(dout0_53) AT=960.025n

.meas tran vdout0_54ck1910 FIND v(dout0_54) AT=960.025n

.meas tran vdout0_55ck1910 FIND v(dout0_55) AT=960.025n

.meas tran vdout0_56ck1910 FIND v(dout0_56) AT=960.025n

.meas tran vdout0_57ck1910 FIND v(dout0_57) AT=960.025n

.meas tran vdout0_58ck1910 FIND v(dout0_58) AT=960.025n

.meas tran vdout0_59ck1910 FIND v(dout0_59) AT=960.025n

.meas tran vdout0_60ck1910 FIND v(dout0_60) AT=960.025n

.meas tran vdout0_61ck1910 FIND v(dout0_61) AT=960.025n

.meas tran vdout0_62ck1910 FIND v(dout0_62) AT=960.025n

.meas tran vdout0_63ck1910 FIND v(dout0_63) AT=960.025n

.meas tran vdout0_64ck1910 FIND v(dout0_64) AT=960.025n

.meas tran vdout0_65ck1910 FIND v(dout0_65) AT=960.025n

.meas tran vdout0_66ck1910 FIND v(dout0_66) AT=960.025n

.meas tran vdout0_67ck1910 FIND v(dout0_67) AT=960.025n

.meas tran vdout0_68ck1910 FIND v(dout0_68) AT=960.025n

.meas tran vdout0_69ck1910 FIND v(dout0_69) AT=960.025n

.meas tran vdout0_70ck1910 FIND v(dout0_70) AT=960.025n

.meas tran vdout0_71ck1910 FIND v(dout0_71) AT=960.025n

.meas tran vdout0_72ck1910 FIND v(dout0_72) AT=960.025n

.meas tran vdout0_73ck1910 FIND v(dout0_73) AT=960.025n

.meas tran vdout0_74ck1910 FIND v(dout0_74) AT=960.025n

.meas tran vdout0_75ck1910 FIND v(dout0_75) AT=960.025n

.meas tran vdout0_76ck1910 FIND v(dout0_76) AT=960.025n

.meas tran vdout0_77ck1910 FIND v(dout0_77) AT=960.025n

.meas tran vdout0_78ck1910 FIND v(dout0_78) AT=960.025n

.meas tran vdout0_79ck1910 FIND v(dout0_79) AT=960.025n

.meas tran vdout0_80ck1910 FIND v(dout0_80) AT=960.025n

.meas tran vdout0_81ck1910 FIND v(dout0_81) AT=960.025n

.meas tran vdout0_82ck1910 FIND v(dout0_82) AT=960.025n

.meas tran vdout0_83ck1910 FIND v(dout0_83) AT=960.025n

.meas tran vdout0_84ck1910 FIND v(dout0_84) AT=960.025n

.meas tran vdout0_85ck1910 FIND v(dout0_85) AT=960.025n

.meas tran vdout0_86ck1910 FIND v(dout0_86) AT=960.025n

.meas tran vdout0_87ck1910 FIND v(dout0_87) AT=960.025n

.meas tran vdout0_88ck1910 FIND v(dout0_88) AT=960.025n

.meas tran vdout0_89ck1910 FIND v(dout0_89) AT=960.025n

.meas tran vdout0_90ck1910 FIND v(dout0_90) AT=960.025n

.meas tran vdout0_91ck1910 FIND v(dout0_91) AT=960.025n

.meas tran vdout0_92ck1910 FIND v(dout0_92) AT=960.025n

.meas tran vdout0_93ck1910 FIND v(dout0_93) AT=960.025n

.meas tran vdout0_94ck1910 FIND v(dout0_94) AT=960.025n

.meas tran vdout0_95ck1910 FIND v(dout0_95) AT=960.025n

.meas tran vdout0_96ck1910 FIND v(dout0_96) AT=960.025n

.meas tran vdout0_97ck1910 FIND v(dout0_97) AT=960.025n

.meas tran vdout0_98ck1910 FIND v(dout0_98) AT=960.025n

.meas tran vdout0_99ck1910 FIND v(dout0_99) AT=960.025n

.meas tran vdout0_100ck1910 FIND v(dout0_100) AT=960.025n

.meas tran vdout0_101ck1910 FIND v(dout0_101) AT=960.025n

.meas tran vdout0_102ck1910 FIND v(dout0_102) AT=960.025n

.meas tran vdout0_103ck1910 FIND v(dout0_103) AT=960.025n

.meas tran vdout0_104ck1910 FIND v(dout0_104) AT=960.025n

.meas tran vdout0_105ck1910 FIND v(dout0_105) AT=960.025n

.meas tran vdout0_106ck1910 FIND v(dout0_106) AT=960.025n

.meas tran vdout0_107ck1910 FIND v(dout0_107) AT=960.025n

.meas tran vdout0_108ck1910 FIND v(dout0_108) AT=960.025n

.meas tran vdout0_109ck1910 FIND v(dout0_109) AT=960.025n

.meas tran vdout0_110ck1910 FIND v(dout0_110) AT=960.025n

.meas tran vdout0_111ck1910 FIND v(dout0_111) AT=960.025n

.meas tran vdout0_112ck1910 FIND v(dout0_112) AT=960.025n

.meas tran vdout0_113ck1910 FIND v(dout0_113) AT=960.025n

.meas tran vdout0_114ck1910 FIND v(dout0_114) AT=960.025n

.meas tran vdout0_115ck1910 FIND v(dout0_115) AT=960.025n

.meas tran vdout0_116ck1910 FIND v(dout0_116) AT=960.025n

.meas tran vdout0_117ck1910 FIND v(dout0_117) AT=960.025n

.meas tran vdout0_118ck1910 FIND v(dout0_118) AT=960.025n

.meas tran vdout0_119ck1910 FIND v(dout0_119) AT=960.025n

.meas tran vdout0_120ck1910 FIND v(dout0_120) AT=960.025n

.meas tran vdout0_121ck1910 FIND v(dout0_121) AT=960.025n

.meas tran vdout0_122ck1910 FIND v(dout0_122) AT=960.025n

.meas tran vdout0_123ck1910 FIND v(dout0_123) AT=960.025n

.meas tran vdout0_124ck1910 FIND v(dout0_124) AT=960.025n

.meas tran vdout0_125ck1910 FIND v(dout0_125) AT=960.025n

.meas tran vdout0_126ck1910 FIND v(dout0_126) AT=960.025n

.meas tran vdout0_127ck1910 FIND v(dout0_127) AT=960.025n

.meas tran vdout0_128ck1910 FIND v(dout0_128) AT=960.025n

.meas tran vdout0_129ck1910 FIND v(dout0_129) AT=960.025n

.meas tran vdout0_130ck1910 FIND v(dout0_130) AT=960.025n

.meas tran vdout0_131ck1910 FIND v(dout0_131) AT=960.025n

.meas tran vdout0_132ck1910 FIND v(dout0_132) AT=960.025n

.meas tran vdout0_133ck1910 FIND v(dout0_133) AT=960.025n

.meas tran vdout0_134ck1910 FIND v(dout0_134) AT=960.025n

.meas tran vdout0_135ck1910 FIND v(dout0_135) AT=960.025n

.meas tran vdout0_136ck1910 FIND v(dout0_136) AT=960.025n

.meas tran vdout0_137ck1910 FIND v(dout0_137) AT=960.025n

.meas tran vdout0_138ck1910 FIND v(dout0_138) AT=960.025n

.meas tran vdout0_139ck1910 FIND v(dout0_139) AT=960.025n

.meas tran vdout0_140ck1910 FIND v(dout0_140) AT=960.025n

.meas tran vdout0_141ck1910 FIND v(dout0_141) AT=960.025n

.meas tran vdout0_142ck1910 FIND v(dout0_142) AT=960.025n

.meas tran vdout0_143ck1910 FIND v(dout0_143) AT=960.025n

.meas tran vdout0_144ck1910 FIND v(dout0_144) AT=960.025n

.meas tran vdout0_145ck1910 FIND v(dout0_145) AT=960.025n

.meas tran vdout0_146ck1910 FIND v(dout0_146) AT=960.025n

.meas tran vdout0_147ck1910 FIND v(dout0_147) AT=960.025n

.meas tran vdout0_148ck1910 FIND v(dout0_148) AT=960.025n

.meas tran vdout0_149ck1910 FIND v(dout0_149) AT=960.025n

.meas tran vdout0_150ck1910 FIND v(dout0_150) AT=960.025n

.meas tran vdout0_151ck1910 FIND v(dout0_151) AT=960.025n

.meas tran vdout0_152ck1910 FIND v(dout0_152) AT=960.025n

.meas tran vdout0_153ck1910 FIND v(dout0_153) AT=960.025n

.meas tran vdout0_154ck1910 FIND v(dout0_154) AT=960.025n

.meas tran vdout0_155ck1910 FIND v(dout0_155) AT=960.025n

.meas tran vdout0_156ck1910 FIND v(dout0_156) AT=960.025n

.meas tran vdout0_157ck1910 FIND v(dout0_157) AT=960.025n

.meas tran vdout0_158ck1910 FIND v(dout0_158) AT=960.025n

.meas tran vdout0_159ck1910 FIND v(dout0_159) AT=960.025n

.meas tran vdout0_160ck1910 FIND v(dout0_160) AT=960.025n

.meas tran vdout0_161ck1910 FIND v(dout0_161) AT=960.025n

.meas tran vdout0_162ck1910 FIND v(dout0_162) AT=960.025n

.meas tran vdout0_163ck1910 FIND v(dout0_163) AT=960.025n

.meas tran vdout0_164ck1910 FIND v(dout0_164) AT=960.025n

.meas tran vdout0_165ck1910 FIND v(dout0_165) AT=960.025n

.meas tran vdout0_166ck1910 FIND v(dout0_166) AT=960.025n

.meas tran vdout0_167ck1910 FIND v(dout0_167) AT=960.025n

.meas tran vdout0_168ck1910 FIND v(dout0_168) AT=960.025n

.meas tran vdout0_169ck1910 FIND v(dout0_169) AT=960.025n

.meas tran vdout0_170ck1910 FIND v(dout0_170) AT=960.025n

.meas tran vdout0_171ck1910 FIND v(dout0_171) AT=960.025n

.meas tran vdout0_172ck1910 FIND v(dout0_172) AT=960.025n

.meas tran vdout0_173ck1910 FIND v(dout0_173) AT=960.025n

.meas tran vdout0_174ck1910 FIND v(dout0_174) AT=960.025n

.meas tran vdout0_175ck1910 FIND v(dout0_175) AT=960.025n

.meas tran vdout0_176ck1910 FIND v(dout0_176) AT=960.025n

.meas tran vdout0_177ck1910 FIND v(dout0_177) AT=960.025n

.meas tran vdout0_178ck1910 FIND v(dout0_178) AT=960.025n

.meas tran vdout0_179ck1910 FIND v(dout0_179) AT=960.025n

.meas tran vdout0_180ck1910 FIND v(dout0_180) AT=960.025n

.meas tran vdout0_181ck1910 FIND v(dout0_181) AT=960.025n

.meas tran vdout0_182ck1910 FIND v(dout0_182) AT=960.025n

.meas tran vdout0_183ck1910 FIND v(dout0_183) AT=960.025n

.meas tran vdout0_184ck1910 FIND v(dout0_184) AT=960.025n

.meas tran vdout0_185ck1910 FIND v(dout0_185) AT=960.025n

.meas tran vdout0_186ck1910 FIND v(dout0_186) AT=960.025n

.meas tran vdout0_187ck1910 FIND v(dout0_187) AT=960.025n

.meas tran vdout0_188ck1910 FIND v(dout0_188) AT=960.025n

.meas tran vdout0_189ck1910 FIND v(dout0_189) AT=960.025n

.meas tran vdout0_190ck1910 FIND v(dout0_190) AT=960.025n

.meas tran vdout0_191ck1910 FIND v(dout0_191) AT=960.025n

.meas tran vdout0_192ck1910 FIND v(dout0_192) AT=960.025n

.meas tran vdout0_193ck1910 FIND v(dout0_193) AT=960.025n

.meas tran vdout0_194ck1910 FIND v(dout0_194) AT=960.025n

.meas tran vdout0_195ck1910 FIND v(dout0_195) AT=960.025n

.meas tran vdout0_196ck1910 FIND v(dout0_196) AT=960.025n

.meas tran vdout0_197ck1910 FIND v(dout0_197) AT=960.025n

.meas tran vdout0_198ck1910 FIND v(dout0_198) AT=960.025n

.meas tran vdout0_199ck1910 FIND v(dout0_199) AT=960.025n

.meas tran vdout0_200ck1910 FIND v(dout0_200) AT=960.025n

.meas tran vdout0_201ck1910 FIND v(dout0_201) AT=960.025n

.meas tran vdout0_202ck1910 FIND v(dout0_202) AT=960.025n

.meas tran vdout0_203ck1910 FIND v(dout0_203) AT=960.025n

.meas tran vdout0_204ck1910 FIND v(dout0_204) AT=960.025n

.meas tran vdout0_205ck1910 FIND v(dout0_205) AT=960.025n

.meas tran vdout0_206ck1910 FIND v(dout0_206) AT=960.025n

.meas tran vdout0_207ck1910 FIND v(dout0_207) AT=960.025n

.meas tran vdout0_208ck1910 FIND v(dout0_208) AT=960.025n

.meas tran vdout0_209ck1910 FIND v(dout0_209) AT=960.025n

.meas tran vdout0_210ck1910 FIND v(dout0_210) AT=960.025n

.meas tran vdout0_211ck1910 FIND v(dout0_211) AT=960.025n

.meas tran vdout0_212ck1910 FIND v(dout0_212) AT=960.025n

.meas tran vdout0_213ck1910 FIND v(dout0_213) AT=960.025n

.meas tran vdout0_214ck1910 FIND v(dout0_214) AT=960.025n

.meas tran vdout0_215ck1910 FIND v(dout0_215) AT=960.025n

.meas tran vdout0_216ck1910 FIND v(dout0_216) AT=960.025n

.meas tran vdout0_217ck1910 FIND v(dout0_217) AT=960.025n

.meas tran vdout0_218ck1910 FIND v(dout0_218) AT=960.025n

.meas tran vdout0_219ck1910 FIND v(dout0_219) AT=960.025n

.meas tran vdout0_220ck1910 FIND v(dout0_220) AT=960.025n

.meas tran vdout0_221ck1910 FIND v(dout0_221) AT=960.025n

.meas tran vdout0_222ck1910 FIND v(dout0_222) AT=960.025n

.meas tran vdout0_223ck1910 FIND v(dout0_223) AT=960.025n

.meas tran vdout0_224ck1910 FIND v(dout0_224) AT=960.025n

.meas tran vdout0_225ck1910 FIND v(dout0_225) AT=960.025n

.meas tran vdout0_226ck1910 FIND v(dout0_226) AT=960.025n

.meas tran vdout0_227ck1910 FIND v(dout0_227) AT=960.025n

.meas tran vdout0_228ck1910 FIND v(dout0_228) AT=960.025n

.meas tran vdout0_229ck1910 FIND v(dout0_229) AT=960.025n

.meas tran vdout0_230ck1910 FIND v(dout0_230) AT=960.025n

.meas tran vdout0_231ck1910 FIND v(dout0_231) AT=960.025n

.meas tran vdout0_232ck1910 FIND v(dout0_232) AT=960.025n

.meas tran vdout0_233ck1910 FIND v(dout0_233) AT=960.025n

.meas tran vdout0_234ck1910 FIND v(dout0_234) AT=960.025n

.meas tran vdout0_235ck1910 FIND v(dout0_235) AT=960.025n

.meas tran vdout0_236ck1910 FIND v(dout0_236) AT=960.025n

.meas tran vdout0_237ck1910 FIND v(dout0_237) AT=960.025n

.meas tran vdout0_238ck1910 FIND v(dout0_238) AT=960.025n

.meas tran vdout0_239ck1910 FIND v(dout0_239) AT=960.025n

.meas tran vdout0_240ck1910 FIND v(dout0_240) AT=960.025n

.meas tran vdout0_241ck1910 FIND v(dout0_241) AT=960.025n

.meas tran vdout0_242ck1910 FIND v(dout0_242) AT=960.025n

.meas tran vdout0_243ck1910 FIND v(dout0_243) AT=960.025n

.meas tran vdout0_244ck1910 FIND v(dout0_244) AT=960.025n

.meas tran vdout0_245ck1910 FIND v(dout0_245) AT=960.025n

.meas tran vdout0_246ck1910 FIND v(dout0_246) AT=960.025n

.meas tran vdout0_247ck1910 FIND v(dout0_247) AT=960.025n

.meas tran vdout0_248ck1910 FIND v(dout0_248) AT=960.025n

.meas tran vdout0_249ck1910 FIND v(dout0_249) AT=960.025n

.meas tran vdout0_250ck1910 FIND v(dout0_250) AT=960.025n

.meas tran vdout0_251ck1910 FIND v(dout0_251) AT=960.025n

.meas tran vdout0_252ck1910 FIND v(dout0_252) AT=960.025n

.meas tran vdout0_253ck1910 FIND v(dout0_253) AT=960.025n

.meas tran vdout0_254ck1910 FIND v(dout0_254) AT=960.025n

.meas tran vdout0_255ck1910 FIND v(dout0_255) AT=960.025n

.meas tran vdout0_0ck1920 FIND v(dout0_0) AT=965.025n

.meas tran vdout0_1ck1920 FIND v(dout0_1) AT=965.025n

.meas tran vdout0_2ck1920 FIND v(dout0_2) AT=965.025n

.meas tran vdout0_3ck1920 FIND v(dout0_3) AT=965.025n

.meas tran vdout0_4ck1920 FIND v(dout0_4) AT=965.025n

.meas tran vdout0_5ck1920 FIND v(dout0_5) AT=965.025n

.meas tran vdout0_6ck1920 FIND v(dout0_6) AT=965.025n

.meas tran vdout0_7ck1920 FIND v(dout0_7) AT=965.025n

.meas tran vdout0_8ck1920 FIND v(dout0_8) AT=965.025n

.meas tran vdout0_9ck1920 FIND v(dout0_9) AT=965.025n

.meas tran vdout0_10ck1920 FIND v(dout0_10) AT=965.025n

.meas tran vdout0_11ck1920 FIND v(dout0_11) AT=965.025n

.meas tran vdout0_12ck1920 FIND v(dout0_12) AT=965.025n

.meas tran vdout0_13ck1920 FIND v(dout0_13) AT=965.025n

.meas tran vdout0_14ck1920 FIND v(dout0_14) AT=965.025n

.meas tran vdout0_15ck1920 FIND v(dout0_15) AT=965.025n

.meas tran vdout0_16ck1920 FIND v(dout0_16) AT=965.025n

.meas tran vdout0_17ck1920 FIND v(dout0_17) AT=965.025n

.meas tran vdout0_18ck1920 FIND v(dout0_18) AT=965.025n

.meas tran vdout0_19ck1920 FIND v(dout0_19) AT=965.025n

.meas tran vdout0_20ck1920 FIND v(dout0_20) AT=965.025n

.meas tran vdout0_21ck1920 FIND v(dout0_21) AT=965.025n

.meas tran vdout0_22ck1920 FIND v(dout0_22) AT=965.025n

.meas tran vdout0_23ck1920 FIND v(dout0_23) AT=965.025n

.meas tran vdout0_24ck1920 FIND v(dout0_24) AT=965.025n

.meas tran vdout0_25ck1920 FIND v(dout0_25) AT=965.025n

.meas tran vdout0_26ck1920 FIND v(dout0_26) AT=965.025n

.meas tran vdout0_27ck1920 FIND v(dout0_27) AT=965.025n

.meas tran vdout0_28ck1920 FIND v(dout0_28) AT=965.025n

.meas tran vdout0_29ck1920 FIND v(dout0_29) AT=965.025n

.meas tran vdout0_30ck1920 FIND v(dout0_30) AT=965.025n

.meas tran vdout0_31ck1920 FIND v(dout0_31) AT=965.025n

.meas tran vdout0_32ck1920 FIND v(dout0_32) AT=965.025n

.meas tran vdout0_33ck1920 FIND v(dout0_33) AT=965.025n

.meas tran vdout0_34ck1920 FIND v(dout0_34) AT=965.025n

.meas tran vdout0_35ck1920 FIND v(dout0_35) AT=965.025n

.meas tran vdout0_36ck1920 FIND v(dout0_36) AT=965.025n

.meas tran vdout0_37ck1920 FIND v(dout0_37) AT=965.025n

.meas tran vdout0_38ck1920 FIND v(dout0_38) AT=965.025n

.meas tran vdout0_39ck1920 FIND v(dout0_39) AT=965.025n

.meas tran vdout0_40ck1920 FIND v(dout0_40) AT=965.025n

.meas tran vdout0_41ck1920 FIND v(dout0_41) AT=965.025n

.meas tran vdout0_42ck1920 FIND v(dout0_42) AT=965.025n

.meas tran vdout0_43ck1920 FIND v(dout0_43) AT=965.025n

.meas tran vdout0_44ck1920 FIND v(dout0_44) AT=965.025n

.meas tran vdout0_45ck1920 FIND v(dout0_45) AT=965.025n

.meas tran vdout0_46ck1920 FIND v(dout0_46) AT=965.025n

.meas tran vdout0_47ck1920 FIND v(dout0_47) AT=965.025n

.meas tran vdout0_48ck1920 FIND v(dout0_48) AT=965.025n

.meas tran vdout0_49ck1920 FIND v(dout0_49) AT=965.025n

.meas tran vdout0_50ck1920 FIND v(dout0_50) AT=965.025n

.meas tran vdout0_51ck1920 FIND v(dout0_51) AT=965.025n

.meas tran vdout0_52ck1920 FIND v(dout0_52) AT=965.025n

.meas tran vdout0_53ck1920 FIND v(dout0_53) AT=965.025n

.meas tran vdout0_54ck1920 FIND v(dout0_54) AT=965.025n

.meas tran vdout0_55ck1920 FIND v(dout0_55) AT=965.025n

.meas tran vdout0_56ck1920 FIND v(dout0_56) AT=965.025n

.meas tran vdout0_57ck1920 FIND v(dout0_57) AT=965.025n

.meas tran vdout0_58ck1920 FIND v(dout0_58) AT=965.025n

.meas tran vdout0_59ck1920 FIND v(dout0_59) AT=965.025n

.meas tran vdout0_60ck1920 FIND v(dout0_60) AT=965.025n

.meas tran vdout0_61ck1920 FIND v(dout0_61) AT=965.025n

.meas tran vdout0_62ck1920 FIND v(dout0_62) AT=965.025n

.meas tran vdout0_63ck1920 FIND v(dout0_63) AT=965.025n

.meas tran vdout0_64ck1920 FIND v(dout0_64) AT=965.025n

.meas tran vdout0_65ck1920 FIND v(dout0_65) AT=965.025n

.meas tran vdout0_66ck1920 FIND v(dout0_66) AT=965.025n

.meas tran vdout0_67ck1920 FIND v(dout0_67) AT=965.025n

.meas tran vdout0_68ck1920 FIND v(dout0_68) AT=965.025n

.meas tran vdout0_69ck1920 FIND v(dout0_69) AT=965.025n

.meas tran vdout0_70ck1920 FIND v(dout0_70) AT=965.025n

.meas tran vdout0_71ck1920 FIND v(dout0_71) AT=965.025n

.meas tran vdout0_72ck1920 FIND v(dout0_72) AT=965.025n

.meas tran vdout0_73ck1920 FIND v(dout0_73) AT=965.025n

.meas tran vdout0_74ck1920 FIND v(dout0_74) AT=965.025n

.meas tran vdout0_75ck1920 FIND v(dout0_75) AT=965.025n

.meas tran vdout0_76ck1920 FIND v(dout0_76) AT=965.025n

.meas tran vdout0_77ck1920 FIND v(dout0_77) AT=965.025n

.meas tran vdout0_78ck1920 FIND v(dout0_78) AT=965.025n

.meas tran vdout0_79ck1920 FIND v(dout0_79) AT=965.025n

.meas tran vdout0_80ck1920 FIND v(dout0_80) AT=965.025n

.meas tran vdout0_81ck1920 FIND v(dout0_81) AT=965.025n

.meas tran vdout0_82ck1920 FIND v(dout0_82) AT=965.025n

.meas tran vdout0_83ck1920 FIND v(dout0_83) AT=965.025n

.meas tran vdout0_84ck1920 FIND v(dout0_84) AT=965.025n

.meas tran vdout0_85ck1920 FIND v(dout0_85) AT=965.025n

.meas tran vdout0_86ck1920 FIND v(dout0_86) AT=965.025n

.meas tran vdout0_87ck1920 FIND v(dout0_87) AT=965.025n

.meas tran vdout0_88ck1920 FIND v(dout0_88) AT=965.025n

.meas tran vdout0_89ck1920 FIND v(dout0_89) AT=965.025n

.meas tran vdout0_90ck1920 FIND v(dout0_90) AT=965.025n

.meas tran vdout0_91ck1920 FIND v(dout0_91) AT=965.025n

.meas tran vdout0_92ck1920 FIND v(dout0_92) AT=965.025n

.meas tran vdout0_93ck1920 FIND v(dout0_93) AT=965.025n

.meas tran vdout0_94ck1920 FIND v(dout0_94) AT=965.025n

.meas tran vdout0_95ck1920 FIND v(dout0_95) AT=965.025n

.meas tran vdout0_96ck1920 FIND v(dout0_96) AT=965.025n

.meas tran vdout0_97ck1920 FIND v(dout0_97) AT=965.025n

.meas tran vdout0_98ck1920 FIND v(dout0_98) AT=965.025n

.meas tran vdout0_99ck1920 FIND v(dout0_99) AT=965.025n

.meas tran vdout0_100ck1920 FIND v(dout0_100) AT=965.025n

.meas tran vdout0_101ck1920 FIND v(dout0_101) AT=965.025n

.meas tran vdout0_102ck1920 FIND v(dout0_102) AT=965.025n

.meas tran vdout0_103ck1920 FIND v(dout0_103) AT=965.025n

.meas tran vdout0_104ck1920 FIND v(dout0_104) AT=965.025n

.meas tran vdout0_105ck1920 FIND v(dout0_105) AT=965.025n

.meas tran vdout0_106ck1920 FIND v(dout0_106) AT=965.025n

.meas tran vdout0_107ck1920 FIND v(dout0_107) AT=965.025n

.meas tran vdout0_108ck1920 FIND v(dout0_108) AT=965.025n

.meas tran vdout0_109ck1920 FIND v(dout0_109) AT=965.025n

.meas tran vdout0_110ck1920 FIND v(dout0_110) AT=965.025n

.meas tran vdout0_111ck1920 FIND v(dout0_111) AT=965.025n

.meas tran vdout0_112ck1920 FIND v(dout0_112) AT=965.025n

.meas tran vdout0_113ck1920 FIND v(dout0_113) AT=965.025n

.meas tran vdout0_114ck1920 FIND v(dout0_114) AT=965.025n

.meas tran vdout0_115ck1920 FIND v(dout0_115) AT=965.025n

.meas tran vdout0_116ck1920 FIND v(dout0_116) AT=965.025n

.meas tran vdout0_117ck1920 FIND v(dout0_117) AT=965.025n

.meas tran vdout0_118ck1920 FIND v(dout0_118) AT=965.025n

.meas tran vdout0_119ck1920 FIND v(dout0_119) AT=965.025n

.meas tran vdout0_120ck1920 FIND v(dout0_120) AT=965.025n

.meas tran vdout0_121ck1920 FIND v(dout0_121) AT=965.025n

.meas tran vdout0_122ck1920 FIND v(dout0_122) AT=965.025n

.meas tran vdout0_123ck1920 FIND v(dout0_123) AT=965.025n

.meas tran vdout0_124ck1920 FIND v(dout0_124) AT=965.025n

.meas tran vdout0_125ck1920 FIND v(dout0_125) AT=965.025n

.meas tran vdout0_126ck1920 FIND v(dout0_126) AT=965.025n

.meas tran vdout0_127ck1920 FIND v(dout0_127) AT=965.025n

.meas tran vdout0_128ck1920 FIND v(dout0_128) AT=965.025n

.meas tran vdout0_129ck1920 FIND v(dout0_129) AT=965.025n

.meas tran vdout0_130ck1920 FIND v(dout0_130) AT=965.025n

.meas tran vdout0_131ck1920 FIND v(dout0_131) AT=965.025n

.meas tran vdout0_132ck1920 FIND v(dout0_132) AT=965.025n

.meas tran vdout0_133ck1920 FIND v(dout0_133) AT=965.025n

.meas tran vdout0_134ck1920 FIND v(dout0_134) AT=965.025n

.meas tran vdout0_135ck1920 FIND v(dout0_135) AT=965.025n

.meas tran vdout0_136ck1920 FIND v(dout0_136) AT=965.025n

.meas tran vdout0_137ck1920 FIND v(dout0_137) AT=965.025n

.meas tran vdout0_138ck1920 FIND v(dout0_138) AT=965.025n

.meas tran vdout0_139ck1920 FIND v(dout0_139) AT=965.025n

.meas tran vdout0_140ck1920 FIND v(dout0_140) AT=965.025n

.meas tran vdout0_141ck1920 FIND v(dout0_141) AT=965.025n

.meas tran vdout0_142ck1920 FIND v(dout0_142) AT=965.025n

.meas tran vdout0_143ck1920 FIND v(dout0_143) AT=965.025n

.meas tran vdout0_144ck1920 FIND v(dout0_144) AT=965.025n

.meas tran vdout0_145ck1920 FIND v(dout0_145) AT=965.025n

.meas tran vdout0_146ck1920 FIND v(dout0_146) AT=965.025n

.meas tran vdout0_147ck1920 FIND v(dout0_147) AT=965.025n

.meas tran vdout0_148ck1920 FIND v(dout0_148) AT=965.025n

.meas tran vdout0_149ck1920 FIND v(dout0_149) AT=965.025n

.meas tran vdout0_150ck1920 FIND v(dout0_150) AT=965.025n

.meas tran vdout0_151ck1920 FIND v(dout0_151) AT=965.025n

.meas tran vdout0_152ck1920 FIND v(dout0_152) AT=965.025n

.meas tran vdout0_153ck1920 FIND v(dout0_153) AT=965.025n

.meas tran vdout0_154ck1920 FIND v(dout0_154) AT=965.025n

.meas tran vdout0_155ck1920 FIND v(dout0_155) AT=965.025n

.meas tran vdout0_156ck1920 FIND v(dout0_156) AT=965.025n

.meas tran vdout0_157ck1920 FIND v(dout0_157) AT=965.025n

.meas tran vdout0_158ck1920 FIND v(dout0_158) AT=965.025n

.meas tran vdout0_159ck1920 FIND v(dout0_159) AT=965.025n

.meas tran vdout0_160ck1920 FIND v(dout0_160) AT=965.025n

.meas tran vdout0_161ck1920 FIND v(dout0_161) AT=965.025n

.meas tran vdout0_162ck1920 FIND v(dout0_162) AT=965.025n

.meas tran vdout0_163ck1920 FIND v(dout0_163) AT=965.025n

.meas tran vdout0_164ck1920 FIND v(dout0_164) AT=965.025n

.meas tran vdout0_165ck1920 FIND v(dout0_165) AT=965.025n

.meas tran vdout0_166ck1920 FIND v(dout0_166) AT=965.025n

.meas tran vdout0_167ck1920 FIND v(dout0_167) AT=965.025n

.meas tran vdout0_168ck1920 FIND v(dout0_168) AT=965.025n

.meas tran vdout0_169ck1920 FIND v(dout0_169) AT=965.025n

.meas tran vdout0_170ck1920 FIND v(dout0_170) AT=965.025n

.meas tran vdout0_171ck1920 FIND v(dout0_171) AT=965.025n

.meas tran vdout0_172ck1920 FIND v(dout0_172) AT=965.025n

.meas tran vdout0_173ck1920 FIND v(dout0_173) AT=965.025n

.meas tran vdout0_174ck1920 FIND v(dout0_174) AT=965.025n

.meas tran vdout0_175ck1920 FIND v(dout0_175) AT=965.025n

.meas tran vdout0_176ck1920 FIND v(dout0_176) AT=965.025n

.meas tran vdout0_177ck1920 FIND v(dout0_177) AT=965.025n

.meas tran vdout0_178ck1920 FIND v(dout0_178) AT=965.025n

.meas tran vdout0_179ck1920 FIND v(dout0_179) AT=965.025n

.meas tran vdout0_180ck1920 FIND v(dout0_180) AT=965.025n

.meas tran vdout0_181ck1920 FIND v(dout0_181) AT=965.025n

.meas tran vdout0_182ck1920 FIND v(dout0_182) AT=965.025n

.meas tran vdout0_183ck1920 FIND v(dout0_183) AT=965.025n

.meas tran vdout0_184ck1920 FIND v(dout0_184) AT=965.025n

.meas tran vdout0_185ck1920 FIND v(dout0_185) AT=965.025n

.meas tran vdout0_186ck1920 FIND v(dout0_186) AT=965.025n

.meas tran vdout0_187ck1920 FIND v(dout0_187) AT=965.025n

.meas tran vdout0_188ck1920 FIND v(dout0_188) AT=965.025n

.meas tran vdout0_189ck1920 FIND v(dout0_189) AT=965.025n

.meas tran vdout0_190ck1920 FIND v(dout0_190) AT=965.025n

.meas tran vdout0_191ck1920 FIND v(dout0_191) AT=965.025n

.meas tran vdout0_192ck1920 FIND v(dout0_192) AT=965.025n

.meas tran vdout0_193ck1920 FIND v(dout0_193) AT=965.025n

.meas tran vdout0_194ck1920 FIND v(dout0_194) AT=965.025n

.meas tran vdout0_195ck1920 FIND v(dout0_195) AT=965.025n

.meas tran vdout0_196ck1920 FIND v(dout0_196) AT=965.025n

.meas tran vdout0_197ck1920 FIND v(dout0_197) AT=965.025n

.meas tran vdout0_198ck1920 FIND v(dout0_198) AT=965.025n

.meas tran vdout0_199ck1920 FIND v(dout0_199) AT=965.025n

.meas tran vdout0_200ck1920 FIND v(dout0_200) AT=965.025n

.meas tran vdout0_201ck1920 FIND v(dout0_201) AT=965.025n

.meas tran vdout0_202ck1920 FIND v(dout0_202) AT=965.025n

.meas tran vdout0_203ck1920 FIND v(dout0_203) AT=965.025n

.meas tran vdout0_204ck1920 FIND v(dout0_204) AT=965.025n

.meas tran vdout0_205ck1920 FIND v(dout0_205) AT=965.025n

.meas tran vdout0_206ck1920 FIND v(dout0_206) AT=965.025n

.meas tran vdout0_207ck1920 FIND v(dout0_207) AT=965.025n

.meas tran vdout0_208ck1920 FIND v(dout0_208) AT=965.025n

.meas tran vdout0_209ck1920 FIND v(dout0_209) AT=965.025n

.meas tran vdout0_210ck1920 FIND v(dout0_210) AT=965.025n

.meas tran vdout0_211ck1920 FIND v(dout0_211) AT=965.025n

.meas tran vdout0_212ck1920 FIND v(dout0_212) AT=965.025n

.meas tran vdout0_213ck1920 FIND v(dout0_213) AT=965.025n

.meas tran vdout0_214ck1920 FIND v(dout0_214) AT=965.025n

.meas tran vdout0_215ck1920 FIND v(dout0_215) AT=965.025n

.meas tran vdout0_216ck1920 FIND v(dout0_216) AT=965.025n

.meas tran vdout0_217ck1920 FIND v(dout0_217) AT=965.025n

.meas tran vdout0_218ck1920 FIND v(dout0_218) AT=965.025n

.meas tran vdout0_219ck1920 FIND v(dout0_219) AT=965.025n

.meas tran vdout0_220ck1920 FIND v(dout0_220) AT=965.025n

.meas tran vdout0_221ck1920 FIND v(dout0_221) AT=965.025n

.meas tran vdout0_222ck1920 FIND v(dout0_222) AT=965.025n

.meas tran vdout0_223ck1920 FIND v(dout0_223) AT=965.025n

.meas tran vdout0_224ck1920 FIND v(dout0_224) AT=965.025n

.meas tran vdout0_225ck1920 FIND v(dout0_225) AT=965.025n

.meas tran vdout0_226ck1920 FIND v(dout0_226) AT=965.025n

.meas tran vdout0_227ck1920 FIND v(dout0_227) AT=965.025n

.meas tran vdout0_228ck1920 FIND v(dout0_228) AT=965.025n

.meas tran vdout0_229ck1920 FIND v(dout0_229) AT=965.025n

.meas tran vdout0_230ck1920 FIND v(dout0_230) AT=965.025n

.meas tran vdout0_231ck1920 FIND v(dout0_231) AT=965.025n

.meas tran vdout0_232ck1920 FIND v(dout0_232) AT=965.025n

.meas tran vdout0_233ck1920 FIND v(dout0_233) AT=965.025n

.meas tran vdout0_234ck1920 FIND v(dout0_234) AT=965.025n

.meas tran vdout0_235ck1920 FIND v(dout0_235) AT=965.025n

.meas tran vdout0_236ck1920 FIND v(dout0_236) AT=965.025n

.meas tran vdout0_237ck1920 FIND v(dout0_237) AT=965.025n

.meas tran vdout0_238ck1920 FIND v(dout0_238) AT=965.025n

.meas tran vdout0_239ck1920 FIND v(dout0_239) AT=965.025n

.meas tran vdout0_240ck1920 FIND v(dout0_240) AT=965.025n

.meas tran vdout0_241ck1920 FIND v(dout0_241) AT=965.025n

.meas tran vdout0_242ck1920 FIND v(dout0_242) AT=965.025n

.meas tran vdout0_243ck1920 FIND v(dout0_243) AT=965.025n

.meas tran vdout0_244ck1920 FIND v(dout0_244) AT=965.025n

.meas tran vdout0_245ck1920 FIND v(dout0_245) AT=965.025n

.meas tran vdout0_246ck1920 FIND v(dout0_246) AT=965.025n

.meas tran vdout0_247ck1920 FIND v(dout0_247) AT=965.025n

.meas tran vdout0_248ck1920 FIND v(dout0_248) AT=965.025n

.meas tran vdout0_249ck1920 FIND v(dout0_249) AT=965.025n

.meas tran vdout0_250ck1920 FIND v(dout0_250) AT=965.025n

.meas tran vdout0_251ck1920 FIND v(dout0_251) AT=965.025n

.meas tran vdout0_252ck1920 FIND v(dout0_252) AT=965.025n

.meas tran vdout0_253ck1920 FIND v(dout0_253) AT=965.025n

.meas tran vdout0_254ck1920 FIND v(dout0_254) AT=965.025n

.meas tran vdout0_255ck1920 FIND v(dout0_255) AT=965.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_128ck1930 FIND v(dout0_128) AT=970.025n

.meas tran vdout0_129ck1930 FIND v(dout0_129) AT=970.025n

.meas tran vdout0_130ck1930 FIND v(dout0_130) AT=970.025n

.meas tran vdout0_131ck1930 FIND v(dout0_131) AT=970.025n

.meas tran vdout0_132ck1930 FIND v(dout0_132) AT=970.025n

.meas tran vdout0_133ck1930 FIND v(dout0_133) AT=970.025n

.meas tran vdout0_134ck1930 FIND v(dout0_134) AT=970.025n

.meas tran vdout0_135ck1930 FIND v(dout0_135) AT=970.025n

.meas tran vdout0_136ck1930 FIND v(dout0_136) AT=970.025n

.meas tran vdout0_137ck1930 FIND v(dout0_137) AT=970.025n

.meas tran vdout0_138ck1930 FIND v(dout0_138) AT=970.025n

.meas tran vdout0_139ck1930 FIND v(dout0_139) AT=970.025n

.meas tran vdout0_140ck1930 FIND v(dout0_140) AT=970.025n

.meas tran vdout0_141ck1930 FIND v(dout0_141) AT=970.025n

.meas tran vdout0_142ck1930 FIND v(dout0_142) AT=970.025n

.meas tran vdout0_143ck1930 FIND v(dout0_143) AT=970.025n

.meas tran vdout0_144ck1930 FIND v(dout0_144) AT=970.025n

.meas tran vdout0_145ck1930 FIND v(dout0_145) AT=970.025n

.meas tran vdout0_146ck1930 FIND v(dout0_146) AT=970.025n

.meas tran vdout0_147ck1930 FIND v(dout0_147) AT=970.025n

.meas tran vdout0_148ck1930 FIND v(dout0_148) AT=970.025n

.meas tran vdout0_149ck1930 FIND v(dout0_149) AT=970.025n

.meas tran vdout0_150ck1930 FIND v(dout0_150) AT=970.025n

.meas tran vdout0_151ck1930 FIND v(dout0_151) AT=970.025n

.meas tran vdout0_152ck1930 FIND v(dout0_152) AT=970.025n

.meas tran vdout0_153ck1930 FIND v(dout0_153) AT=970.025n

.meas tran vdout0_154ck1930 FIND v(dout0_154) AT=970.025n

.meas tran vdout0_155ck1930 FIND v(dout0_155) AT=970.025n

.meas tran vdout0_156ck1930 FIND v(dout0_156) AT=970.025n

.meas tran vdout0_157ck1930 FIND v(dout0_157) AT=970.025n

.meas tran vdout0_158ck1930 FIND v(dout0_158) AT=970.025n

.meas tran vdout0_159ck1930 FIND v(dout0_159) AT=970.025n

.meas tran vdout0_160ck1930 FIND v(dout0_160) AT=970.025n

.meas tran vdout0_161ck1930 FIND v(dout0_161) AT=970.025n

.meas tran vdout0_162ck1930 FIND v(dout0_162) AT=970.025n

.meas tran vdout0_163ck1930 FIND v(dout0_163) AT=970.025n

.meas tran vdout0_164ck1930 FIND v(dout0_164) AT=970.025n

.meas tran vdout0_165ck1930 FIND v(dout0_165) AT=970.025n

.meas tran vdout0_166ck1930 FIND v(dout0_166) AT=970.025n

.meas tran vdout0_167ck1930 FIND v(dout0_167) AT=970.025n

.meas tran vdout0_168ck1930 FIND v(dout0_168) AT=970.025n

.meas tran vdout0_169ck1930 FIND v(dout0_169) AT=970.025n

.meas tran vdout0_170ck1930 FIND v(dout0_170) AT=970.025n

.meas tran vdout0_171ck1930 FIND v(dout0_171) AT=970.025n

.meas tran vdout0_172ck1930 FIND v(dout0_172) AT=970.025n

.meas tran vdout0_173ck1930 FIND v(dout0_173) AT=970.025n

.meas tran vdout0_174ck1930 FIND v(dout0_174) AT=970.025n

.meas tran vdout0_175ck1930 FIND v(dout0_175) AT=970.025n

.meas tran vdout0_176ck1930 FIND v(dout0_176) AT=970.025n

.meas tran vdout0_177ck1930 FIND v(dout0_177) AT=970.025n

.meas tran vdout0_178ck1930 FIND v(dout0_178) AT=970.025n

.meas tran vdout0_179ck1930 FIND v(dout0_179) AT=970.025n

.meas tran vdout0_180ck1930 FIND v(dout0_180) AT=970.025n

.meas tran vdout0_181ck1930 FIND v(dout0_181) AT=970.025n

.meas tran vdout0_182ck1930 FIND v(dout0_182) AT=970.025n

.meas tran vdout0_183ck1930 FIND v(dout0_183) AT=970.025n

.meas tran vdout0_184ck1930 FIND v(dout0_184) AT=970.025n

.meas tran vdout0_185ck1930 FIND v(dout0_185) AT=970.025n

.meas tran vdout0_186ck1930 FIND v(dout0_186) AT=970.025n

.meas tran vdout0_187ck1930 FIND v(dout0_187) AT=970.025n

.meas tran vdout0_188ck1930 FIND v(dout0_188) AT=970.025n

.meas tran vdout0_189ck1930 FIND v(dout0_189) AT=970.025n

.meas tran vdout0_190ck1930 FIND v(dout0_190) AT=970.025n

.meas tran vdout0_191ck1930 FIND v(dout0_191) AT=970.025n

.meas tran vdout0_192ck1930 FIND v(dout0_192) AT=970.025n

.meas tran vdout0_193ck1930 FIND v(dout0_193) AT=970.025n

.meas tran vdout0_194ck1930 FIND v(dout0_194) AT=970.025n

.meas tran vdout0_195ck1930 FIND v(dout0_195) AT=970.025n

.meas tran vdout0_196ck1930 FIND v(dout0_196) AT=970.025n

.meas tran vdout0_197ck1930 FIND v(dout0_197) AT=970.025n

.meas tran vdout0_198ck1930 FIND v(dout0_198) AT=970.025n

.meas tran vdout0_199ck1930 FIND v(dout0_199) AT=970.025n

.meas tran vdout0_200ck1930 FIND v(dout0_200) AT=970.025n

.meas tran vdout0_201ck1930 FIND v(dout0_201) AT=970.025n

.meas tran vdout0_202ck1930 FIND v(dout0_202) AT=970.025n

.meas tran vdout0_203ck1930 FIND v(dout0_203) AT=970.025n

.meas tran vdout0_204ck1930 FIND v(dout0_204) AT=970.025n

.meas tran vdout0_205ck1930 FIND v(dout0_205) AT=970.025n

.meas tran vdout0_206ck1930 FIND v(dout0_206) AT=970.025n

.meas tran vdout0_207ck1930 FIND v(dout0_207) AT=970.025n

.meas tran vdout0_208ck1930 FIND v(dout0_208) AT=970.025n

.meas tran vdout0_209ck1930 FIND v(dout0_209) AT=970.025n

.meas tran vdout0_210ck1930 FIND v(dout0_210) AT=970.025n

.meas tran vdout0_211ck1930 FIND v(dout0_211) AT=970.025n

.meas tran vdout0_212ck1930 FIND v(dout0_212) AT=970.025n

.meas tran vdout0_213ck1930 FIND v(dout0_213) AT=970.025n

.meas tran vdout0_214ck1930 FIND v(dout0_214) AT=970.025n

.meas tran vdout0_215ck1930 FIND v(dout0_215) AT=970.025n

.meas tran vdout0_216ck1930 FIND v(dout0_216) AT=970.025n

.meas tran vdout0_217ck1930 FIND v(dout0_217) AT=970.025n

.meas tran vdout0_218ck1930 FIND v(dout0_218) AT=970.025n

.meas tran vdout0_219ck1930 FIND v(dout0_219) AT=970.025n

.meas tran vdout0_220ck1930 FIND v(dout0_220) AT=970.025n

.meas tran vdout0_221ck1930 FIND v(dout0_221) AT=970.025n

.meas tran vdout0_222ck1930 FIND v(dout0_222) AT=970.025n

.meas tran vdout0_223ck1930 FIND v(dout0_223) AT=970.025n

.meas tran vdout0_224ck1930 FIND v(dout0_224) AT=970.025n

.meas tran vdout0_225ck1930 FIND v(dout0_225) AT=970.025n

.meas tran vdout0_226ck1930 FIND v(dout0_226) AT=970.025n

.meas tran vdout0_227ck1930 FIND v(dout0_227) AT=970.025n

.meas tran vdout0_228ck1930 FIND v(dout0_228) AT=970.025n

.meas tran vdout0_229ck1930 FIND v(dout0_229) AT=970.025n

.meas tran vdout0_230ck1930 FIND v(dout0_230) AT=970.025n

.meas tran vdout0_231ck1930 FIND v(dout0_231) AT=970.025n

.meas tran vdout0_232ck1930 FIND v(dout0_232) AT=970.025n

.meas tran vdout0_233ck1930 FIND v(dout0_233) AT=970.025n

.meas tran vdout0_234ck1930 FIND v(dout0_234) AT=970.025n

.meas tran vdout0_235ck1930 FIND v(dout0_235) AT=970.025n

.meas tran vdout0_236ck1930 FIND v(dout0_236) AT=970.025n

.meas tran vdout0_237ck1930 FIND v(dout0_237) AT=970.025n

.meas tran vdout0_238ck1930 FIND v(dout0_238) AT=970.025n

.meas tran vdout0_239ck1930 FIND v(dout0_239) AT=970.025n

.meas tran vdout0_240ck1930 FIND v(dout0_240) AT=970.025n

.meas tran vdout0_241ck1930 FIND v(dout0_241) AT=970.025n

.meas tran vdout0_242ck1930 FIND v(dout0_242) AT=970.025n

.meas tran vdout0_243ck1930 FIND v(dout0_243) AT=970.025n

.meas tran vdout0_244ck1930 FIND v(dout0_244) AT=970.025n

.meas tran vdout0_245ck1930 FIND v(dout0_245) AT=970.025n

.meas tran vdout0_246ck1930 FIND v(dout0_246) AT=970.025n

.meas tran vdout0_247ck1930 FIND v(dout0_247) AT=970.025n

.meas tran vdout0_248ck1930 FIND v(dout0_248) AT=970.025n

.meas tran vdout0_249ck1930 FIND v(dout0_249) AT=970.025n

.meas tran vdout0_250ck1930 FIND v(dout0_250) AT=970.025n

.meas tran vdout0_251ck1930 FIND v(dout0_251) AT=970.025n

.meas tran vdout0_252ck1930 FIND v(dout0_252) AT=970.025n

.meas tran vdout0_253ck1930 FIND v(dout0_253) AT=970.025n

.meas tran vdout0_254ck1930 FIND v(dout0_254) AT=970.025n

.meas tran vdout0_255ck1930 FIND v(dout0_255) AT=970.025n

.meas tran vdout0_0ck1950 FIND v(dout0_0) AT=980.025n

.meas tran vdout0_1ck1950 FIND v(dout0_1) AT=980.025n

.meas tran vdout0_2ck1950 FIND v(dout0_2) AT=980.025n

.meas tran vdout0_3ck1950 FIND v(dout0_3) AT=980.025n

.meas tran vdout0_4ck1950 FIND v(dout0_4) AT=980.025n

.meas tran vdout0_5ck1950 FIND v(dout0_5) AT=980.025n

.meas tran vdout0_6ck1950 FIND v(dout0_6) AT=980.025n

.meas tran vdout0_7ck1950 FIND v(dout0_7) AT=980.025n

.meas tran vdout0_8ck1950 FIND v(dout0_8) AT=980.025n

.meas tran vdout0_9ck1950 FIND v(dout0_9) AT=980.025n

.meas tran vdout0_10ck1950 FIND v(dout0_10) AT=980.025n

.meas tran vdout0_11ck1950 FIND v(dout0_11) AT=980.025n

.meas tran vdout0_12ck1950 FIND v(dout0_12) AT=980.025n

.meas tran vdout0_13ck1950 FIND v(dout0_13) AT=980.025n

.meas tran vdout0_14ck1950 FIND v(dout0_14) AT=980.025n

.meas tran vdout0_15ck1950 FIND v(dout0_15) AT=980.025n

.meas tran vdout0_16ck1950 FIND v(dout0_16) AT=980.025n

.meas tran vdout0_17ck1950 FIND v(dout0_17) AT=980.025n

.meas tran vdout0_18ck1950 FIND v(dout0_18) AT=980.025n

.meas tran vdout0_19ck1950 FIND v(dout0_19) AT=980.025n

.meas tran vdout0_20ck1950 FIND v(dout0_20) AT=980.025n

.meas tran vdout0_21ck1950 FIND v(dout0_21) AT=980.025n

.meas tran vdout0_22ck1950 FIND v(dout0_22) AT=980.025n

.meas tran vdout0_23ck1950 FIND v(dout0_23) AT=980.025n

.meas tran vdout0_24ck1950 FIND v(dout0_24) AT=980.025n

.meas tran vdout0_25ck1950 FIND v(dout0_25) AT=980.025n

.meas tran vdout0_26ck1950 FIND v(dout0_26) AT=980.025n

.meas tran vdout0_27ck1950 FIND v(dout0_27) AT=980.025n

.meas tran vdout0_28ck1950 FIND v(dout0_28) AT=980.025n

.meas tran vdout0_29ck1950 FIND v(dout0_29) AT=980.025n

.meas tran vdout0_30ck1950 FIND v(dout0_30) AT=980.025n

.meas tran vdout0_31ck1950 FIND v(dout0_31) AT=980.025n

.meas tran vdout0_32ck1950 FIND v(dout0_32) AT=980.025n

.meas tran vdout0_33ck1950 FIND v(dout0_33) AT=980.025n

.meas tran vdout0_34ck1950 FIND v(dout0_34) AT=980.025n

.meas tran vdout0_35ck1950 FIND v(dout0_35) AT=980.025n

.meas tran vdout0_36ck1950 FIND v(dout0_36) AT=980.025n

.meas tran vdout0_37ck1950 FIND v(dout0_37) AT=980.025n

.meas tran vdout0_38ck1950 FIND v(dout0_38) AT=980.025n

.meas tran vdout0_39ck1950 FIND v(dout0_39) AT=980.025n

.meas tran vdout0_40ck1950 FIND v(dout0_40) AT=980.025n

.meas tran vdout0_41ck1950 FIND v(dout0_41) AT=980.025n

.meas tran vdout0_42ck1950 FIND v(dout0_42) AT=980.025n

.meas tran vdout0_43ck1950 FIND v(dout0_43) AT=980.025n

.meas tran vdout0_44ck1950 FIND v(dout0_44) AT=980.025n

.meas tran vdout0_45ck1950 FIND v(dout0_45) AT=980.025n

.meas tran vdout0_46ck1950 FIND v(dout0_46) AT=980.025n

.meas tran vdout0_47ck1950 FIND v(dout0_47) AT=980.025n

.meas tran vdout0_48ck1950 FIND v(dout0_48) AT=980.025n

.meas tran vdout0_49ck1950 FIND v(dout0_49) AT=980.025n

.meas tran vdout0_50ck1950 FIND v(dout0_50) AT=980.025n

.meas tran vdout0_51ck1950 FIND v(dout0_51) AT=980.025n

.meas tran vdout0_52ck1950 FIND v(dout0_52) AT=980.025n

.meas tran vdout0_53ck1950 FIND v(dout0_53) AT=980.025n

.meas tran vdout0_54ck1950 FIND v(dout0_54) AT=980.025n

.meas tran vdout0_55ck1950 FIND v(dout0_55) AT=980.025n

.meas tran vdout0_56ck1950 FIND v(dout0_56) AT=980.025n

.meas tran vdout0_57ck1950 FIND v(dout0_57) AT=980.025n

.meas tran vdout0_58ck1950 FIND v(dout0_58) AT=980.025n

.meas tran vdout0_59ck1950 FIND v(dout0_59) AT=980.025n

.meas tran vdout0_60ck1950 FIND v(dout0_60) AT=980.025n

.meas tran vdout0_61ck1950 FIND v(dout0_61) AT=980.025n

.meas tran vdout0_62ck1950 FIND v(dout0_62) AT=980.025n

.meas tran vdout0_63ck1950 FIND v(dout0_63) AT=980.025n

.meas tran vdout0_64ck1950 FIND v(dout0_64) AT=980.025n

.meas tran vdout0_65ck1950 FIND v(dout0_65) AT=980.025n

.meas tran vdout0_66ck1950 FIND v(dout0_66) AT=980.025n

.meas tran vdout0_67ck1950 FIND v(dout0_67) AT=980.025n

.meas tran vdout0_68ck1950 FIND v(dout0_68) AT=980.025n

.meas tran vdout0_69ck1950 FIND v(dout0_69) AT=980.025n

.meas tran vdout0_70ck1950 FIND v(dout0_70) AT=980.025n

.meas tran vdout0_71ck1950 FIND v(dout0_71) AT=980.025n

.meas tran vdout0_72ck1950 FIND v(dout0_72) AT=980.025n

.meas tran vdout0_73ck1950 FIND v(dout0_73) AT=980.025n

.meas tran vdout0_74ck1950 FIND v(dout0_74) AT=980.025n

.meas tran vdout0_75ck1950 FIND v(dout0_75) AT=980.025n

.meas tran vdout0_76ck1950 FIND v(dout0_76) AT=980.025n

.meas tran vdout0_77ck1950 FIND v(dout0_77) AT=980.025n

.meas tran vdout0_78ck1950 FIND v(dout0_78) AT=980.025n

.meas tran vdout0_79ck1950 FIND v(dout0_79) AT=980.025n

.meas tran vdout0_80ck1950 FIND v(dout0_80) AT=980.025n

.meas tran vdout0_81ck1950 FIND v(dout0_81) AT=980.025n

.meas tran vdout0_82ck1950 FIND v(dout0_82) AT=980.025n

.meas tran vdout0_83ck1950 FIND v(dout0_83) AT=980.025n

.meas tran vdout0_84ck1950 FIND v(dout0_84) AT=980.025n

.meas tran vdout0_85ck1950 FIND v(dout0_85) AT=980.025n

.meas tran vdout0_86ck1950 FIND v(dout0_86) AT=980.025n

.meas tran vdout0_87ck1950 FIND v(dout0_87) AT=980.025n

.meas tran vdout0_88ck1950 FIND v(dout0_88) AT=980.025n

.meas tran vdout0_89ck1950 FIND v(dout0_89) AT=980.025n

.meas tran vdout0_90ck1950 FIND v(dout0_90) AT=980.025n

.meas tran vdout0_91ck1950 FIND v(dout0_91) AT=980.025n

.meas tran vdout0_92ck1950 FIND v(dout0_92) AT=980.025n

.meas tran vdout0_93ck1950 FIND v(dout0_93) AT=980.025n

.meas tran vdout0_94ck1950 FIND v(dout0_94) AT=980.025n

.meas tran vdout0_95ck1950 FIND v(dout0_95) AT=980.025n

.meas tran vdout0_96ck1950 FIND v(dout0_96) AT=980.025n

.meas tran vdout0_97ck1950 FIND v(dout0_97) AT=980.025n

.meas tran vdout0_98ck1950 FIND v(dout0_98) AT=980.025n

.meas tran vdout0_99ck1950 FIND v(dout0_99) AT=980.025n

.meas tran vdout0_100ck1950 FIND v(dout0_100) AT=980.025n

.meas tran vdout0_101ck1950 FIND v(dout0_101) AT=980.025n

.meas tran vdout0_102ck1950 FIND v(dout0_102) AT=980.025n

.meas tran vdout0_103ck1950 FIND v(dout0_103) AT=980.025n

.meas tran vdout0_104ck1950 FIND v(dout0_104) AT=980.025n

.meas tran vdout0_105ck1950 FIND v(dout0_105) AT=980.025n

.meas tran vdout0_106ck1950 FIND v(dout0_106) AT=980.025n

.meas tran vdout0_107ck1950 FIND v(dout0_107) AT=980.025n

.meas tran vdout0_108ck1950 FIND v(dout0_108) AT=980.025n

.meas tran vdout0_109ck1950 FIND v(dout0_109) AT=980.025n

.meas tran vdout0_110ck1950 FIND v(dout0_110) AT=980.025n

.meas tran vdout0_111ck1950 FIND v(dout0_111) AT=980.025n

.meas tran vdout0_112ck1950 FIND v(dout0_112) AT=980.025n

.meas tran vdout0_113ck1950 FIND v(dout0_113) AT=980.025n

.meas tran vdout0_114ck1950 FIND v(dout0_114) AT=980.025n

.meas tran vdout0_115ck1950 FIND v(dout0_115) AT=980.025n

.meas tran vdout0_116ck1950 FIND v(dout0_116) AT=980.025n

.meas tran vdout0_117ck1950 FIND v(dout0_117) AT=980.025n

.meas tran vdout0_118ck1950 FIND v(dout0_118) AT=980.025n

.meas tran vdout0_119ck1950 FIND v(dout0_119) AT=980.025n

.meas tran vdout0_120ck1950 FIND v(dout0_120) AT=980.025n

.meas tran vdout0_121ck1950 FIND v(dout0_121) AT=980.025n

.meas tran vdout0_122ck1950 FIND v(dout0_122) AT=980.025n

.meas tran vdout0_123ck1950 FIND v(dout0_123) AT=980.025n

.meas tran vdout0_124ck1950 FIND v(dout0_124) AT=980.025n

.meas tran vdout0_125ck1950 FIND v(dout0_125) AT=980.025n

.meas tran vdout0_126ck1950 FIND v(dout0_126) AT=980.025n

.meas tran vdout0_127ck1950 FIND v(dout0_127) AT=980.025n

.meas tran vdout0_128ck1950 FIND v(dout0_128) AT=980.025n

.meas tran vdout0_129ck1950 FIND v(dout0_129) AT=980.025n

.meas tran vdout0_130ck1950 FIND v(dout0_130) AT=980.025n

.meas tran vdout0_131ck1950 FIND v(dout0_131) AT=980.025n

.meas tran vdout0_132ck1950 FIND v(dout0_132) AT=980.025n

.meas tran vdout0_133ck1950 FIND v(dout0_133) AT=980.025n

.meas tran vdout0_134ck1950 FIND v(dout0_134) AT=980.025n

.meas tran vdout0_135ck1950 FIND v(dout0_135) AT=980.025n

.meas tran vdout0_136ck1950 FIND v(dout0_136) AT=980.025n

.meas tran vdout0_137ck1950 FIND v(dout0_137) AT=980.025n

.meas tran vdout0_138ck1950 FIND v(dout0_138) AT=980.025n

.meas tran vdout0_139ck1950 FIND v(dout0_139) AT=980.025n

.meas tran vdout0_140ck1950 FIND v(dout0_140) AT=980.025n

.meas tran vdout0_141ck1950 FIND v(dout0_141) AT=980.025n

.meas tran vdout0_142ck1950 FIND v(dout0_142) AT=980.025n

.meas tran vdout0_143ck1950 FIND v(dout0_143) AT=980.025n

.meas tran vdout0_144ck1950 FIND v(dout0_144) AT=980.025n

.meas tran vdout0_145ck1950 FIND v(dout0_145) AT=980.025n

.meas tran vdout0_146ck1950 FIND v(dout0_146) AT=980.025n

.meas tran vdout0_147ck1950 FIND v(dout0_147) AT=980.025n

.meas tran vdout0_148ck1950 FIND v(dout0_148) AT=980.025n

.meas tran vdout0_149ck1950 FIND v(dout0_149) AT=980.025n

.meas tran vdout0_150ck1950 FIND v(dout0_150) AT=980.025n

.meas tran vdout0_151ck1950 FIND v(dout0_151) AT=980.025n

.meas tran vdout0_152ck1950 FIND v(dout0_152) AT=980.025n

.meas tran vdout0_153ck1950 FIND v(dout0_153) AT=980.025n

.meas tran vdout0_154ck1950 FIND v(dout0_154) AT=980.025n

.meas tran vdout0_155ck1950 FIND v(dout0_155) AT=980.025n

.meas tran vdout0_156ck1950 FIND v(dout0_156) AT=980.025n

.meas tran vdout0_157ck1950 FIND v(dout0_157) AT=980.025n

.meas tran vdout0_158ck1950 FIND v(dout0_158) AT=980.025n

.meas tran vdout0_159ck1950 FIND v(dout0_159) AT=980.025n

.meas tran vdout0_160ck1950 FIND v(dout0_160) AT=980.025n

.meas tran vdout0_161ck1950 FIND v(dout0_161) AT=980.025n

.meas tran vdout0_162ck1950 FIND v(dout0_162) AT=980.025n

.meas tran vdout0_163ck1950 FIND v(dout0_163) AT=980.025n

.meas tran vdout0_164ck1950 FIND v(dout0_164) AT=980.025n

.meas tran vdout0_165ck1950 FIND v(dout0_165) AT=980.025n

.meas tran vdout0_166ck1950 FIND v(dout0_166) AT=980.025n

.meas tran vdout0_167ck1950 FIND v(dout0_167) AT=980.025n

.meas tran vdout0_168ck1950 FIND v(dout0_168) AT=980.025n

.meas tran vdout0_169ck1950 FIND v(dout0_169) AT=980.025n

.meas tran vdout0_170ck1950 FIND v(dout0_170) AT=980.025n

.meas tran vdout0_171ck1950 FIND v(dout0_171) AT=980.025n

.meas tran vdout0_172ck1950 FIND v(dout0_172) AT=980.025n

.meas tran vdout0_173ck1950 FIND v(dout0_173) AT=980.025n

.meas tran vdout0_174ck1950 FIND v(dout0_174) AT=980.025n

.meas tran vdout0_175ck1950 FIND v(dout0_175) AT=980.025n

.meas tran vdout0_176ck1950 FIND v(dout0_176) AT=980.025n

.meas tran vdout0_177ck1950 FIND v(dout0_177) AT=980.025n

.meas tran vdout0_178ck1950 FIND v(dout0_178) AT=980.025n

.meas tran vdout0_179ck1950 FIND v(dout0_179) AT=980.025n

.meas tran vdout0_180ck1950 FIND v(dout0_180) AT=980.025n

.meas tran vdout0_181ck1950 FIND v(dout0_181) AT=980.025n

.meas tran vdout0_182ck1950 FIND v(dout0_182) AT=980.025n

.meas tran vdout0_183ck1950 FIND v(dout0_183) AT=980.025n

.meas tran vdout0_184ck1950 FIND v(dout0_184) AT=980.025n

.meas tran vdout0_185ck1950 FIND v(dout0_185) AT=980.025n

.meas tran vdout0_186ck1950 FIND v(dout0_186) AT=980.025n

.meas tran vdout0_187ck1950 FIND v(dout0_187) AT=980.025n

.meas tran vdout0_188ck1950 FIND v(dout0_188) AT=980.025n

.meas tran vdout0_189ck1950 FIND v(dout0_189) AT=980.025n

.meas tran vdout0_190ck1950 FIND v(dout0_190) AT=980.025n

.meas tran vdout0_191ck1950 FIND v(dout0_191) AT=980.025n

.meas tran vdout0_192ck1950 FIND v(dout0_192) AT=980.025n

.meas tran vdout0_193ck1950 FIND v(dout0_193) AT=980.025n

.meas tran vdout0_194ck1950 FIND v(dout0_194) AT=980.025n

.meas tran vdout0_195ck1950 FIND v(dout0_195) AT=980.025n

.meas tran vdout0_196ck1950 FIND v(dout0_196) AT=980.025n

.meas tran vdout0_197ck1950 FIND v(dout0_197) AT=980.025n

.meas tran vdout0_198ck1950 FIND v(dout0_198) AT=980.025n

.meas tran vdout0_199ck1950 FIND v(dout0_199) AT=980.025n

.meas tran vdout0_200ck1950 FIND v(dout0_200) AT=980.025n

.meas tran vdout0_201ck1950 FIND v(dout0_201) AT=980.025n

.meas tran vdout0_202ck1950 FIND v(dout0_202) AT=980.025n

.meas tran vdout0_203ck1950 FIND v(dout0_203) AT=980.025n

.meas tran vdout0_204ck1950 FIND v(dout0_204) AT=980.025n

.meas tran vdout0_205ck1950 FIND v(dout0_205) AT=980.025n

.meas tran vdout0_206ck1950 FIND v(dout0_206) AT=980.025n

.meas tran vdout0_207ck1950 FIND v(dout0_207) AT=980.025n

.meas tran vdout0_208ck1950 FIND v(dout0_208) AT=980.025n

.meas tran vdout0_209ck1950 FIND v(dout0_209) AT=980.025n

.meas tran vdout0_210ck1950 FIND v(dout0_210) AT=980.025n

.meas tran vdout0_211ck1950 FIND v(dout0_211) AT=980.025n

.meas tran vdout0_212ck1950 FIND v(dout0_212) AT=980.025n

.meas tran vdout0_213ck1950 FIND v(dout0_213) AT=980.025n

.meas tran vdout0_214ck1950 FIND v(dout0_214) AT=980.025n

.meas tran vdout0_215ck1950 FIND v(dout0_215) AT=980.025n

.meas tran vdout0_216ck1950 FIND v(dout0_216) AT=980.025n

.meas tran vdout0_217ck1950 FIND v(dout0_217) AT=980.025n

.meas tran vdout0_218ck1950 FIND v(dout0_218) AT=980.025n

.meas tran vdout0_219ck1950 FIND v(dout0_219) AT=980.025n

.meas tran vdout0_220ck1950 FIND v(dout0_220) AT=980.025n

.meas tran vdout0_221ck1950 FIND v(dout0_221) AT=980.025n

.meas tran vdout0_222ck1950 FIND v(dout0_222) AT=980.025n

.meas tran vdout0_223ck1950 FIND v(dout0_223) AT=980.025n

.meas tran vdout0_224ck1950 FIND v(dout0_224) AT=980.025n

.meas tran vdout0_225ck1950 FIND v(dout0_225) AT=980.025n

.meas tran vdout0_226ck1950 FIND v(dout0_226) AT=980.025n

.meas tran vdout0_227ck1950 FIND v(dout0_227) AT=980.025n

.meas tran vdout0_228ck1950 FIND v(dout0_228) AT=980.025n

.meas tran vdout0_229ck1950 FIND v(dout0_229) AT=980.025n

.meas tran vdout0_230ck1950 FIND v(dout0_230) AT=980.025n

.meas tran vdout0_231ck1950 FIND v(dout0_231) AT=980.025n

.meas tran vdout0_232ck1950 FIND v(dout0_232) AT=980.025n

.meas tran vdout0_233ck1950 FIND v(dout0_233) AT=980.025n

.meas tran vdout0_234ck1950 FIND v(dout0_234) AT=980.025n

.meas tran vdout0_235ck1950 FIND v(dout0_235) AT=980.025n

.meas tran vdout0_236ck1950 FIND v(dout0_236) AT=980.025n

.meas tran vdout0_237ck1950 FIND v(dout0_237) AT=980.025n

.meas tran vdout0_238ck1950 FIND v(dout0_238) AT=980.025n

.meas tran vdout0_239ck1950 FIND v(dout0_239) AT=980.025n

.meas tran vdout0_240ck1950 FIND v(dout0_240) AT=980.025n

.meas tran vdout0_241ck1950 FIND v(dout0_241) AT=980.025n

.meas tran vdout0_242ck1950 FIND v(dout0_242) AT=980.025n

.meas tran vdout0_243ck1950 FIND v(dout0_243) AT=980.025n

.meas tran vdout0_244ck1950 FIND v(dout0_244) AT=980.025n

.meas tran vdout0_245ck1950 FIND v(dout0_245) AT=980.025n

.meas tran vdout0_246ck1950 FIND v(dout0_246) AT=980.025n

.meas tran vdout0_247ck1950 FIND v(dout0_247) AT=980.025n

.meas tran vdout0_248ck1950 FIND v(dout0_248) AT=980.025n

.meas tran vdout0_249ck1950 FIND v(dout0_249) AT=980.025n

.meas tran vdout0_250ck1950 FIND v(dout0_250) AT=980.025n

.meas tran vdout0_251ck1950 FIND v(dout0_251) AT=980.025n

.meas tran vdout0_252ck1950 FIND v(dout0_252) AT=980.025n

.meas tran vdout0_253ck1950 FIND v(dout0_253) AT=980.025n

.meas tran vdout0_254ck1950 FIND v(dout0_254) AT=980.025n

.meas tran vdout0_255ck1950 FIND v(dout0_255) AT=980.025n

.meas tran vdout0_0ck1960 FIND v(dout0_0) AT=985.025n

.meas tran vdout0_1ck1960 FIND v(dout0_1) AT=985.025n

.meas tran vdout0_2ck1960 FIND v(dout0_2) AT=985.025n

.meas tran vdout0_3ck1960 FIND v(dout0_3) AT=985.025n

.meas tran vdout0_4ck1960 FIND v(dout0_4) AT=985.025n

.meas tran vdout0_5ck1960 FIND v(dout0_5) AT=985.025n

.meas tran vdout0_6ck1960 FIND v(dout0_6) AT=985.025n

.meas tran vdout0_7ck1960 FIND v(dout0_7) AT=985.025n

.meas tran vdout0_8ck1960 FIND v(dout0_8) AT=985.025n

.meas tran vdout0_9ck1960 FIND v(dout0_9) AT=985.025n

.meas tran vdout0_10ck1960 FIND v(dout0_10) AT=985.025n

.meas tran vdout0_11ck1960 FIND v(dout0_11) AT=985.025n

.meas tran vdout0_12ck1960 FIND v(dout0_12) AT=985.025n

.meas tran vdout0_13ck1960 FIND v(dout0_13) AT=985.025n

.meas tran vdout0_14ck1960 FIND v(dout0_14) AT=985.025n

.meas tran vdout0_15ck1960 FIND v(dout0_15) AT=985.025n

.meas tran vdout0_16ck1960 FIND v(dout0_16) AT=985.025n

.meas tran vdout0_17ck1960 FIND v(dout0_17) AT=985.025n

.meas tran vdout0_18ck1960 FIND v(dout0_18) AT=985.025n

.meas tran vdout0_19ck1960 FIND v(dout0_19) AT=985.025n

.meas tran vdout0_20ck1960 FIND v(dout0_20) AT=985.025n

.meas tran vdout0_21ck1960 FIND v(dout0_21) AT=985.025n

.meas tran vdout0_22ck1960 FIND v(dout0_22) AT=985.025n

.meas tran vdout0_23ck1960 FIND v(dout0_23) AT=985.025n

.meas tran vdout0_24ck1960 FIND v(dout0_24) AT=985.025n

.meas tran vdout0_25ck1960 FIND v(dout0_25) AT=985.025n

.meas tran vdout0_26ck1960 FIND v(dout0_26) AT=985.025n

.meas tran vdout0_27ck1960 FIND v(dout0_27) AT=985.025n

.meas tran vdout0_28ck1960 FIND v(dout0_28) AT=985.025n

.meas tran vdout0_29ck1960 FIND v(dout0_29) AT=985.025n

.meas tran vdout0_30ck1960 FIND v(dout0_30) AT=985.025n

.meas tran vdout0_31ck1960 FIND v(dout0_31) AT=985.025n

.meas tran vdout0_32ck1960 FIND v(dout0_32) AT=985.025n

.meas tran vdout0_33ck1960 FIND v(dout0_33) AT=985.025n

.meas tran vdout0_34ck1960 FIND v(dout0_34) AT=985.025n

.meas tran vdout0_35ck1960 FIND v(dout0_35) AT=985.025n

.meas tran vdout0_36ck1960 FIND v(dout0_36) AT=985.025n

.meas tran vdout0_37ck1960 FIND v(dout0_37) AT=985.025n

.meas tran vdout0_38ck1960 FIND v(dout0_38) AT=985.025n

.meas tran vdout0_39ck1960 FIND v(dout0_39) AT=985.025n

.meas tran vdout0_40ck1960 FIND v(dout0_40) AT=985.025n

.meas tran vdout0_41ck1960 FIND v(dout0_41) AT=985.025n

.meas tran vdout0_42ck1960 FIND v(dout0_42) AT=985.025n

.meas tran vdout0_43ck1960 FIND v(dout0_43) AT=985.025n

.meas tran vdout0_44ck1960 FIND v(dout0_44) AT=985.025n

.meas tran vdout0_45ck1960 FIND v(dout0_45) AT=985.025n

.meas tran vdout0_46ck1960 FIND v(dout0_46) AT=985.025n

.meas tran vdout0_47ck1960 FIND v(dout0_47) AT=985.025n

.meas tran vdout0_48ck1960 FIND v(dout0_48) AT=985.025n

.meas tran vdout0_49ck1960 FIND v(dout0_49) AT=985.025n

.meas tran vdout0_50ck1960 FIND v(dout0_50) AT=985.025n

.meas tran vdout0_51ck1960 FIND v(dout0_51) AT=985.025n

.meas tran vdout0_52ck1960 FIND v(dout0_52) AT=985.025n

.meas tran vdout0_53ck1960 FIND v(dout0_53) AT=985.025n

.meas tran vdout0_54ck1960 FIND v(dout0_54) AT=985.025n

.meas tran vdout0_55ck1960 FIND v(dout0_55) AT=985.025n

.meas tran vdout0_56ck1960 FIND v(dout0_56) AT=985.025n

.meas tran vdout0_57ck1960 FIND v(dout0_57) AT=985.025n

.meas tran vdout0_58ck1960 FIND v(dout0_58) AT=985.025n

.meas tran vdout0_59ck1960 FIND v(dout0_59) AT=985.025n

.meas tran vdout0_60ck1960 FIND v(dout0_60) AT=985.025n

.meas tran vdout0_61ck1960 FIND v(dout0_61) AT=985.025n

.meas tran vdout0_62ck1960 FIND v(dout0_62) AT=985.025n

.meas tran vdout0_63ck1960 FIND v(dout0_63) AT=985.025n

.meas tran vdout0_64ck1960 FIND v(dout0_64) AT=985.025n

.meas tran vdout0_65ck1960 FIND v(dout0_65) AT=985.025n

.meas tran vdout0_66ck1960 FIND v(dout0_66) AT=985.025n

.meas tran vdout0_67ck1960 FIND v(dout0_67) AT=985.025n

.meas tran vdout0_68ck1960 FIND v(dout0_68) AT=985.025n

.meas tran vdout0_69ck1960 FIND v(dout0_69) AT=985.025n

.meas tran vdout0_70ck1960 FIND v(dout0_70) AT=985.025n

.meas tran vdout0_71ck1960 FIND v(dout0_71) AT=985.025n

.meas tran vdout0_72ck1960 FIND v(dout0_72) AT=985.025n

.meas tran vdout0_73ck1960 FIND v(dout0_73) AT=985.025n

.meas tran vdout0_74ck1960 FIND v(dout0_74) AT=985.025n

.meas tran vdout0_75ck1960 FIND v(dout0_75) AT=985.025n

.meas tran vdout0_76ck1960 FIND v(dout0_76) AT=985.025n

.meas tran vdout0_77ck1960 FIND v(dout0_77) AT=985.025n

.meas tran vdout0_78ck1960 FIND v(dout0_78) AT=985.025n

.meas tran vdout0_79ck1960 FIND v(dout0_79) AT=985.025n

.meas tran vdout0_80ck1960 FIND v(dout0_80) AT=985.025n

.meas tran vdout0_81ck1960 FIND v(dout0_81) AT=985.025n

.meas tran vdout0_82ck1960 FIND v(dout0_82) AT=985.025n

.meas tran vdout0_83ck1960 FIND v(dout0_83) AT=985.025n

.meas tran vdout0_84ck1960 FIND v(dout0_84) AT=985.025n

.meas tran vdout0_85ck1960 FIND v(dout0_85) AT=985.025n

.meas tran vdout0_86ck1960 FIND v(dout0_86) AT=985.025n

.meas tran vdout0_87ck1960 FIND v(dout0_87) AT=985.025n

.meas tran vdout0_88ck1960 FIND v(dout0_88) AT=985.025n

.meas tran vdout0_89ck1960 FIND v(dout0_89) AT=985.025n

.meas tran vdout0_90ck1960 FIND v(dout0_90) AT=985.025n

.meas tran vdout0_91ck1960 FIND v(dout0_91) AT=985.025n

.meas tran vdout0_92ck1960 FIND v(dout0_92) AT=985.025n

.meas tran vdout0_93ck1960 FIND v(dout0_93) AT=985.025n

.meas tran vdout0_94ck1960 FIND v(dout0_94) AT=985.025n

.meas tran vdout0_95ck1960 FIND v(dout0_95) AT=985.025n

.meas tran vdout0_96ck1960 FIND v(dout0_96) AT=985.025n

.meas tran vdout0_97ck1960 FIND v(dout0_97) AT=985.025n

.meas tran vdout0_98ck1960 FIND v(dout0_98) AT=985.025n

.meas tran vdout0_99ck1960 FIND v(dout0_99) AT=985.025n

.meas tran vdout0_100ck1960 FIND v(dout0_100) AT=985.025n

.meas tran vdout0_101ck1960 FIND v(dout0_101) AT=985.025n

.meas tran vdout0_102ck1960 FIND v(dout0_102) AT=985.025n

.meas tran vdout0_103ck1960 FIND v(dout0_103) AT=985.025n

.meas tran vdout0_104ck1960 FIND v(dout0_104) AT=985.025n

.meas tran vdout0_105ck1960 FIND v(dout0_105) AT=985.025n

.meas tran vdout0_106ck1960 FIND v(dout0_106) AT=985.025n

.meas tran vdout0_107ck1960 FIND v(dout0_107) AT=985.025n

.meas tran vdout0_108ck1960 FIND v(dout0_108) AT=985.025n

.meas tran vdout0_109ck1960 FIND v(dout0_109) AT=985.025n

.meas tran vdout0_110ck1960 FIND v(dout0_110) AT=985.025n

.meas tran vdout0_111ck1960 FIND v(dout0_111) AT=985.025n

.meas tran vdout0_112ck1960 FIND v(dout0_112) AT=985.025n

.meas tran vdout0_113ck1960 FIND v(dout0_113) AT=985.025n

.meas tran vdout0_114ck1960 FIND v(dout0_114) AT=985.025n

.meas tran vdout0_115ck1960 FIND v(dout0_115) AT=985.025n

.meas tran vdout0_116ck1960 FIND v(dout0_116) AT=985.025n

.meas tran vdout0_117ck1960 FIND v(dout0_117) AT=985.025n

.meas tran vdout0_118ck1960 FIND v(dout0_118) AT=985.025n

.meas tran vdout0_119ck1960 FIND v(dout0_119) AT=985.025n

.meas tran vdout0_120ck1960 FIND v(dout0_120) AT=985.025n

.meas tran vdout0_121ck1960 FIND v(dout0_121) AT=985.025n

.meas tran vdout0_122ck1960 FIND v(dout0_122) AT=985.025n

.meas tran vdout0_123ck1960 FIND v(dout0_123) AT=985.025n

.meas tran vdout0_124ck1960 FIND v(dout0_124) AT=985.025n

.meas tran vdout0_125ck1960 FIND v(dout0_125) AT=985.025n

.meas tran vdout0_126ck1960 FIND v(dout0_126) AT=985.025n

.meas tran vdout0_127ck1960 FIND v(dout0_127) AT=985.025n

.meas tran vdout0_128ck1960 FIND v(dout0_128) AT=985.025n

.meas tran vdout0_129ck1960 FIND v(dout0_129) AT=985.025n

.meas tran vdout0_130ck1960 FIND v(dout0_130) AT=985.025n

.meas tran vdout0_131ck1960 FIND v(dout0_131) AT=985.025n

.meas tran vdout0_132ck1960 FIND v(dout0_132) AT=985.025n

.meas tran vdout0_133ck1960 FIND v(dout0_133) AT=985.025n

.meas tran vdout0_134ck1960 FIND v(dout0_134) AT=985.025n

.meas tran vdout0_135ck1960 FIND v(dout0_135) AT=985.025n

.meas tran vdout0_136ck1960 FIND v(dout0_136) AT=985.025n

.meas tran vdout0_137ck1960 FIND v(dout0_137) AT=985.025n

.meas tran vdout0_138ck1960 FIND v(dout0_138) AT=985.025n

.meas tran vdout0_139ck1960 FIND v(dout0_139) AT=985.025n

.meas tran vdout0_140ck1960 FIND v(dout0_140) AT=985.025n

.meas tran vdout0_141ck1960 FIND v(dout0_141) AT=985.025n

.meas tran vdout0_142ck1960 FIND v(dout0_142) AT=985.025n

.meas tran vdout0_143ck1960 FIND v(dout0_143) AT=985.025n

.meas tran vdout0_144ck1960 FIND v(dout0_144) AT=985.025n

.meas tran vdout0_145ck1960 FIND v(dout0_145) AT=985.025n

.meas tran vdout0_146ck1960 FIND v(dout0_146) AT=985.025n

.meas tran vdout0_147ck1960 FIND v(dout0_147) AT=985.025n

.meas tran vdout0_148ck1960 FIND v(dout0_148) AT=985.025n

.meas tran vdout0_149ck1960 FIND v(dout0_149) AT=985.025n

.meas tran vdout0_150ck1960 FIND v(dout0_150) AT=985.025n

.meas tran vdout0_151ck1960 FIND v(dout0_151) AT=985.025n

.meas tran vdout0_152ck1960 FIND v(dout0_152) AT=985.025n

.meas tran vdout0_153ck1960 FIND v(dout0_153) AT=985.025n

.meas tran vdout0_154ck1960 FIND v(dout0_154) AT=985.025n

.meas tran vdout0_155ck1960 FIND v(dout0_155) AT=985.025n

.meas tran vdout0_156ck1960 FIND v(dout0_156) AT=985.025n

.meas tran vdout0_157ck1960 FIND v(dout0_157) AT=985.025n

.meas tran vdout0_158ck1960 FIND v(dout0_158) AT=985.025n

.meas tran vdout0_159ck1960 FIND v(dout0_159) AT=985.025n

.meas tran vdout0_160ck1960 FIND v(dout0_160) AT=985.025n

.meas tran vdout0_161ck1960 FIND v(dout0_161) AT=985.025n

.meas tran vdout0_162ck1960 FIND v(dout0_162) AT=985.025n

.meas tran vdout0_163ck1960 FIND v(dout0_163) AT=985.025n

.meas tran vdout0_164ck1960 FIND v(dout0_164) AT=985.025n

.meas tran vdout0_165ck1960 FIND v(dout0_165) AT=985.025n

.meas tran vdout0_166ck1960 FIND v(dout0_166) AT=985.025n

.meas tran vdout0_167ck1960 FIND v(dout0_167) AT=985.025n

.meas tran vdout0_168ck1960 FIND v(dout0_168) AT=985.025n

.meas tran vdout0_169ck1960 FIND v(dout0_169) AT=985.025n

.meas tran vdout0_170ck1960 FIND v(dout0_170) AT=985.025n

.meas tran vdout0_171ck1960 FIND v(dout0_171) AT=985.025n

.meas tran vdout0_172ck1960 FIND v(dout0_172) AT=985.025n

.meas tran vdout0_173ck1960 FIND v(dout0_173) AT=985.025n

.meas tran vdout0_174ck1960 FIND v(dout0_174) AT=985.025n

.meas tran vdout0_175ck1960 FIND v(dout0_175) AT=985.025n

.meas tran vdout0_176ck1960 FIND v(dout0_176) AT=985.025n

.meas tran vdout0_177ck1960 FIND v(dout0_177) AT=985.025n

.meas tran vdout0_178ck1960 FIND v(dout0_178) AT=985.025n

.meas tran vdout0_179ck1960 FIND v(dout0_179) AT=985.025n

.meas tran vdout0_180ck1960 FIND v(dout0_180) AT=985.025n

.meas tran vdout0_181ck1960 FIND v(dout0_181) AT=985.025n

.meas tran vdout0_182ck1960 FIND v(dout0_182) AT=985.025n

.meas tran vdout0_183ck1960 FIND v(dout0_183) AT=985.025n

.meas tran vdout0_184ck1960 FIND v(dout0_184) AT=985.025n

.meas tran vdout0_185ck1960 FIND v(dout0_185) AT=985.025n

.meas tran vdout0_186ck1960 FIND v(dout0_186) AT=985.025n

.meas tran vdout0_187ck1960 FIND v(dout0_187) AT=985.025n

.meas tran vdout0_188ck1960 FIND v(dout0_188) AT=985.025n

.meas tran vdout0_189ck1960 FIND v(dout0_189) AT=985.025n

.meas tran vdout0_190ck1960 FIND v(dout0_190) AT=985.025n

.meas tran vdout0_191ck1960 FIND v(dout0_191) AT=985.025n

.meas tran vdout0_192ck1960 FIND v(dout0_192) AT=985.025n

.meas tran vdout0_193ck1960 FIND v(dout0_193) AT=985.025n

.meas tran vdout0_194ck1960 FIND v(dout0_194) AT=985.025n

.meas tran vdout0_195ck1960 FIND v(dout0_195) AT=985.025n

.meas tran vdout0_196ck1960 FIND v(dout0_196) AT=985.025n

.meas tran vdout0_197ck1960 FIND v(dout0_197) AT=985.025n

.meas tran vdout0_198ck1960 FIND v(dout0_198) AT=985.025n

.meas tran vdout0_199ck1960 FIND v(dout0_199) AT=985.025n

.meas tran vdout0_200ck1960 FIND v(dout0_200) AT=985.025n

.meas tran vdout0_201ck1960 FIND v(dout0_201) AT=985.025n

.meas tran vdout0_202ck1960 FIND v(dout0_202) AT=985.025n

.meas tran vdout0_203ck1960 FIND v(dout0_203) AT=985.025n

.meas tran vdout0_204ck1960 FIND v(dout0_204) AT=985.025n

.meas tran vdout0_205ck1960 FIND v(dout0_205) AT=985.025n

.meas tran vdout0_206ck1960 FIND v(dout0_206) AT=985.025n

.meas tran vdout0_207ck1960 FIND v(dout0_207) AT=985.025n

.meas tran vdout0_208ck1960 FIND v(dout0_208) AT=985.025n

.meas tran vdout0_209ck1960 FIND v(dout0_209) AT=985.025n

.meas tran vdout0_210ck1960 FIND v(dout0_210) AT=985.025n

.meas tran vdout0_211ck1960 FIND v(dout0_211) AT=985.025n

.meas tran vdout0_212ck1960 FIND v(dout0_212) AT=985.025n

.meas tran vdout0_213ck1960 FIND v(dout0_213) AT=985.025n

.meas tran vdout0_214ck1960 FIND v(dout0_214) AT=985.025n

.meas tran vdout0_215ck1960 FIND v(dout0_215) AT=985.025n

.meas tran vdout0_216ck1960 FIND v(dout0_216) AT=985.025n

.meas tran vdout0_217ck1960 FIND v(dout0_217) AT=985.025n

.meas tran vdout0_218ck1960 FIND v(dout0_218) AT=985.025n

.meas tran vdout0_219ck1960 FIND v(dout0_219) AT=985.025n

.meas tran vdout0_220ck1960 FIND v(dout0_220) AT=985.025n

.meas tran vdout0_221ck1960 FIND v(dout0_221) AT=985.025n

.meas tran vdout0_222ck1960 FIND v(dout0_222) AT=985.025n

.meas tran vdout0_223ck1960 FIND v(dout0_223) AT=985.025n

.meas tran vdout0_224ck1960 FIND v(dout0_224) AT=985.025n

.meas tran vdout0_225ck1960 FIND v(dout0_225) AT=985.025n

.meas tran vdout0_226ck1960 FIND v(dout0_226) AT=985.025n

.meas tran vdout0_227ck1960 FIND v(dout0_227) AT=985.025n

.meas tran vdout0_228ck1960 FIND v(dout0_228) AT=985.025n

.meas tran vdout0_229ck1960 FIND v(dout0_229) AT=985.025n

.meas tran vdout0_230ck1960 FIND v(dout0_230) AT=985.025n

.meas tran vdout0_231ck1960 FIND v(dout0_231) AT=985.025n

.meas tran vdout0_232ck1960 FIND v(dout0_232) AT=985.025n

.meas tran vdout0_233ck1960 FIND v(dout0_233) AT=985.025n

.meas tran vdout0_234ck1960 FIND v(dout0_234) AT=985.025n

.meas tran vdout0_235ck1960 FIND v(dout0_235) AT=985.025n

.meas tran vdout0_236ck1960 FIND v(dout0_236) AT=985.025n

.meas tran vdout0_237ck1960 FIND v(dout0_237) AT=985.025n

.meas tran vdout0_238ck1960 FIND v(dout0_238) AT=985.025n

.meas tran vdout0_239ck1960 FIND v(dout0_239) AT=985.025n

.meas tran vdout0_240ck1960 FIND v(dout0_240) AT=985.025n

.meas tran vdout0_241ck1960 FIND v(dout0_241) AT=985.025n

.meas tran vdout0_242ck1960 FIND v(dout0_242) AT=985.025n

.meas tran vdout0_243ck1960 FIND v(dout0_243) AT=985.025n

.meas tran vdout0_244ck1960 FIND v(dout0_244) AT=985.025n

.meas tran vdout0_245ck1960 FIND v(dout0_245) AT=985.025n

.meas tran vdout0_246ck1960 FIND v(dout0_246) AT=985.025n

.meas tran vdout0_247ck1960 FIND v(dout0_247) AT=985.025n

.meas tran vdout0_248ck1960 FIND v(dout0_248) AT=985.025n

.meas tran vdout0_249ck1960 FIND v(dout0_249) AT=985.025n

.meas tran vdout0_250ck1960 FIND v(dout0_250) AT=985.025n

.meas tran vdout0_251ck1960 FIND v(dout0_251) AT=985.025n

.meas tran vdout0_252ck1960 FIND v(dout0_252) AT=985.025n

.meas tran vdout0_253ck1960 FIND v(dout0_253) AT=985.025n

.meas tran vdout0_254ck1960 FIND v(dout0_254) AT=985.025n

.meas tran vdout0_255ck1960 FIND v(dout0_255) AT=985.025n

.meas tran vdout0_0ck2000 FIND v(dout0_0) AT=1005.025n

.meas tran vdout0_1ck2000 FIND v(dout0_1) AT=1005.025n

.meas tran vdout0_2ck2000 FIND v(dout0_2) AT=1005.025n

.meas tran vdout0_3ck2000 FIND v(dout0_3) AT=1005.025n

.meas tran vdout0_4ck2000 FIND v(dout0_4) AT=1005.025n

.meas tran vdout0_5ck2000 FIND v(dout0_5) AT=1005.025n

.meas tran vdout0_6ck2000 FIND v(dout0_6) AT=1005.025n

.meas tran vdout0_7ck2000 FIND v(dout0_7) AT=1005.025n

.meas tran vdout0_8ck2000 FIND v(dout0_8) AT=1005.025n

.meas tran vdout0_9ck2000 FIND v(dout0_9) AT=1005.025n

.meas tran vdout0_10ck2000 FIND v(dout0_10) AT=1005.025n

.meas tran vdout0_11ck2000 FIND v(dout0_11) AT=1005.025n

.meas tran vdout0_12ck2000 FIND v(dout0_12) AT=1005.025n

.meas tran vdout0_13ck2000 FIND v(dout0_13) AT=1005.025n

.meas tran vdout0_14ck2000 FIND v(dout0_14) AT=1005.025n

.meas tran vdout0_15ck2000 FIND v(dout0_15) AT=1005.025n

.meas tran vdout0_16ck2000 FIND v(dout0_16) AT=1005.025n

.meas tran vdout0_17ck2000 FIND v(dout0_17) AT=1005.025n

.meas tran vdout0_18ck2000 FIND v(dout0_18) AT=1005.025n

.meas tran vdout0_19ck2000 FIND v(dout0_19) AT=1005.025n

.meas tran vdout0_20ck2000 FIND v(dout0_20) AT=1005.025n

.meas tran vdout0_21ck2000 FIND v(dout0_21) AT=1005.025n

.meas tran vdout0_22ck2000 FIND v(dout0_22) AT=1005.025n

.meas tran vdout0_23ck2000 FIND v(dout0_23) AT=1005.025n

.meas tran vdout0_24ck2000 FIND v(dout0_24) AT=1005.025n

.meas tran vdout0_25ck2000 FIND v(dout0_25) AT=1005.025n

.meas tran vdout0_26ck2000 FIND v(dout0_26) AT=1005.025n

.meas tran vdout0_27ck2000 FIND v(dout0_27) AT=1005.025n

.meas tran vdout0_28ck2000 FIND v(dout0_28) AT=1005.025n

.meas tran vdout0_29ck2000 FIND v(dout0_29) AT=1005.025n

.meas tran vdout0_30ck2000 FIND v(dout0_30) AT=1005.025n

.meas tran vdout0_31ck2000 FIND v(dout0_31) AT=1005.025n

.meas tran vdout0_32ck2000 FIND v(dout0_32) AT=1005.025n

.meas tran vdout0_33ck2000 FIND v(dout0_33) AT=1005.025n

.meas tran vdout0_34ck2000 FIND v(dout0_34) AT=1005.025n

.meas tran vdout0_35ck2000 FIND v(dout0_35) AT=1005.025n

.meas tran vdout0_36ck2000 FIND v(dout0_36) AT=1005.025n

.meas tran vdout0_37ck2000 FIND v(dout0_37) AT=1005.025n

.meas tran vdout0_38ck2000 FIND v(dout0_38) AT=1005.025n

.meas tran vdout0_39ck2000 FIND v(dout0_39) AT=1005.025n

.meas tran vdout0_40ck2000 FIND v(dout0_40) AT=1005.025n

.meas tran vdout0_41ck2000 FIND v(dout0_41) AT=1005.025n

.meas tran vdout0_42ck2000 FIND v(dout0_42) AT=1005.025n

.meas tran vdout0_43ck2000 FIND v(dout0_43) AT=1005.025n

.meas tran vdout0_44ck2000 FIND v(dout0_44) AT=1005.025n

.meas tran vdout0_45ck2000 FIND v(dout0_45) AT=1005.025n

.meas tran vdout0_46ck2000 FIND v(dout0_46) AT=1005.025n

.meas tran vdout0_47ck2000 FIND v(dout0_47) AT=1005.025n

.meas tran vdout0_48ck2000 FIND v(dout0_48) AT=1005.025n

.meas tran vdout0_49ck2000 FIND v(dout0_49) AT=1005.025n

.meas tran vdout0_50ck2000 FIND v(dout0_50) AT=1005.025n

.meas tran vdout0_51ck2000 FIND v(dout0_51) AT=1005.025n

.meas tran vdout0_52ck2000 FIND v(dout0_52) AT=1005.025n

.meas tran vdout0_53ck2000 FIND v(dout0_53) AT=1005.025n

.meas tran vdout0_54ck2000 FIND v(dout0_54) AT=1005.025n

.meas tran vdout0_55ck2000 FIND v(dout0_55) AT=1005.025n

.meas tran vdout0_56ck2000 FIND v(dout0_56) AT=1005.025n

.meas tran vdout0_57ck2000 FIND v(dout0_57) AT=1005.025n

.meas tran vdout0_58ck2000 FIND v(dout0_58) AT=1005.025n

.meas tran vdout0_59ck2000 FIND v(dout0_59) AT=1005.025n

.meas tran vdout0_60ck2000 FIND v(dout0_60) AT=1005.025n

.meas tran vdout0_61ck2000 FIND v(dout0_61) AT=1005.025n

.meas tran vdout0_62ck2000 FIND v(dout0_62) AT=1005.025n

.meas tran vdout0_63ck2000 FIND v(dout0_63) AT=1005.025n

.meas tran vdout0_64ck2000 FIND v(dout0_64) AT=1005.025n

.meas tran vdout0_65ck2000 FIND v(dout0_65) AT=1005.025n

.meas tran vdout0_66ck2000 FIND v(dout0_66) AT=1005.025n

.meas tran vdout0_67ck2000 FIND v(dout0_67) AT=1005.025n

.meas tran vdout0_68ck2000 FIND v(dout0_68) AT=1005.025n

.meas tran vdout0_69ck2000 FIND v(dout0_69) AT=1005.025n

.meas tran vdout0_70ck2000 FIND v(dout0_70) AT=1005.025n

.meas tran vdout0_71ck2000 FIND v(dout0_71) AT=1005.025n

.meas tran vdout0_72ck2000 FIND v(dout0_72) AT=1005.025n

.meas tran vdout0_73ck2000 FIND v(dout0_73) AT=1005.025n

.meas tran vdout0_74ck2000 FIND v(dout0_74) AT=1005.025n

.meas tran vdout0_75ck2000 FIND v(dout0_75) AT=1005.025n

.meas tran vdout0_76ck2000 FIND v(dout0_76) AT=1005.025n

.meas tran vdout0_77ck2000 FIND v(dout0_77) AT=1005.025n

.meas tran vdout0_78ck2000 FIND v(dout0_78) AT=1005.025n

.meas tran vdout0_79ck2000 FIND v(dout0_79) AT=1005.025n

.meas tran vdout0_80ck2000 FIND v(dout0_80) AT=1005.025n

.meas tran vdout0_81ck2000 FIND v(dout0_81) AT=1005.025n

.meas tran vdout0_82ck2000 FIND v(dout0_82) AT=1005.025n

.meas tran vdout0_83ck2000 FIND v(dout0_83) AT=1005.025n

.meas tran vdout0_84ck2000 FIND v(dout0_84) AT=1005.025n

.meas tran vdout0_85ck2000 FIND v(dout0_85) AT=1005.025n

.meas tran vdout0_86ck2000 FIND v(dout0_86) AT=1005.025n

.meas tran vdout0_87ck2000 FIND v(dout0_87) AT=1005.025n

.meas tran vdout0_88ck2000 FIND v(dout0_88) AT=1005.025n

.meas tran vdout0_89ck2000 FIND v(dout0_89) AT=1005.025n

.meas tran vdout0_90ck2000 FIND v(dout0_90) AT=1005.025n

.meas tran vdout0_91ck2000 FIND v(dout0_91) AT=1005.025n

.meas tran vdout0_92ck2000 FIND v(dout0_92) AT=1005.025n

.meas tran vdout0_93ck2000 FIND v(dout0_93) AT=1005.025n

.meas tran vdout0_94ck2000 FIND v(dout0_94) AT=1005.025n

.meas tran vdout0_95ck2000 FIND v(dout0_95) AT=1005.025n

.meas tran vdout0_96ck2000 FIND v(dout0_96) AT=1005.025n

.meas tran vdout0_97ck2000 FIND v(dout0_97) AT=1005.025n

.meas tran vdout0_98ck2000 FIND v(dout0_98) AT=1005.025n

.meas tran vdout0_99ck2000 FIND v(dout0_99) AT=1005.025n

.meas tran vdout0_100ck2000 FIND v(dout0_100) AT=1005.025n

.meas tran vdout0_101ck2000 FIND v(dout0_101) AT=1005.025n

.meas tran vdout0_102ck2000 FIND v(dout0_102) AT=1005.025n

.meas tran vdout0_103ck2000 FIND v(dout0_103) AT=1005.025n

.meas tran vdout0_104ck2000 FIND v(dout0_104) AT=1005.025n

.meas tran vdout0_105ck2000 FIND v(dout0_105) AT=1005.025n

.meas tran vdout0_106ck2000 FIND v(dout0_106) AT=1005.025n

.meas tran vdout0_107ck2000 FIND v(dout0_107) AT=1005.025n

.meas tran vdout0_108ck2000 FIND v(dout0_108) AT=1005.025n

.meas tran vdout0_109ck2000 FIND v(dout0_109) AT=1005.025n

.meas tran vdout0_110ck2000 FIND v(dout0_110) AT=1005.025n

.meas tran vdout0_111ck2000 FIND v(dout0_111) AT=1005.025n

.meas tran vdout0_112ck2000 FIND v(dout0_112) AT=1005.025n

.meas tran vdout0_113ck2000 FIND v(dout0_113) AT=1005.025n

.meas tran vdout0_114ck2000 FIND v(dout0_114) AT=1005.025n

.meas tran vdout0_115ck2000 FIND v(dout0_115) AT=1005.025n

.meas tran vdout0_116ck2000 FIND v(dout0_116) AT=1005.025n

.meas tran vdout0_117ck2000 FIND v(dout0_117) AT=1005.025n

.meas tran vdout0_118ck2000 FIND v(dout0_118) AT=1005.025n

.meas tran vdout0_119ck2000 FIND v(dout0_119) AT=1005.025n

.meas tran vdout0_120ck2000 FIND v(dout0_120) AT=1005.025n

.meas tran vdout0_121ck2000 FIND v(dout0_121) AT=1005.025n

.meas tran vdout0_122ck2000 FIND v(dout0_122) AT=1005.025n

.meas tran vdout0_123ck2000 FIND v(dout0_123) AT=1005.025n

.meas tran vdout0_124ck2000 FIND v(dout0_124) AT=1005.025n

.meas tran vdout0_125ck2000 FIND v(dout0_125) AT=1005.025n

.meas tran vdout0_126ck2000 FIND v(dout0_126) AT=1005.025n

.meas tran vdout0_127ck2000 FIND v(dout0_127) AT=1005.025n

.meas tran vdout0_128ck2000 FIND v(dout0_128) AT=1005.025n

.meas tran vdout0_129ck2000 FIND v(dout0_129) AT=1005.025n

.meas tran vdout0_130ck2000 FIND v(dout0_130) AT=1005.025n

.meas tran vdout0_131ck2000 FIND v(dout0_131) AT=1005.025n

.meas tran vdout0_132ck2000 FIND v(dout0_132) AT=1005.025n

.meas tran vdout0_133ck2000 FIND v(dout0_133) AT=1005.025n

.meas tran vdout0_134ck2000 FIND v(dout0_134) AT=1005.025n

.meas tran vdout0_135ck2000 FIND v(dout0_135) AT=1005.025n

.meas tran vdout0_136ck2000 FIND v(dout0_136) AT=1005.025n

.meas tran vdout0_137ck2000 FIND v(dout0_137) AT=1005.025n

.meas tran vdout0_138ck2000 FIND v(dout0_138) AT=1005.025n

.meas tran vdout0_139ck2000 FIND v(dout0_139) AT=1005.025n

.meas tran vdout0_140ck2000 FIND v(dout0_140) AT=1005.025n

.meas tran vdout0_141ck2000 FIND v(dout0_141) AT=1005.025n

.meas tran vdout0_142ck2000 FIND v(dout0_142) AT=1005.025n

.meas tran vdout0_143ck2000 FIND v(dout0_143) AT=1005.025n

.meas tran vdout0_144ck2000 FIND v(dout0_144) AT=1005.025n

.meas tran vdout0_145ck2000 FIND v(dout0_145) AT=1005.025n

.meas tran vdout0_146ck2000 FIND v(dout0_146) AT=1005.025n

.meas tran vdout0_147ck2000 FIND v(dout0_147) AT=1005.025n

.meas tran vdout0_148ck2000 FIND v(dout0_148) AT=1005.025n

.meas tran vdout0_149ck2000 FIND v(dout0_149) AT=1005.025n

.meas tran vdout0_150ck2000 FIND v(dout0_150) AT=1005.025n

.meas tran vdout0_151ck2000 FIND v(dout0_151) AT=1005.025n

.meas tran vdout0_152ck2000 FIND v(dout0_152) AT=1005.025n

.meas tran vdout0_153ck2000 FIND v(dout0_153) AT=1005.025n

.meas tran vdout0_154ck2000 FIND v(dout0_154) AT=1005.025n

.meas tran vdout0_155ck2000 FIND v(dout0_155) AT=1005.025n

.meas tran vdout0_156ck2000 FIND v(dout0_156) AT=1005.025n

.meas tran vdout0_157ck2000 FIND v(dout0_157) AT=1005.025n

.meas tran vdout0_158ck2000 FIND v(dout0_158) AT=1005.025n

.meas tran vdout0_159ck2000 FIND v(dout0_159) AT=1005.025n

.meas tran vdout0_160ck2000 FIND v(dout0_160) AT=1005.025n

.meas tran vdout0_161ck2000 FIND v(dout0_161) AT=1005.025n

.meas tran vdout0_162ck2000 FIND v(dout0_162) AT=1005.025n

.meas tran vdout0_163ck2000 FIND v(dout0_163) AT=1005.025n

.meas tran vdout0_164ck2000 FIND v(dout0_164) AT=1005.025n

.meas tran vdout0_165ck2000 FIND v(dout0_165) AT=1005.025n

.meas tran vdout0_166ck2000 FIND v(dout0_166) AT=1005.025n

.meas tran vdout0_167ck2000 FIND v(dout0_167) AT=1005.025n

.meas tran vdout0_168ck2000 FIND v(dout0_168) AT=1005.025n

.meas tran vdout0_169ck2000 FIND v(dout0_169) AT=1005.025n

.meas tran vdout0_170ck2000 FIND v(dout0_170) AT=1005.025n

.meas tran vdout0_171ck2000 FIND v(dout0_171) AT=1005.025n

.meas tran vdout0_172ck2000 FIND v(dout0_172) AT=1005.025n

.meas tran vdout0_173ck2000 FIND v(dout0_173) AT=1005.025n

.meas tran vdout0_174ck2000 FIND v(dout0_174) AT=1005.025n

.meas tran vdout0_175ck2000 FIND v(dout0_175) AT=1005.025n

.meas tran vdout0_176ck2000 FIND v(dout0_176) AT=1005.025n

.meas tran vdout0_177ck2000 FIND v(dout0_177) AT=1005.025n

.meas tran vdout0_178ck2000 FIND v(dout0_178) AT=1005.025n

.meas tran vdout0_179ck2000 FIND v(dout0_179) AT=1005.025n

.meas tran vdout0_180ck2000 FIND v(dout0_180) AT=1005.025n

.meas tran vdout0_181ck2000 FIND v(dout0_181) AT=1005.025n

.meas tran vdout0_182ck2000 FIND v(dout0_182) AT=1005.025n

.meas tran vdout0_183ck2000 FIND v(dout0_183) AT=1005.025n

.meas tran vdout0_184ck2000 FIND v(dout0_184) AT=1005.025n

.meas tran vdout0_185ck2000 FIND v(dout0_185) AT=1005.025n

.meas tran vdout0_186ck2000 FIND v(dout0_186) AT=1005.025n

.meas tran vdout0_187ck2000 FIND v(dout0_187) AT=1005.025n

.meas tran vdout0_188ck2000 FIND v(dout0_188) AT=1005.025n

.meas tran vdout0_189ck2000 FIND v(dout0_189) AT=1005.025n

.meas tran vdout0_190ck2000 FIND v(dout0_190) AT=1005.025n

.meas tran vdout0_191ck2000 FIND v(dout0_191) AT=1005.025n

.meas tran vdout0_192ck2000 FIND v(dout0_192) AT=1005.025n

.meas tran vdout0_193ck2000 FIND v(dout0_193) AT=1005.025n

.meas tran vdout0_194ck2000 FIND v(dout0_194) AT=1005.025n

.meas tran vdout0_195ck2000 FIND v(dout0_195) AT=1005.025n

.meas tran vdout0_196ck2000 FIND v(dout0_196) AT=1005.025n

.meas tran vdout0_197ck2000 FIND v(dout0_197) AT=1005.025n

.meas tran vdout0_198ck2000 FIND v(dout0_198) AT=1005.025n

.meas tran vdout0_199ck2000 FIND v(dout0_199) AT=1005.025n

.meas tran vdout0_200ck2000 FIND v(dout0_200) AT=1005.025n

.meas tran vdout0_201ck2000 FIND v(dout0_201) AT=1005.025n

.meas tran vdout0_202ck2000 FIND v(dout0_202) AT=1005.025n

.meas tran vdout0_203ck2000 FIND v(dout0_203) AT=1005.025n

.meas tran vdout0_204ck2000 FIND v(dout0_204) AT=1005.025n

.meas tran vdout0_205ck2000 FIND v(dout0_205) AT=1005.025n

.meas tran vdout0_206ck2000 FIND v(dout0_206) AT=1005.025n

.meas tran vdout0_207ck2000 FIND v(dout0_207) AT=1005.025n

.meas tran vdout0_208ck2000 FIND v(dout0_208) AT=1005.025n

.meas tran vdout0_209ck2000 FIND v(dout0_209) AT=1005.025n

.meas tran vdout0_210ck2000 FIND v(dout0_210) AT=1005.025n

.meas tran vdout0_211ck2000 FIND v(dout0_211) AT=1005.025n

.meas tran vdout0_212ck2000 FIND v(dout0_212) AT=1005.025n

.meas tran vdout0_213ck2000 FIND v(dout0_213) AT=1005.025n

.meas tran vdout0_214ck2000 FIND v(dout0_214) AT=1005.025n

.meas tran vdout0_215ck2000 FIND v(dout0_215) AT=1005.025n

.meas tran vdout0_216ck2000 FIND v(dout0_216) AT=1005.025n

.meas tran vdout0_217ck2000 FIND v(dout0_217) AT=1005.025n

.meas tran vdout0_218ck2000 FIND v(dout0_218) AT=1005.025n

.meas tran vdout0_219ck2000 FIND v(dout0_219) AT=1005.025n

.meas tran vdout0_220ck2000 FIND v(dout0_220) AT=1005.025n

.meas tran vdout0_221ck2000 FIND v(dout0_221) AT=1005.025n

.meas tran vdout0_222ck2000 FIND v(dout0_222) AT=1005.025n

.meas tran vdout0_223ck2000 FIND v(dout0_223) AT=1005.025n

.meas tran vdout0_224ck2000 FIND v(dout0_224) AT=1005.025n

.meas tran vdout0_225ck2000 FIND v(dout0_225) AT=1005.025n

.meas tran vdout0_226ck2000 FIND v(dout0_226) AT=1005.025n

.meas tran vdout0_227ck2000 FIND v(dout0_227) AT=1005.025n

.meas tran vdout0_228ck2000 FIND v(dout0_228) AT=1005.025n

.meas tran vdout0_229ck2000 FIND v(dout0_229) AT=1005.025n

.meas tran vdout0_230ck2000 FIND v(dout0_230) AT=1005.025n

.meas tran vdout0_231ck2000 FIND v(dout0_231) AT=1005.025n

.meas tran vdout0_232ck2000 FIND v(dout0_232) AT=1005.025n

.meas tran vdout0_233ck2000 FIND v(dout0_233) AT=1005.025n

.meas tran vdout0_234ck2000 FIND v(dout0_234) AT=1005.025n

.meas tran vdout0_235ck2000 FIND v(dout0_235) AT=1005.025n

.meas tran vdout0_236ck2000 FIND v(dout0_236) AT=1005.025n

.meas tran vdout0_237ck2000 FIND v(dout0_237) AT=1005.025n

.meas tran vdout0_238ck2000 FIND v(dout0_238) AT=1005.025n

.meas tran vdout0_239ck2000 FIND v(dout0_239) AT=1005.025n

.meas tran vdout0_240ck2000 FIND v(dout0_240) AT=1005.025n

.meas tran vdout0_241ck2000 FIND v(dout0_241) AT=1005.025n

.meas tran vdout0_242ck2000 FIND v(dout0_242) AT=1005.025n

.meas tran vdout0_243ck2000 FIND v(dout0_243) AT=1005.025n

.meas tran vdout0_244ck2000 FIND v(dout0_244) AT=1005.025n

.meas tran vdout0_245ck2000 FIND v(dout0_245) AT=1005.025n

.meas tran vdout0_246ck2000 FIND v(dout0_246) AT=1005.025n

.meas tran vdout0_247ck2000 FIND v(dout0_247) AT=1005.025n

.meas tran vdout0_248ck2000 FIND v(dout0_248) AT=1005.025n

.meas tran vdout0_249ck2000 FIND v(dout0_249) AT=1005.025n

.meas tran vdout0_250ck2000 FIND v(dout0_250) AT=1005.025n

.meas tran vdout0_251ck2000 FIND v(dout0_251) AT=1005.025n

.meas tran vdout0_252ck2000 FIND v(dout0_252) AT=1005.025n

.meas tran vdout0_253ck2000 FIND v(dout0_253) AT=1005.025n

.meas tran vdout0_254ck2000 FIND v(dout0_254) AT=1005.025n

.meas tran vdout0_255ck2000 FIND v(dout0_255) AT=1005.025n

.meas tran vdout0_0ck2030 FIND v(dout0_0) AT=1020.025n

.meas tran vdout0_1ck2030 FIND v(dout0_1) AT=1020.025n

.meas tran vdout0_2ck2030 FIND v(dout0_2) AT=1020.025n

.meas tran vdout0_3ck2030 FIND v(dout0_3) AT=1020.025n

.meas tran vdout0_4ck2030 FIND v(dout0_4) AT=1020.025n

.meas tran vdout0_5ck2030 FIND v(dout0_5) AT=1020.025n

.meas tran vdout0_6ck2030 FIND v(dout0_6) AT=1020.025n

.meas tran vdout0_7ck2030 FIND v(dout0_7) AT=1020.025n

.meas tran vdout0_8ck2030 FIND v(dout0_8) AT=1020.025n

.meas tran vdout0_9ck2030 FIND v(dout0_9) AT=1020.025n

.meas tran vdout0_10ck2030 FIND v(dout0_10) AT=1020.025n

.meas tran vdout0_11ck2030 FIND v(dout0_11) AT=1020.025n

.meas tran vdout0_12ck2030 FIND v(dout0_12) AT=1020.025n

.meas tran vdout0_13ck2030 FIND v(dout0_13) AT=1020.025n

.meas tran vdout0_14ck2030 FIND v(dout0_14) AT=1020.025n

.meas tran vdout0_15ck2030 FIND v(dout0_15) AT=1020.025n

.meas tran vdout0_16ck2030 FIND v(dout0_16) AT=1020.025n

.meas tran vdout0_17ck2030 FIND v(dout0_17) AT=1020.025n

.meas tran vdout0_18ck2030 FIND v(dout0_18) AT=1020.025n

.meas tran vdout0_19ck2030 FIND v(dout0_19) AT=1020.025n

.meas tran vdout0_20ck2030 FIND v(dout0_20) AT=1020.025n

.meas tran vdout0_21ck2030 FIND v(dout0_21) AT=1020.025n

.meas tran vdout0_22ck2030 FIND v(dout0_22) AT=1020.025n

.meas tran vdout0_23ck2030 FIND v(dout0_23) AT=1020.025n

.meas tran vdout0_24ck2030 FIND v(dout0_24) AT=1020.025n

.meas tran vdout0_25ck2030 FIND v(dout0_25) AT=1020.025n

.meas tran vdout0_26ck2030 FIND v(dout0_26) AT=1020.025n

.meas tran vdout0_27ck2030 FIND v(dout0_27) AT=1020.025n

.meas tran vdout0_28ck2030 FIND v(dout0_28) AT=1020.025n

.meas tran vdout0_29ck2030 FIND v(dout0_29) AT=1020.025n

.meas tran vdout0_30ck2030 FIND v(dout0_30) AT=1020.025n

.meas tran vdout0_31ck2030 FIND v(dout0_31) AT=1020.025n

.meas tran vdout0_32ck2030 FIND v(dout0_32) AT=1020.025n

.meas tran vdout0_33ck2030 FIND v(dout0_33) AT=1020.025n

.meas tran vdout0_34ck2030 FIND v(dout0_34) AT=1020.025n

.meas tran vdout0_35ck2030 FIND v(dout0_35) AT=1020.025n

.meas tran vdout0_36ck2030 FIND v(dout0_36) AT=1020.025n

.meas tran vdout0_37ck2030 FIND v(dout0_37) AT=1020.025n

.meas tran vdout0_38ck2030 FIND v(dout0_38) AT=1020.025n

.meas tran vdout0_39ck2030 FIND v(dout0_39) AT=1020.025n

.meas tran vdout0_40ck2030 FIND v(dout0_40) AT=1020.025n

.meas tran vdout0_41ck2030 FIND v(dout0_41) AT=1020.025n

.meas tran vdout0_42ck2030 FIND v(dout0_42) AT=1020.025n

.meas tran vdout0_43ck2030 FIND v(dout0_43) AT=1020.025n

.meas tran vdout0_44ck2030 FIND v(dout0_44) AT=1020.025n

.meas tran vdout0_45ck2030 FIND v(dout0_45) AT=1020.025n

.meas tran vdout0_46ck2030 FIND v(dout0_46) AT=1020.025n

.meas tran vdout0_47ck2030 FIND v(dout0_47) AT=1020.025n

.meas tran vdout0_48ck2030 FIND v(dout0_48) AT=1020.025n

.meas tran vdout0_49ck2030 FIND v(dout0_49) AT=1020.025n

.meas tran vdout0_50ck2030 FIND v(dout0_50) AT=1020.025n

.meas tran vdout0_51ck2030 FIND v(dout0_51) AT=1020.025n

.meas tran vdout0_52ck2030 FIND v(dout0_52) AT=1020.025n

.meas tran vdout0_53ck2030 FIND v(dout0_53) AT=1020.025n

.meas tran vdout0_54ck2030 FIND v(dout0_54) AT=1020.025n

.meas tran vdout0_55ck2030 FIND v(dout0_55) AT=1020.025n

.meas tran vdout0_56ck2030 FIND v(dout0_56) AT=1020.025n

.meas tran vdout0_57ck2030 FIND v(dout0_57) AT=1020.025n

.meas tran vdout0_58ck2030 FIND v(dout0_58) AT=1020.025n

.meas tran vdout0_59ck2030 FIND v(dout0_59) AT=1020.025n

.meas tran vdout0_60ck2030 FIND v(dout0_60) AT=1020.025n

.meas tran vdout0_61ck2030 FIND v(dout0_61) AT=1020.025n

.meas tran vdout0_62ck2030 FIND v(dout0_62) AT=1020.025n

.meas tran vdout0_63ck2030 FIND v(dout0_63) AT=1020.025n

.meas tran vdout0_64ck2030 FIND v(dout0_64) AT=1020.025n

.meas tran vdout0_65ck2030 FIND v(dout0_65) AT=1020.025n

.meas tran vdout0_66ck2030 FIND v(dout0_66) AT=1020.025n

.meas tran vdout0_67ck2030 FIND v(dout0_67) AT=1020.025n

.meas tran vdout0_68ck2030 FIND v(dout0_68) AT=1020.025n

.meas tran vdout0_69ck2030 FIND v(dout0_69) AT=1020.025n

.meas tran vdout0_70ck2030 FIND v(dout0_70) AT=1020.025n

.meas tran vdout0_71ck2030 FIND v(dout0_71) AT=1020.025n

.meas tran vdout0_72ck2030 FIND v(dout0_72) AT=1020.025n

.meas tran vdout0_73ck2030 FIND v(dout0_73) AT=1020.025n

.meas tran vdout0_74ck2030 FIND v(dout0_74) AT=1020.025n

.meas tran vdout0_75ck2030 FIND v(dout0_75) AT=1020.025n

.meas tran vdout0_76ck2030 FIND v(dout0_76) AT=1020.025n

.meas tran vdout0_77ck2030 FIND v(dout0_77) AT=1020.025n

.meas tran vdout0_78ck2030 FIND v(dout0_78) AT=1020.025n

.meas tran vdout0_79ck2030 FIND v(dout0_79) AT=1020.025n

.meas tran vdout0_80ck2030 FIND v(dout0_80) AT=1020.025n

.meas tran vdout0_81ck2030 FIND v(dout0_81) AT=1020.025n

.meas tran vdout0_82ck2030 FIND v(dout0_82) AT=1020.025n

.meas tran vdout0_83ck2030 FIND v(dout0_83) AT=1020.025n

.meas tran vdout0_84ck2030 FIND v(dout0_84) AT=1020.025n

.meas tran vdout0_85ck2030 FIND v(dout0_85) AT=1020.025n

.meas tran vdout0_86ck2030 FIND v(dout0_86) AT=1020.025n

.meas tran vdout0_87ck2030 FIND v(dout0_87) AT=1020.025n

.meas tran vdout0_88ck2030 FIND v(dout0_88) AT=1020.025n

.meas tran vdout0_89ck2030 FIND v(dout0_89) AT=1020.025n

.meas tran vdout0_90ck2030 FIND v(dout0_90) AT=1020.025n

.meas tran vdout0_91ck2030 FIND v(dout0_91) AT=1020.025n

.meas tran vdout0_92ck2030 FIND v(dout0_92) AT=1020.025n

.meas tran vdout0_93ck2030 FIND v(dout0_93) AT=1020.025n

.meas tran vdout0_94ck2030 FIND v(dout0_94) AT=1020.025n

.meas tran vdout0_95ck2030 FIND v(dout0_95) AT=1020.025n

.meas tran vdout0_96ck2030 FIND v(dout0_96) AT=1020.025n

.meas tran vdout0_97ck2030 FIND v(dout0_97) AT=1020.025n

.meas tran vdout0_98ck2030 FIND v(dout0_98) AT=1020.025n

.meas tran vdout0_99ck2030 FIND v(dout0_99) AT=1020.025n

.meas tran vdout0_100ck2030 FIND v(dout0_100) AT=1020.025n

.meas tran vdout0_101ck2030 FIND v(dout0_101) AT=1020.025n

.meas tran vdout0_102ck2030 FIND v(dout0_102) AT=1020.025n

.meas tran vdout0_103ck2030 FIND v(dout0_103) AT=1020.025n

.meas tran vdout0_104ck2030 FIND v(dout0_104) AT=1020.025n

.meas tran vdout0_105ck2030 FIND v(dout0_105) AT=1020.025n

.meas tran vdout0_106ck2030 FIND v(dout0_106) AT=1020.025n

.meas tran vdout0_107ck2030 FIND v(dout0_107) AT=1020.025n

.meas tran vdout0_108ck2030 FIND v(dout0_108) AT=1020.025n

.meas tran vdout0_109ck2030 FIND v(dout0_109) AT=1020.025n

.meas tran vdout0_110ck2030 FIND v(dout0_110) AT=1020.025n

.meas tran vdout0_111ck2030 FIND v(dout0_111) AT=1020.025n

.meas tran vdout0_112ck2030 FIND v(dout0_112) AT=1020.025n

.meas tran vdout0_113ck2030 FIND v(dout0_113) AT=1020.025n

.meas tran vdout0_114ck2030 FIND v(dout0_114) AT=1020.025n

.meas tran vdout0_115ck2030 FIND v(dout0_115) AT=1020.025n

.meas tran vdout0_116ck2030 FIND v(dout0_116) AT=1020.025n

.meas tran vdout0_117ck2030 FIND v(dout0_117) AT=1020.025n

.meas tran vdout0_118ck2030 FIND v(dout0_118) AT=1020.025n

.meas tran vdout0_119ck2030 FIND v(dout0_119) AT=1020.025n

.meas tran vdout0_120ck2030 FIND v(dout0_120) AT=1020.025n

.meas tran vdout0_121ck2030 FIND v(dout0_121) AT=1020.025n

.meas tran vdout0_122ck2030 FIND v(dout0_122) AT=1020.025n

.meas tran vdout0_123ck2030 FIND v(dout0_123) AT=1020.025n

.meas tran vdout0_124ck2030 FIND v(dout0_124) AT=1020.025n

.meas tran vdout0_125ck2030 FIND v(dout0_125) AT=1020.025n

.meas tran vdout0_126ck2030 FIND v(dout0_126) AT=1020.025n

.meas tran vdout0_127ck2030 FIND v(dout0_127) AT=1020.025n

.meas tran vdout0_128ck2030 FIND v(dout0_128) AT=1020.025n

.meas tran vdout0_129ck2030 FIND v(dout0_129) AT=1020.025n

.meas tran vdout0_130ck2030 FIND v(dout0_130) AT=1020.025n

.meas tran vdout0_131ck2030 FIND v(dout0_131) AT=1020.025n

.meas tran vdout0_132ck2030 FIND v(dout0_132) AT=1020.025n

.meas tran vdout0_133ck2030 FIND v(dout0_133) AT=1020.025n

.meas tran vdout0_134ck2030 FIND v(dout0_134) AT=1020.025n

.meas tran vdout0_135ck2030 FIND v(dout0_135) AT=1020.025n

.meas tran vdout0_136ck2030 FIND v(dout0_136) AT=1020.025n

.meas tran vdout0_137ck2030 FIND v(dout0_137) AT=1020.025n

.meas tran vdout0_138ck2030 FIND v(dout0_138) AT=1020.025n

.meas tran vdout0_139ck2030 FIND v(dout0_139) AT=1020.025n

.meas tran vdout0_140ck2030 FIND v(dout0_140) AT=1020.025n

.meas tran vdout0_141ck2030 FIND v(dout0_141) AT=1020.025n

.meas tran vdout0_142ck2030 FIND v(dout0_142) AT=1020.025n

.meas tran vdout0_143ck2030 FIND v(dout0_143) AT=1020.025n

.meas tran vdout0_144ck2030 FIND v(dout0_144) AT=1020.025n

.meas tran vdout0_145ck2030 FIND v(dout0_145) AT=1020.025n

.meas tran vdout0_146ck2030 FIND v(dout0_146) AT=1020.025n

.meas tran vdout0_147ck2030 FIND v(dout0_147) AT=1020.025n

.meas tran vdout0_148ck2030 FIND v(dout0_148) AT=1020.025n

.meas tran vdout0_149ck2030 FIND v(dout0_149) AT=1020.025n

.meas tran vdout0_150ck2030 FIND v(dout0_150) AT=1020.025n

.meas tran vdout0_151ck2030 FIND v(dout0_151) AT=1020.025n

.meas tran vdout0_152ck2030 FIND v(dout0_152) AT=1020.025n

.meas tran vdout0_153ck2030 FIND v(dout0_153) AT=1020.025n

.meas tran vdout0_154ck2030 FIND v(dout0_154) AT=1020.025n

.meas tran vdout0_155ck2030 FIND v(dout0_155) AT=1020.025n

.meas tran vdout0_156ck2030 FIND v(dout0_156) AT=1020.025n

.meas tran vdout0_157ck2030 FIND v(dout0_157) AT=1020.025n

.meas tran vdout0_158ck2030 FIND v(dout0_158) AT=1020.025n

.meas tran vdout0_159ck2030 FIND v(dout0_159) AT=1020.025n

.meas tran vdout0_160ck2030 FIND v(dout0_160) AT=1020.025n

.meas tran vdout0_161ck2030 FIND v(dout0_161) AT=1020.025n

.meas tran vdout0_162ck2030 FIND v(dout0_162) AT=1020.025n

.meas tran vdout0_163ck2030 FIND v(dout0_163) AT=1020.025n

.meas tran vdout0_164ck2030 FIND v(dout0_164) AT=1020.025n

.meas tran vdout0_165ck2030 FIND v(dout0_165) AT=1020.025n

.meas tran vdout0_166ck2030 FIND v(dout0_166) AT=1020.025n

.meas tran vdout0_167ck2030 FIND v(dout0_167) AT=1020.025n

.meas tran vdout0_168ck2030 FIND v(dout0_168) AT=1020.025n

.meas tran vdout0_169ck2030 FIND v(dout0_169) AT=1020.025n

.meas tran vdout0_170ck2030 FIND v(dout0_170) AT=1020.025n

.meas tran vdout0_171ck2030 FIND v(dout0_171) AT=1020.025n

.meas tran vdout0_172ck2030 FIND v(dout0_172) AT=1020.025n

.meas tran vdout0_173ck2030 FIND v(dout0_173) AT=1020.025n

.meas tran vdout0_174ck2030 FIND v(dout0_174) AT=1020.025n

.meas tran vdout0_175ck2030 FIND v(dout0_175) AT=1020.025n

.meas tran vdout0_176ck2030 FIND v(dout0_176) AT=1020.025n

.meas tran vdout0_177ck2030 FIND v(dout0_177) AT=1020.025n

.meas tran vdout0_178ck2030 FIND v(dout0_178) AT=1020.025n

.meas tran vdout0_179ck2030 FIND v(dout0_179) AT=1020.025n

.meas tran vdout0_180ck2030 FIND v(dout0_180) AT=1020.025n

.meas tran vdout0_181ck2030 FIND v(dout0_181) AT=1020.025n

.meas tran vdout0_182ck2030 FIND v(dout0_182) AT=1020.025n

.meas tran vdout0_183ck2030 FIND v(dout0_183) AT=1020.025n

.meas tran vdout0_184ck2030 FIND v(dout0_184) AT=1020.025n

.meas tran vdout0_185ck2030 FIND v(dout0_185) AT=1020.025n

.meas tran vdout0_186ck2030 FIND v(dout0_186) AT=1020.025n

.meas tran vdout0_187ck2030 FIND v(dout0_187) AT=1020.025n

.meas tran vdout0_188ck2030 FIND v(dout0_188) AT=1020.025n

.meas tran vdout0_189ck2030 FIND v(dout0_189) AT=1020.025n

.meas tran vdout0_190ck2030 FIND v(dout0_190) AT=1020.025n

.meas tran vdout0_191ck2030 FIND v(dout0_191) AT=1020.025n

.meas tran vdout0_192ck2030 FIND v(dout0_192) AT=1020.025n

.meas tran vdout0_193ck2030 FIND v(dout0_193) AT=1020.025n

.meas tran vdout0_194ck2030 FIND v(dout0_194) AT=1020.025n

.meas tran vdout0_195ck2030 FIND v(dout0_195) AT=1020.025n

.meas tran vdout0_196ck2030 FIND v(dout0_196) AT=1020.025n

.meas tran vdout0_197ck2030 FIND v(dout0_197) AT=1020.025n

.meas tran vdout0_198ck2030 FIND v(dout0_198) AT=1020.025n

.meas tran vdout0_199ck2030 FIND v(dout0_199) AT=1020.025n

.meas tran vdout0_200ck2030 FIND v(dout0_200) AT=1020.025n

.meas tran vdout0_201ck2030 FIND v(dout0_201) AT=1020.025n

.meas tran vdout0_202ck2030 FIND v(dout0_202) AT=1020.025n

.meas tran vdout0_203ck2030 FIND v(dout0_203) AT=1020.025n

.meas tran vdout0_204ck2030 FIND v(dout0_204) AT=1020.025n

.meas tran vdout0_205ck2030 FIND v(dout0_205) AT=1020.025n

.meas tran vdout0_206ck2030 FIND v(dout0_206) AT=1020.025n

.meas tran vdout0_207ck2030 FIND v(dout0_207) AT=1020.025n

.meas tran vdout0_208ck2030 FIND v(dout0_208) AT=1020.025n

.meas tran vdout0_209ck2030 FIND v(dout0_209) AT=1020.025n

.meas tran vdout0_210ck2030 FIND v(dout0_210) AT=1020.025n

.meas tran vdout0_211ck2030 FIND v(dout0_211) AT=1020.025n

.meas tran vdout0_212ck2030 FIND v(dout0_212) AT=1020.025n

.meas tran vdout0_213ck2030 FIND v(dout0_213) AT=1020.025n

.meas tran vdout0_214ck2030 FIND v(dout0_214) AT=1020.025n

.meas tran vdout0_215ck2030 FIND v(dout0_215) AT=1020.025n

.meas tran vdout0_216ck2030 FIND v(dout0_216) AT=1020.025n

.meas tran vdout0_217ck2030 FIND v(dout0_217) AT=1020.025n

.meas tran vdout0_218ck2030 FIND v(dout0_218) AT=1020.025n

.meas tran vdout0_219ck2030 FIND v(dout0_219) AT=1020.025n

.meas tran vdout0_220ck2030 FIND v(dout0_220) AT=1020.025n

.meas tran vdout0_221ck2030 FIND v(dout0_221) AT=1020.025n

.meas tran vdout0_222ck2030 FIND v(dout0_222) AT=1020.025n

.meas tran vdout0_223ck2030 FIND v(dout0_223) AT=1020.025n

.meas tran vdout0_224ck2030 FIND v(dout0_224) AT=1020.025n

.meas tran vdout0_225ck2030 FIND v(dout0_225) AT=1020.025n

.meas tran vdout0_226ck2030 FIND v(dout0_226) AT=1020.025n

.meas tran vdout0_227ck2030 FIND v(dout0_227) AT=1020.025n

.meas tran vdout0_228ck2030 FIND v(dout0_228) AT=1020.025n

.meas tran vdout0_229ck2030 FIND v(dout0_229) AT=1020.025n

.meas tran vdout0_230ck2030 FIND v(dout0_230) AT=1020.025n

.meas tran vdout0_231ck2030 FIND v(dout0_231) AT=1020.025n

.meas tran vdout0_232ck2030 FIND v(dout0_232) AT=1020.025n

.meas tran vdout0_233ck2030 FIND v(dout0_233) AT=1020.025n

.meas tran vdout0_234ck2030 FIND v(dout0_234) AT=1020.025n

.meas tran vdout0_235ck2030 FIND v(dout0_235) AT=1020.025n

.meas tran vdout0_236ck2030 FIND v(dout0_236) AT=1020.025n

.meas tran vdout0_237ck2030 FIND v(dout0_237) AT=1020.025n

.meas tran vdout0_238ck2030 FIND v(dout0_238) AT=1020.025n

.meas tran vdout0_239ck2030 FIND v(dout0_239) AT=1020.025n

.meas tran vdout0_240ck2030 FIND v(dout0_240) AT=1020.025n

.meas tran vdout0_241ck2030 FIND v(dout0_241) AT=1020.025n

.meas tran vdout0_242ck2030 FIND v(dout0_242) AT=1020.025n

.meas tran vdout0_243ck2030 FIND v(dout0_243) AT=1020.025n

.meas tran vdout0_244ck2030 FIND v(dout0_244) AT=1020.025n

.meas tran vdout0_245ck2030 FIND v(dout0_245) AT=1020.025n

.meas tran vdout0_246ck2030 FIND v(dout0_246) AT=1020.025n

.meas tran vdout0_247ck2030 FIND v(dout0_247) AT=1020.025n

.meas tran vdout0_248ck2030 FIND v(dout0_248) AT=1020.025n

.meas tran vdout0_249ck2030 FIND v(dout0_249) AT=1020.025n

.meas tran vdout0_250ck2030 FIND v(dout0_250) AT=1020.025n

.meas tran vdout0_251ck2030 FIND v(dout0_251) AT=1020.025n

.meas tran vdout0_252ck2030 FIND v(dout0_252) AT=1020.025n

.meas tran vdout0_253ck2030 FIND v(dout0_253) AT=1020.025n

.meas tran vdout0_254ck2030 FIND v(dout0_254) AT=1020.025n

.meas tran vdout0_255ck2030 FIND v(dout0_255) AT=1020.025n

.meas tran vdout0_0ck2040 FIND v(dout0_0) AT=1025.025n

.meas tran vdout0_1ck2040 FIND v(dout0_1) AT=1025.025n

.meas tran vdout0_2ck2040 FIND v(dout0_2) AT=1025.025n

.meas tran vdout0_3ck2040 FIND v(dout0_3) AT=1025.025n

.meas tran vdout0_4ck2040 FIND v(dout0_4) AT=1025.025n

.meas tran vdout0_5ck2040 FIND v(dout0_5) AT=1025.025n

.meas tran vdout0_6ck2040 FIND v(dout0_6) AT=1025.025n

.meas tran vdout0_7ck2040 FIND v(dout0_7) AT=1025.025n

.meas tran vdout0_8ck2040 FIND v(dout0_8) AT=1025.025n

.meas tran vdout0_9ck2040 FIND v(dout0_9) AT=1025.025n

.meas tran vdout0_10ck2040 FIND v(dout0_10) AT=1025.025n

.meas tran vdout0_11ck2040 FIND v(dout0_11) AT=1025.025n

.meas tran vdout0_12ck2040 FIND v(dout0_12) AT=1025.025n

.meas tran vdout0_13ck2040 FIND v(dout0_13) AT=1025.025n

.meas tran vdout0_14ck2040 FIND v(dout0_14) AT=1025.025n

.meas tran vdout0_15ck2040 FIND v(dout0_15) AT=1025.025n

.meas tran vdout0_16ck2040 FIND v(dout0_16) AT=1025.025n

.meas tran vdout0_17ck2040 FIND v(dout0_17) AT=1025.025n

.meas tran vdout0_18ck2040 FIND v(dout0_18) AT=1025.025n

.meas tran vdout0_19ck2040 FIND v(dout0_19) AT=1025.025n

.meas tran vdout0_20ck2040 FIND v(dout0_20) AT=1025.025n

.meas tran vdout0_21ck2040 FIND v(dout0_21) AT=1025.025n

.meas tran vdout0_22ck2040 FIND v(dout0_22) AT=1025.025n

.meas tran vdout0_23ck2040 FIND v(dout0_23) AT=1025.025n

.meas tran vdout0_24ck2040 FIND v(dout0_24) AT=1025.025n

.meas tran vdout0_25ck2040 FIND v(dout0_25) AT=1025.025n

.meas tran vdout0_26ck2040 FIND v(dout0_26) AT=1025.025n

.meas tran vdout0_27ck2040 FIND v(dout0_27) AT=1025.025n

.meas tran vdout0_28ck2040 FIND v(dout0_28) AT=1025.025n

.meas tran vdout0_29ck2040 FIND v(dout0_29) AT=1025.025n

.meas tran vdout0_30ck2040 FIND v(dout0_30) AT=1025.025n

.meas tran vdout0_31ck2040 FIND v(dout0_31) AT=1025.025n

.meas tran vdout0_32ck2040 FIND v(dout0_32) AT=1025.025n

.meas tran vdout0_33ck2040 FIND v(dout0_33) AT=1025.025n

.meas tran vdout0_34ck2040 FIND v(dout0_34) AT=1025.025n

.meas tran vdout0_35ck2040 FIND v(dout0_35) AT=1025.025n

.meas tran vdout0_36ck2040 FIND v(dout0_36) AT=1025.025n

.meas tran vdout0_37ck2040 FIND v(dout0_37) AT=1025.025n

.meas tran vdout0_38ck2040 FIND v(dout0_38) AT=1025.025n

.meas tran vdout0_39ck2040 FIND v(dout0_39) AT=1025.025n

.meas tran vdout0_40ck2040 FIND v(dout0_40) AT=1025.025n

.meas tran vdout0_41ck2040 FIND v(dout0_41) AT=1025.025n

.meas tran vdout0_42ck2040 FIND v(dout0_42) AT=1025.025n

.meas tran vdout0_43ck2040 FIND v(dout0_43) AT=1025.025n

.meas tran vdout0_44ck2040 FIND v(dout0_44) AT=1025.025n

.meas tran vdout0_45ck2040 FIND v(dout0_45) AT=1025.025n

.meas tran vdout0_46ck2040 FIND v(dout0_46) AT=1025.025n

.meas tran vdout0_47ck2040 FIND v(dout0_47) AT=1025.025n

.meas tran vdout0_48ck2040 FIND v(dout0_48) AT=1025.025n

.meas tran vdout0_49ck2040 FIND v(dout0_49) AT=1025.025n

.meas tran vdout0_50ck2040 FIND v(dout0_50) AT=1025.025n

.meas tran vdout0_51ck2040 FIND v(dout0_51) AT=1025.025n

.meas tran vdout0_52ck2040 FIND v(dout0_52) AT=1025.025n

.meas tran vdout0_53ck2040 FIND v(dout0_53) AT=1025.025n

.meas tran vdout0_54ck2040 FIND v(dout0_54) AT=1025.025n

.meas tran vdout0_55ck2040 FIND v(dout0_55) AT=1025.025n

.meas tran vdout0_56ck2040 FIND v(dout0_56) AT=1025.025n

.meas tran vdout0_57ck2040 FIND v(dout0_57) AT=1025.025n

.meas tran vdout0_58ck2040 FIND v(dout0_58) AT=1025.025n

.meas tran vdout0_59ck2040 FIND v(dout0_59) AT=1025.025n

.meas tran vdout0_60ck2040 FIND v(dout0_60) AT=1025.025n

.meas tran vdout0_61ck2040 FIND v(dout0_61) AT=1025.025n

.meas tran vdout0_62ck2040 FIND v(dout0_62) AT=1025.025n

.meas tran vdout0_63ck2040 FIND v(dout0_63) AT=1025.025n

.meas tran vdout0_64ck2040 FIND v(dout0_64) AT=1025.025n

.meas tran vdout0_65ck2040 FIND v(dout0_65) AT=1025.025n

.meas tran vdout0_66ck2040 FIND v(dout0_66) AT=1025.025n

.meas tran vdout0_67ck2040 FIND v(dout0_67) AT=1025.025n

.meas tran vdout0_68ck2040 FIND v(dout0_68) AT=1025.025n

.meas tran vdout0_69ck2040 FIND v(dout0_69) AT=1025.025n

.meas tran vdout0_70ck2040 FIND v(dout0_70) AT=1025.025n

.meas tran vdout0_71ck2040 FIND v(dout0_71) AT=1025.025n

.meas tran vdout0_72ck2040 FIND v(dout0_72) AT=1025.025n

.meas tran vdout0_73ck2040 FIND v(dout0_73) AT=1025.025n

.meas tran vdout0_74ck2040 FIND v(dout0_74) AT=1025.025n

.meas tran vdout0_75ck2040 FIND v(dout0_75) AT=1025.025n

.meas tran vdout0_76ck2040 FIND v(dout0_76) AT=1025.025n

.meas tran vdout0_77ck2040 FIND v(dout0_77) AT=1025.025n

.meas tran vdout0_78ck2040 FIND v(dout0_78) AT=1025.025n

.meas tran vdout0_79ck2040 FIND v(dout0_79) AT=1025.025n

.meas tran vdout0_80ck2040 FIND v(dout0_80) AT=1025.025n

.meas tran vdout0_81ck2040 FIND v(dout0_81) AT=1025.025n

.meas tran vdout0_82ck2040 FIND v(dout0_82) AT=1025.025n

.meas tran vdout0_83ck2040 FIND v(dout0_83) AT=1025.025n

.meas tran vdout0_84ck2040 FIND v(dout0_84) AT=1025.025n

.meas tran vdout0_85ck2040 FIND v(dout0_85) AT=1025.025n

.meas tran vdout0_86ck2040 FIND v(dout0_86) AT=1025.025n

.meas tran vdout0_87ck2040 FIND v(dout0_87) AT=1025.025n

.meas tran vdout0_88ck2040 FIND v(dout0_88) AT=1025.025n

.meas tran vdout0_89ck2040 FIND v(dout0_89) AT=1025.025n

.meas tran vdout0_90ck2040 FIND v(dout0_90) AT=1025.025n

.meas tran vdout0_91ck2040 FIND v(dout0_91) AT=1025.025n

.meas tran vdout0_92ck2040 FIND v(dout0_92) AT=1025.025n

.meas tran vdout0_93ck2040 FIND v(dout0_93) AT=1025.025n

.meas tran vdout0_94ck2040 FIND v(dout0_94) AT=1025.025n

.meas tran vdout0_95ck2040 FIND v(dout0_95) AT=1025.025n

.meas tran vdout0_96ck2040 FIND v(dout0_96) AT=1025.025n

.meas tran vdout0_97ck2040 FIND v(dout0_97) AT=1025.025n

.meas tran vdout0_98ck2040 FIND v(dout0_98) AT=1025.025n

.meas tran vdout0_99ck2040 FIND v(dout0_99) AT=1025.025n

.meas tran vdout0_100ck2040 FIND v(dout0_100) AT=1025.025n

.meas tran vdout0_101ck2040 FIND v(dout0_101) AT=1025.025n

.meas tran vdout0_102ck2040 FIND v(dout0_102) AT=1025.025n

.meas tran vdout0_103ck2040 FIND v(dout0_103) AT=1025.025n

.meas tran vdout0_104ck2040 FIND v(dout0_104) AT=1025.025n

.meas tran vdout0_105ck2040 FIND v(dout0_105) AT=1025.025n

.meas tran vdout0_106ck2040 FIND v(dout0_106) AT=1025.025n

.meas tran vdout0_107ck2040 FIND v(dout0_107) AT=1025.025n

.meas tran vdout0_108ck2040 FIND v(dout0_108) AT=1025.025n

.meas tran vdout0_109ck2040 FIND v(dout0_109) AT=1025.025n

.meas tran vdout0_110ck2040 FIND v(dout0_110) AT=1025.025n

.meas tran vdout0_111ck2040 FIND v(dout0_111) AT=1025.025n

.meas tran vdout0_112ck2040 FIND v(dout0_112) AT=1025.025n

.meas tran vdout0_113ck2040 FIND v(dout0_113) AT=1025.025n

.meas tran vdout0_114ck2040 FIND v(dout0_114) AT=1025.025n

.meas tran vdout0_115ck2040 FIND v(dout0_115) AT=1025.025n

.meas tran vdout0_116ck2040 FIND v(dout0_116) AT=1025.025n

.meas tran vdout0_117ck2040 FIND v(dout0_117) AT=1025.025n

.meas tran vdout0_118ck2040 FIND v(dout0_118) AT=1025.025n

.meas tran vdout0_119ck2040 FIND v(dout0_119) AT=1025.025n

.meas tran vdout0_120ck2040 FIND v(dout0_120) AT=1025.025n

.meas tran vdout0_121ck2040 FIND v(dout0_121) AT=1025.025n

.meas tran vdout0_122ck2040 FIND v(dout0_122) AT=1025.025n

.meas tran vdout0_123ck2040 FIND v(dout0_123) AT=1025.025n

.meas tran vdout0_124ck2040 FIND v(dout0_124) AT=1025.025n

.meas tran vdout0_125ck2040 FIND v(dout0_125) AT=1025.025n

.meas tran vdout0_126ck2040 FIND v(dout0_126) AT=1025.025n

.meas tran vdout0_127ck2040 FIND v(dout0_127) AT=1025.025n

.meas tran vdout0_128ck2040 FIND v(dout0_128) AT=1025.025n

.meas tran vdout0_129ck2040 FIND v(dout0_129) AT=1025.025n

.meas tran vdout0_130ck2040 FIND v(dout0_130) AT=1025.025n

.meas tran vdout0_131ck2040 FIND v(dout0_131) AT=1025.025n

.meas tran vdout0_132ck2040 FIND v(dout0_132) AT=1025.025n

.meas tran vdout0_133ck2040 FIND v(dout0_133) AT=1025.025n

.meas tran vdout0_134ck2040 FIND v(dout0_134) AT=1025.025n

.meas tran vdout0_135ck2040 FIND v(dout0_135) AT=1025.025n

.meas tran vdout0_136ck2040 FIND v(dout0_136) AT=1025.025n

.meas tran vdout0_137ck2040 FIND v(dout0_137) AT=1025.025n

.meas tran vdout0_138ck2040 FIND v(dout0_138) AT=1025.025n

.meas tran vdout0_139ck2040 FIND v(dout0_139) AT=1025.025n

.meas tran vdout0_140ck2040 FIND v(dout0_140) AT=1025.025n

.meas tran vdout0_141ck2040 FIND v(dout0_141) AT=1025.025n

.meas tran vdout0_142ck2040 FIND v(dout0_142) AT=1025.025n

.meas tran vdout0_143ck2040 FIND v(dout0_143) AT=1025.025n

.meas tran vdout0_144ck2040 FIND v(dout0_144) AT=1025.025n

.meas tran vdout0_145ck2040 FIND v(dout0_145) AT=1025.025n

.meas tran vdout0_146ck2040 FIND v(dout0_146) AT=1025.025n

.meas tran vdout0_147ck2040 FIND v(dout0_147) AT=1025.025n

.meas tran vdout0_148ck2040 FIND v(dout0_148) AT=1025.025n

.meas tran vdout0_149ck2040 FIND v(dout0_149) AT=1025.025n

.meas tran vdout0_150ck2040 FIND v(dout0_150) AT=1025.025n

.meas tran vdout0_151ck2040 FIND v(dout0_151) AT=1025.025n

.meas tran vdout0_152ck2040 FIND v(dout0_152) AT=1025.025n

.meas tran vdout0_153ck2040 FIND v(dout0_153) AT=1025.025n

.meas tran vdout0_154ck2040 FIND v(dout0_154) AT=1025.025n

.meas tran vdout0_155ck2040 FIND v(dout0_155) AT=1025.025n

.meas tran vdout0_156ck2040 FIND v(dout0_156) AT=1025.025n

.meas tran vdout0_157ck2040 FIND v(dout0_157) AT=1025.025n

.meas tran vdout0_158ck2040 FIND v(dout0_158) AT=1025.025n

.meas tran vdout0_159ck2040 FIND v(dout0_159) AT=1025.025n

.meas tran vdout0_160ck2040 FIND v(dout0_160) AT=1025.025n

.meas tran vdout0_161ck2040 FIND v(dout0_161) AT=1025.025n

.meas tran vdout0_162ck2040 FIND v(dout0_162) AT=1025.025n

.meas tran vdout0_163ck2040 FIND v(dout0_163) AT=1025.025n

.meas tran vdout0_164ck2040 FIND v(dout0_164) AT=1025.025n

.meas tran vdout0_165ck2040 FIND v(dout0_165) AT=1025.025n

.meas tran vdout0_166ck2040 FIND v(dout0_166) AT=1025.025n

.meas tran vdout0_167ck2040 FIND v(dout0_167) AT=1025.025n

.meas tran vdout0_168ck2040 FIND v(dout0_168) AT=1025.025n

.meas tran vdout0_169ck2040 FIND v(dout0_169) AT=1025.025n

.meas tran vdout0_170ck2040 FIND v(dout0_170) AT=1025.025n

.meas tran vdout0_171ck2040 FIND v(dout0_171) AT=1025.025n

.meas tran vdout0_172ck2040 FIND v(dout0_172) AT=1025.025n

.meas tran vdout0_173ck2040 FIND v(dout0_173) AT=1025.025n

.meas tran vdout0_174ck2040 FIND v(dout0_174) AT=1025.025n

.meas tran vdout0_175ck2040 FIND v(dout0_175) AT=1025.025n

.meas tran vdout0_176ck2040 FIND v(dout0_176) AT=1025.025n

.meas tran vdout0_177ck2040 FIND v(dout0_177) AT=1025.025n

.meas tran vdout0_178ck2040 FIND v(dout0_178) AT=1025.025n

.meas tran vdout0_179ck2040 FIND v(dout0_179) AT=1025.025n

.meas tran vdout0_180ck2040 FIND v(dout0_180) AT=1025.025n

.meas tran vdout0_181ck2040 FIND v(dout0_181) AT=1025.025n

.meas tran vdout0_182ck2040 FIND v(dout0_182) AT=1025.025n

.meas tran vdout0_183ck2040 FIND v(dout0_183) AT=1025.025n

.meas tran vdout0_184ck2040 FIND v(dout0_184) AT=1025.025n

.meas tran vdout0_185ck2040 FIND v(dout0_185) AT=1025.025n

.meas tran vdout0_186ck2040 FIND v(dout0_186) AT=1025.025n

.meas tran vdout0_187ck2040 FIND v(dout0_187) AT=1025.025n

.meas tran vdout0_188ck2040 FIND v(dout0_188) AT=1025.025n

.meas tran vdout0_189ck2040 FIND v(dout0_189) AT=1025.025n

.meas tran vdout0_190ck2040 FIND v(dout0_190) AT=1025.025n

.meas tran vdout0_191ck2040 FIND v(dout0_191) AT=1025.025n

.meas tran vdout0_192ck2040 FIND v(dout0_192) AT=1025.025n

.meas tran vdout0_193ck2040 FIND v(dout0_193) AT=1025.025n

.meas tran vdout0_194ck2040 FIND v(dout0_194) AT=1025.025n

.meas tran vdout0_195ck2040 FIND v(dout0_195) AT=1025.025n

.meas tran vdout0_196ck2040 FIND v(dout0_196) AT=1025.025n

.meas tran vdout0_197ck2040 FIND v(dout0_197) AT=1025.025n

.meas tran vdout0_198ck2040 FIND v(dout0_198) AT=1025.025n

.meas tran vdout0_199ck2040 FIND v(dout0_199) AT=1025.025n

.meas tran vdout0_200ck2040 FIND v(dout0_200) AT=1025.025n

.meas tran vdout0_201ck2040 FIND v(dout0_201) AT=1025.025n

.meas tran vdout0_202ck2040 FIND v(dout0_202) AT=1025.025n

.meas tran vdout0_203ck2040 FIND v(dout0_203) AT=1025.025n

.meas tran vdout0_204ck2040 FIND v(dout0_204) AT=1025.025n

.meas tran vdout0_205ck2040 FIND v(dout0_205) AT=1025.025n

.meas tran vdout0_206ck2040 FIND v(dout0_206) AT=1025.025n

.meas tran vdout0_207ck2040 FIND v(dout0_207) AT=1025.025n

.meas tran vdout0_208ck2040 FIND v(dout0_208) AT=1025.025n

.meas tran vdout0_209ck2040 FIND v(dout0_209) AT=1025.025n

.meas tran vdout0_210ck2040 FIND v(dout0_210) AT=1025.025n

.meas tran vdout0_211ck2040 FIND v(dout0_211) AT=1025.025n

.meas tran vdout0_212ck2040 FIND v(dout0_212) AT=1025.025n

.meas tran vdout0_213ck2040 FIND v(dout0_213) AT=1025.025n

.meas tran vdout0_214ck2040 FIND v(dout0_214) AT=1025.025n

.meas tran vdout0_215ck2040 FIND v(dout0_215) AT=1025.025n

.meas tran vdout0_216ck2040 FIND v(dout0_216) AT=1025.025n

.meas tran vdout0_217ck2040 FIND v(dout0_217) AT=1025.025n

.meas tran vdout0_218ck2040 FIND v(dout0_218) AT=1025.025n

.meas tran vdout0_219ck2040 FIND v(dout0_219) AT=1025.025n

.meas tran vdout0_220ck2040 FIND v(dout0_220) AT=1025.025n

.meas tran vdout0_221ck2040 FIND v(dout0_221) AT=1025.025n

.meas tran vdout0_222ck2040 FIND v(dout0_222) AT=1025.025n

.meas tran vdout0_223ck2040 FIND v(dout0_223) AT=1025.025n

.meas tran vdout0_224ck2040 FIND v(dout0_224) AT=1025.025n

.meas tran vdout0_225ck2040 FIND v(dout0_225) AT=1025.025n

.meas tran vdout0_226ck2040 FIND v(dout0_226) AT=1025.025n

.meas tran vdout0_227ck2040 FIND v(dout0_227) AT=1025.025n

.meas tran vdout0_228ck2040 FIND v(dout0_228) AT=1025.025n

.meas tran vdout0_229ck2040 FIND v(dout0_229) AT=1025.025n

.meas tran vdout0_230ck2040 FIND v(dout0_230) AT=1025.025n

.meas tran vdout0_231ck2040 FIND v(dout0_231) AT=1025.025n

.meas tran vdout0_232ck2040 FIND v(dout0_232) AT=1025.025n

.meas tran vdout0_233ck2040 FIND v(dout0_233) AT=1025.025n

.meas tran vdout0_234ck2040 FIND v(dout0_234) AT=1025.025n

.meas tran vdout0_235ck2040 FIND v(dout0_235) AT=1025.025n

.meas tran vdout0_236ck2040 FIND v(dout0_236) AT=1025.025n

.meas tran vdout0_237ck2040 FIND v(dout0_237) AT=1025.025n

.meas tran vdout0_238ck2040 FIND v(dout0_238) AT=1025.025n

.meas tran vdout0_239ck2040 FIND v(dout0_239) AT=1025.025n

.meas tran vdout0_240ck2040 FIND v(dout0_240) AT=1025.025n

.meas tran vdout0_241ck2040 FIND v(dout0_241) AT=1025.025n

.meas tran vdout0_242ck2040 FIND v(dout0_242) AT=1025.025n

.meas tran vdout0_243ck2040 FIND v(dout0_243) AT=1025.025n

.meas tran vdout0_244ck2040 FIND v(dout0_244) AT=1025.025n

.meas tran vdout0_245ck2040 FIND v(dout0_245) AT=1025.025n

.meas tran vdout0_246ck2040 FIND v(dout0_246) AT=1025.025n

.meas tran vdout0_247ck2040 FIND v(dout0_247) AT=1025.025n

.meas tran vdout0_248ck2040 FIND v(dout0_248) AT=1025.025n

.meas tran vdout0_249ck2040 FIND v(dout0_249) AT=1025.025n

.meas tran vdout0_250ck2040 FIND v(dout0_250) AT=1025.025n

.meas tran vdout0_251ck2040 FIND v(dout0_251) AT=1025.025n

.meas tran vdout0_252ck2040 FIND v(dout0_252) AT=1025.025n

.meas tran vdout0_253ck2040 FIND v(dout0_253) AT=1025.025n

.meas tran vdout0_254ck2040 FIND v(dout0_254) AT=1025.025n

.meas tran vdout0_255ck2040 FIND v(dout0_255) AT=1025.025n
